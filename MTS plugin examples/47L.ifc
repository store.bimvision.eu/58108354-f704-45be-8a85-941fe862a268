Properties of the parts of a building model (IFC2X3), part 7 of 22

# IfcDiscreteAccessory: END PLATE (3408)
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x END PLATE | FL12*180 | +19.996 | +20.296 | 4 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pb-67 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | FL12*180 | +21.090 | +21.102 | 4 | 8 | 5.1 | 0.1 | 23.5 | 0.1 | 180 | 12 | 300 | pb-68 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | PLT16*160 | +21.134 | +21.430 | 4 | 8 | 5.9 | 0 | 18.4 | 0.1 | 159.9 | 16 | 295.6 | pb-198 | 0.109171 | 0.109171 | 0.00256 | 0.000756736 | 0.000756736
22 x END PLATE | PLT12*160 | +17.856 | +18.020 | 4 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pb-54 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
22 x END PLATE | PLT12*160 | +17.856 | +18.020 | 4 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pb-54 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
38 x END PLATE | FL12*150 | +21.280 | +21.430 | 4 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pb-56 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
4 x END PLATE | PLT12*160 | +21.263 | +21.430 | 4 | 8 | 2.5 | 0 | 24.3 | 0.1 | 159.9 | 12 | 167.2 | pb-65 | 0.0613568 | 0.0613568 | 0.00192 | 0.000321024 | 0.000321024
6 x END PLATE | FL12*150 | +17.870 | +18.020 | 4 | 99 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pb-56 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
39 x END PLATE | FL12*150 | +17.870 | +18.020 | 4 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pb-56 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
END PLATE | PLT12*160 | +17.853 | +18.020 | 4 | 8 | 2.5 | 0 | 24.3 | 0.1 | 159.9 | 12 | 167.2 | pb-69 | 0.0613568 | 0.0613568 | 0.00192 | 0.000321024 | 0.000321024
4 x END PLATE | FL12*150 | +21.280 | +21.430 | 4 | 99 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pb-56 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
7 x END PLATE | PLT12*160 | +21.106 | +21.118 | 4 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pb-66 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
3 x END PLATE | PLT12*160 | +17.696 | +17.708 | 4 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pb-66 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
5 x END PLATE | PLT12*160 | +17.856 | +18.044 | 4 | 8 | 2.8 | 0 | 24.3 | 0.1 | 159.9 | 12 | 188 | pb-60 | 0.068512 | 0.068512 | 0.00192 | 0.00036096 | 0.00036096
END PLATE | PLT12*160 | +15.346 | +15.358 | 4 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pb-66 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
21 x END PLATE | PLT12*160 | +21.266 | +21.430 | 4 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pb-54 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
5 x END PLATE | PLT12*160 | +21.266 | +21.454 | 4 | 8 | 2.8 | 0 | 24.3 | 0.1 | 159.9 | 12 | 188 | pb-60 | 0.068512 | 0.068512 | 0.00192 | 0.00036096 | 0.00036096
END PLATE | PLT16*188 | +21.266 | +21.454 | 4 | 8 | 4.5 | 0 | 18.6 | 0.1 | 188 | 16 | 190 | pb-214 | 0.083536 | 0.083536 | 0.00304 | 0.00057152 | 0.00057152
END PLATE | PLT12*124 | +21.246 | +21.258 | 4 | 8 | 3.4 | 0 | 24.1 | 0.1 | 124 | 12 | 300 | pb-41 | 0.0845767 | 0.0845767 | 0.001488 | 0.000446404 | 0.000446404
END PLATE | PLT12*160 | +20.337 | +20.637 | 4 | 8 | 4.5 | 0 | 23.8 | 0.1 | 159.9 | 12 | 300 | pb-61 | 0.107041 | 0.107041 | 0.00192 | 0.000576005 | 0.000576005
4 x END PLATE | PLT12*160 | +24.124 | +24.288 | 4 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pb-54 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
2 x END PLATE | PLT12*164 | +21.266 | +21.430 | 4 | 8 | 3.2 | 0 | 24 | 0.1 | 164 | 12 | 210 | pb-58 | 0.077856 | 0.077856 | 0.00252 | 0.00041328 | 0.00041328
2 x END PLATE | FL10*70 | +19.755 | +19.765 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
END PLATE | PLT12*140.4 | +18.050 | +18.062 | 4 | 8 | 2.1 | 0 | 24.6 | 0.1 | 140.4 | 12 | 160 | pb-63 | 0.0521376 | 0.0521376 | 0.00192 | 0.000269568 | 0.000269568
END PLATE | FL12*150 | +19.490 | +19.502 | 4 | 8 | 1.9 | 0 | 24.8 | 0 | 140.4 | 12 | 140.4 | pb-64 | 0.0490896 | 0.0490896 | 0.0018 | 0.00025272 | 0.00025272
4 x END PLATE | PLT12*160 | +19.561 | +19.725 | 4 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pb-54 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
3 x END PLATE | PLT12*140 | +19.534 | +19.725 | 4 | 8 | 2.5 | 0 | 24.4 | 0.1 | 140 | 12 | 191.5 | pb-59 | 0.061576 | 0.061576 | 0.00168 | 0.00032172 | 0.00032172
2 x END PLATE | PLT12*164 | +17.856 | +18.020 | 4 | 8 | 3.2 | 0 | 24 | 0.1 | 164 | 12 | 210 | pb-58 | 0.077856 | 0.077856 | 0.00252 | 0.00041328 | 0.00041328
16 x END PLATE | PLT12*160 | +15.506 | +15.670 | 4 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pb-54 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
2 x END PLATE | FL10*70 | +13.145 | +13.155 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
4 x END PLATE | PLT12*160 | +12.951 | +13.115 | 4 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pb-54 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
4 x END PLATE | PLT12*140 | +12.923 | +13.115 | 4 | 8 | 2.5 | 0 | 24.4 | 0.1 | 140 | 12 | 191.5 | pb-59 | 0.061576 | 0.061576 | 0.00168 | 0.00032172 | 0.00032172
END PLATE | PLT16*160 | +21.160 | +21.430 | 4 | 8 | 5.4 | 0 | 18.4 | 0.1 | 159.9 | 16 | 270 | pb-197 | 0.10016 | 0.10016 | 0.00256 | 0.0006912 | 0.0006912
END PLATE | PLT16*160 | +17.750 | +18.020 | 4 | 8 | 5.4 | 0 | 18.4 | 0.1 | 159.9 | 16 | 270 | pb-197 | 0.10016 | 0.10016 | 0.00256 | 0.0006912 | 0.0006912
END PLATE | PLT12*160 | +17.750 | +18.020 | 4 | 8 | 4.1 | 0 | 23.8 | 0.1 | 159.9 | 12 | 270 | pb-40 | 0.09672 | 0.09672 | 0.00192 | 0.0005184 | 0.0005184
END PLATE | PLT12*124 | +17.836 | +17.848 | 4 | 8 | 3.4 | 0 | 24.1 | 0.1 | 124 | 12 | 300 | pb-41 | 0.0845767 | 0.0845767 | 0.001488 | 0.000446404 | 0.000446404
END PLATE | PLT12*160 | +16.927 | +17.227 | 4 | 8 | 4.5 | 0 | 23.8 | 0.1 | 159.9 | 12 | 300 | pb-61 | 0.107041 | 0.107041 | 0.00192 | 0.000576005 | 0.000576005
END PLATE | PLT16*188 | +17.856 | +18.044 | 4 | 8 | 4.5 | 0 | 18.6 | 0.1 | 188 | 16 | 190 | pb-214 | 0.083536 | 0.083536 | 0.00304 | 0.00057152 | 0.00057152
16 x END PLATE | FL12*180 | +21.266 | +21.454 | 4 | 8 | 3.2 | 0 | 24 | 0.1 | 180 | 12 | 188 | pb-62 | 0.076512 | 0.076512 | 0.00216 | 0.00040608 | 0.00040608
16 x END PLATE | FL12*180 | +17.856 | +18.044 | 4 | 8 | 3.2 | 0 | 24 | 0.1 | 180 | 12 | 188 | pb-62 | 0.076512 | 0.076512 | 0.00216 | 0.00040608 | 0.00040608
END PLATE | PLT20*190 | +15.245 | +15.900 | 4 | 8 | 19.4 | 0 | 14.4 | 0.3 | 190 | 20 | 655.4 | pb-37 | 0.282847 | 0.282847 | 0.0038 | 0.00249033 | 0.00249033
2 x END PLATE | PLT20*190 | +15.350 | +15.900 | 4 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-28 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | FL16*200 | +15.350 | +15.694 | 5 | 8 | 8.5 | 0 | 17.9 | 0.2 | 200 | 16 | 343.6 | pc-228 | 0.154835 | 0.154835 | 0.0032 | 0.00109952 | 0.00109952
2 x END PLATE | FL16*200 | +15.344 | +15.694 | 5 | 8 | 8.8 | 0 | 17.9 | 0.2 | 200 | 16 | 349.6 | pc-234 | 0.157427 | 0.157427 | 0.0032 | 0.00111872 | 0.00111872
END PLATE | FL16*200 | +15.350 | +15.694 | 4 | 8 | 8.5 | 0 | 17.9 | 0.2 | 200 | 16 | 343.6 | pb-211 | 0.154835 | 0.154835 | 0.0032 | 0.00109952 | 0.00109952
2 x END PLATE | FL10*70 | +69.602 | +69.716 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +67.402 | +67.516 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +64.902 | +65.016 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +62.143 | +62.256 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +59.428 | +59.541 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +56.713 | +56.826 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +54.222 | +54.333 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +52.146 | +52.256 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +49.978 | +50.089 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +45.843 | +45.953 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +43.242 | +43.355 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +40.474 | +40.587 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +37.705 | +37.819 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +35.185 | +35.295 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +34.299 | +34.409 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +32.914 | +33.024 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +27.797 | +27.908 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +25.417 | +25.528 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +22.939 | +23.050 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +16.926 | +17.039 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +14.474 | +14.587 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +11.919 | +12.032 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +10.901 | +11.014 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +13.456 | +13.569 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +16.010 | +16.122 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +18.350 | +18.461 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +21.762 | +21.873 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +24.620 | +24.731 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +26.716 | +26.827 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +32.028 | +32.138 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +36.582 | +36.695 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +39.351 | +39.464 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +42.118 | +42.231 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +44.872 | +44.982 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +47.310 | +47.420 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +48.999 | +49.109 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +51.452 | +51.562 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +53.339 | +53.449 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +55.613 | +55.726 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +58.327 | +58.439 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +61.043 | +61.156 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +63.766 | +63.880 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +66.566 | +66.680 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +68.766 | +68.880 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +30.453 | +30.564 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +29.380 | +29.490 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +20.055 | +20.166 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +68.238 | +68.352 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +66.038 | +66.152 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +63.245 | +63.357 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +60.530 | +60.642 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +57.815 | +57.927 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +55.106 | +55.216 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +52.841 | +52.951 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +50.954 | +51.064 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +48.502 | +48.612 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +46.815 | +46.925 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +44.366 | +44.479 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +41.597 | +41.710 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +38.829 | +38.942 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +36.070 | +36.181 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +33.799 | +33.910 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +31.528 | +31.639 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +28.879 | +28.990 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +26.214 | +26.325 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +24.117 | +24.228 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +21.260 | +21.370 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +19.555 | +19.665 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +17.843 | +17.955 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +15.492 | +15.605 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +70.438 | +70.552 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +8.145 | +8.155 | 3 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pa-130 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
4 x END PLATE | PLT12*160 | +7.951 | +8.115 | 3 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pa-48 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
15 x END PLATE | FL16*200 | +5.350 | +5.694 | 3 | 8 | 8.5 | 0 | 17.9 | 0.2 | 200 | 16 | 343.6 | pa-158 | 0.154835 | 0.154835 | 0.0032 | 0.00109952 | 0.00109952
2 x END PLATE | FL10*70 | +10.391 | +10.502 | 3 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pa-130 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +9.417 | +9.528 | 3 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pa-130 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +8.444 | +8.554 | 3 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pa-130 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +12.937 | +13.050 | 4 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pb-74 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +7.946 | +8.056 | 3 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pa-130 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +6.972 | +7.082 | 3 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pa-130 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +5.998 | +6.108 | 3 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pa-130 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +3.014 | +3.128 | 3 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pa-130 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +4.251 | +4.365 | 3 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pa-130 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +5.488 | +5.602 | 3 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pa-130 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +2.488 | +2.602 | 3 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pa-130 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +1.316 | +1.430 | 3 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pa-130 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +0.144 | +0.258 | 3 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pa-130 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
12 x END PLATE | PLT12*160 | +10.236 | +10.248 | 3 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pa-52 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
END PLATE | PLT12*160 | +10.236 | +10.248 | 3 | 8 | 2.9 | 0 | 24.3 | 0.1 | 159.9 | 12 | 192 | pa-53 | 0.069888 | 0.069888 | 0.00192 | 0.00036864 | 0.00036864
45 x END PLATE | PLT12*160 | +10.396 | +10.560 | 3 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pa-48 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
END PLATE | PLT12*160 | +10.396 | +10.560 | 3 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pa-54 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
54 x END PLATE | FL12*150 | +10.410 | +10.560 | 3 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pa-50 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
5 x END PLATE | FL12*150 | +10.410 | +10.560 | 3 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pa-55 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
8 x END PLATE | PLT12*160 | +10.393 | +10.560 | 3 | 8 | 2.5 | 0 | 24.3 | 0.1 | 159.9 | 12 | 167.2 | pa-56 | 0.0613568 | 0.0613568 | 0.00192 | 0.000321024 | 0.000321024
4 x END PLATE | FL12*150 | +10.410 | +10.560 | 3 | 99 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pa-50 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
END PLATE | PLT12*160 | +5.346 | +5.358 | 3 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pa-58 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
2 x END PLATE | PLT12*160 | +5.346 | +5.358 | 3 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pa-52 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
4 x END PLATE | PLT12*140 | +7.923 | +8.115 | 3 | 8 | 2.5 | 0 | 24.4 | 0.1 | 140 | 12 | 191.5 | pa-57 | 0.061576 | 0.061576 | 0.00168 | 0.00032172 | 0.00032172
27 x END PLATE | PLT12*160 | +5.506 | +5.670 | 3 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pa-48 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
34 x END PLATE | FL12*150 | +5.520 | +5.670 | 3 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pa-50 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
END PLATE | PLT12*160 | +5.503 | +5.670 | 3 | 99 | 2.5 | 0 | 24.3 | 0.1 | 159.9 | 12 | 167.2 | pa-56 | 0.0613568 | 0.0613568 | 0.00192 | 0.000321024 | 0.000321024
4 x END PLATE | PLT12*140 | +2.478 | +2.670 | 3 | 8 | 2.5 | 0 | 24.4 | 0.1 | 140 | 12 | 191.5 | pa-57 | 0.061576 | 0.061576 | 0.00168 | 0.00032172 | 0.00032172
2 x END PLATE | PLT12*160 | +2.506 | +2.670 | 3 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pa-48 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
2 x END PLATE | PLT20*190 | +9.994 | +10.584 | 3 | 8 | 17.6 | 0 | 14.4 | 0.3 | 190 | 20 | 589.6 | pa-35 | 0.255232 | 0.255232 | 0.0038 | 0.00224048 | 0.00224048
4 x END PLATE | FL12*150 | +5.520 | +5.670 | 3 | 99 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pa-50 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
3 x END PLATE | PLT12*160 | +5.503 | +5.670 | 3 | 8 | 2.5 | 0 | 24.3 | 0.1 | 159.9 | 12 | 167.2 | pa-56 | 0.0613568 | 0.0613568 | 0.00192 | 0.000321024 | 0.000321024
8 x END PLATE | FL16*200 | +5.350 | +5.694 | 5 | 8 | 8.5 | 0 | 17.9 | 0.2 | 200 | 16 | 343.6 | pc-228 | 0.154835 | 0.154835 | 0.0032 | 0.00109952 | 0.00109952
2 x END PLATE | PLT16*230 | +5.344 | +5.694 | 5 | 8 | 9.5 | 0 | 17.8 | 0.2 | 230 | 16 | 349.6 | pc-223 | 0.169318 | 0.179363 | 0.00368 | 0.00120982 | 0.00128653
2 x END PLATE | PLT20*190 | +5.297 | +5.694 | 5 | 8 | 11.9 | 0 | 14.6 | 0.2 | 190 | 20 | 397.4 | pc-12 | 0.174508 | 0.174508 | 0.0038 | 0.00151012 | 0.00151012
4 x END PLATE | FL12*70 | +68.256 | +68.444 | 8 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pf-40 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +66.056 | +66.244 | 8 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pf-40 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +60.541 | +60.729 | 8 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pf-40 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +57.826 | +58.014 | 8 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pf-40 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +52.846 | +53.034 | 8 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pf-40 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +50.959 | +51.147 | 8 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pf-40 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
2 x END PLATE | FL12*70 | +48.506 | +48.694 | 8 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pf-40 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
2 x END PLATE | FL12*70 | +48.506 | +48.694 | 7 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pe-49 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +46.819 | +47.007 | 7 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pe-49 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +41.612 | +41.800 | 7 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pe-49 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +38.844 | +39.032 | 7 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pe-49 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
2 x END PLATE | FL12*70 | +36.076 | +36.264 | 7 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pe-49 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +33.805 | +33.993 | 6 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pd-24 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +31.534 | +31.722 | 6 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pd-24 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +26.221 | +26.409 | 6 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pd-24 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
2 x END PLATE | FL12*70 | +24.124 | +24.312 | 6 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pd-24 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
2 x END PLATE | FL12*70 | +24.124 | +24.312 | 4 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pb-44 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +19.561 | +19.749 | 4 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pb-44 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +17.856 | +18.044 | 4 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pb-44 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +15.506 | +15.694 | 4 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pb-44 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +12.951 | +13.139 | 4 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pb-44 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
2 x END PLATE | FL12*70 | +10.396 | +10.584 | 4 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pb-44 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
2 x END PLATE | FL12*70 | +10.396 | +10.584 | 3 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pa-44 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +7.951 | +8.139 | 3 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pa-44 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +5.506 | +5.694 | 3 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pa-44 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +2.506 | +2.694 | 3 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pa-44 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL16*200 | +5.344 | +5.694 | 5 | 8 | 8.8 | 0 | 17.9 | 0.2 | 200 | 16 | 349.6 | pc-369 | 0.157427 | 0.157427 | 0.0032 | 0.00111872 | 0.00111872
END PLATE | PLT20*190 | +5.136 | +5.694 | 5 | 8 | 16.7 | 0 | 14.4 | 0.2 | 190 | 20 | 557.6 | pc-48 | 0.241792 | 0.241792 | 0.0038 | 0.00211888 | 0.00211888
END PLATE | PLT20*240 | +5.136 | +5.694 | 5 | 8 | 21 | 0 | 14.4 | 0.3 | 240 | 20 | 557.6 | pc-47 | 0.299552 | 0.299552 | 0.0048 | 0.00267648 | 0.00267648
4 x END PLATE | FL16*200 | +5.297 | +5.694 | 5 | 8 | 9.9 | 0 | 17.8 | 0.2 | 200 | 16 | 397.4 | pc-235 | 0.178076 | 0.178076 | 0.0032 | 0.00127167 | 0.00127167
8 x END PLATE | FL16*200 | +5.344 | +5.694 | 5 | 8 | 8.8 | 0 | 17.9 | 0.2 | 200 | 16 | 349.6 | pc-234 | 0.157427 | 0.157427 | 0.0032 | 0.00111872 | 0.00111872
END PLATE | PLT16*260 | +5.344 | +5.694 | 5 | 8 | 10.2 | 0 | 17.7 | 0.2 | 260 | 16 | 349.6 | pc-215 | 0.181208 | 0.201299 | 0.00416 | 0.00130093 | 0.00145434
2 x END PLATE | FL12*200 | +5.506 | +5.670 | 5 | 99 | 3.1 | 0 | 24.1 | 0.1 | 164 | 12 | 164 | pc-121 | 0.074336 | 0.074336 | 0.0024 | 0.0003936 | 0.0003936
3 x END PLATE | FL16*200 | +5.252 | +5.694 | 5 | 8 | 11.1 | 0 | 17.8 | 0.2 | 200 | 16 | 441.6 | pc-233 | 0.19717 | 0.19717 | 0.0032 | 0.00141311 | 0.00141311
END PLATE | FL16*200 | +5.252 | +5.694 | 5 | 8 | 11.1 | 0 | 17.8 | 0.2 | 200 | 16 | 441.6 | pc-382 | 0.19717 | 0.19717 | 0.0032 | 0.00141311 | 0.00141311
END PLATE | PLT16*270 | +5.344 | +5.694 | 5 | 8 | 10.5 | 0 | 17.7 | 0.2 | 270 | 16 | 349.6 | pc-216 | 0.18518 | 0.208611 | 0.00432 | 0.00133129 | 0.00151027
8 x END PLATE | PLT12*144 | +2.576 | +2.720 | 5 | 8 | 2.2 | 0 | 24.6 | 0.1 | 144 | 12 | 160 | pc-122 | 0.053376 | 0.053376 | 0.00192 | 0.00027648 | 0.00027648
10 x END PLATE | PLT12*160 | +2.556 | +2.720 | 5 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pc-114 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
END PLATE | PLT16*160 | +2.556 | +2.720 | 5 | 8 | 3.3 | 0 | 19.1 | 0.1 | 159.9 | 16 | 164 | pc-268 | 0.062848 | 0.062848 | 0.00256 | 0.00041984 | 0.00041984
END PLATE | PLT12*78 | +3.141 | +3.219 | 5 | 8 | 1.1 | 0 | 26.2 | 0 | 78 | 12 | 148 | pc-101 | 0.028512 | 0.028512 | 0.001776 | 0.000138528 | 0.000138528
END PLATE | PLT20*290 | +4.997 | +5.357 | 3 | 8 | 16.4 | 0 | 14.4 | 0.2 | 290 | 20 | 360.2 | pa-30 | 0.234924 | 0.234924 | 0.0058 | 0.00208916 | 0.00208916
END PLATE | PLT20*230 | +4.995 | +5.338 | 5 | 8 | 12.4 | 0 | 14.6 | 0.2 | 230 | 20 | 343.6 | pc-60 | 0.181 | 0.181 | 0.0046 | 0.00158056 | 0.00158056
END PLATE | PLT20*290 | +6.902 | +7.242 | 3 | 8 | 15.5 | 0 | 14.4 | 0.2 | 290 | 20 | 339.6 | pa-29 | 0.222152 | 0.222152 | 0.0058 | 0.00196968 | 0.00196968
END PLATE | PLT20*230 | +6.900 | +7.244 | 5 | 8 | 12.4 | 0 | 14.6 | 0.2 | 230 | 20 | 343.6 | pc-60 | 0.181 | 0.181 | 0.0046 | 0.00158056 | 0.00158056
END PLATE | PLT20*290 | +8.852 | +9.192 | 3 | 8 | 15.5 | 0 | 14.4 | 0.2 | 290 | 20 | 339.6 | pa-29 | 0.222152 | 0.222152 | 0.0058 | 0.00196968 | 0.00196968
END PLATE | PLT20*230 | +8.850 | +9.194 | 5 | 8 | 12.4 | 0 | 14.6 | 0.2 | 230 | 20 | 343.6 | pc-60 | 0.181 | 0.181 | 0.0046 | 0.00158056 | 0.00158056
2 x END PLATE | FL12*110 | +10.590 | +10.602 | 5 | 8 | 3.6 | 0 | 24.3 | 0.1 | 110 | 12 | 349.4 | pc-100 | 0.0879027 | 0.0879027 | 0.00132 | 0.000461257 | 0.000461257
2 x END PLATE | FL12*180 | +3.572 | +3.872 | 3 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pa-59 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | FL12*180 | +5.330 | +5.342 | 3 | 8 | 5.1 | 0.1 | 23.5 | 0.1 | 180 | 12 | 300 | pa-60 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
END PLATE | PLT12*91 | +11.043 | +11.343 | 5 | 8 | 2.6 | 0 | 24.9 | 0.1 | 91 | 12 | 300 | pc-99 | 0.0639846 | 0.0639846 | 0.001092 | 0.000327603 | 0.000327603
END PLATE | PLT12*82 | +12.286 | +12.298 | 5 | 8 | 2.3 | 0 | 25.3 | 0.1 | 82 | 12 | 300 | pc-98 | 0.0583685 | 0.0583685 | 0.000984 | 0.000295203 | 0.000295203
END PLATE | FL16*200 | +12.306 | +12.494 | 5 | 8 | 4.6 | 0 | 18.6 | 0.1 | 188 | 16 | 188 | pc-267 | 0.087616 | 0.087616 | 0.0032 | 0.0006016 | 0.0006016
END PLATE | FL16*200 | +12.170 | +12.494 | 5 | 8 | 8.1 | 0 | 17.9 | 0.1 | 200 | 16 | 324 | pc-380 | 0.146381 | 0.146381 | 0.0032 | 0.0010369 | 0.0010369
31 x END PLATE | FL16*200 | +12.150 | +12.494 | 5 | 8 | 8.5 | 0 | 17.9 | 0.2 | 200 | 16 | 343.6 | pc-370 | 0.154835 | 0.154835 | 0.0032 | 0.00109952 | 0.00109952
2 x END PLATE | FL12*180 | +15.922 | +16.222 | 4 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pb-67 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | FL12*180 | +17.680 | +17.692 | 4 | 8 | 5.1 | 0.1 | 23.5 | 0.1 | 180 | 12 | 300 | pb-68 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
4 x END PLATE | FL12*70 | +2.506 | +2.694 | 5 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pc-97 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
2 x END PLATE | FL12*70 | +12.306 | +12.494 | 5 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pc-96 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +9.906 | +10.094 | 5 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pc-96 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +7.706 | +7.894 | 5 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pc-96 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
4 x END PLATE | FL12*70 | +5.506 | +5.694 | 5 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pc-97 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
2 x END PLATE | FL16*200 | +5.150 | +5.694 | 5 | 8 | 13.7 | 0 | 17.7 | 0.2 | 200 | 16 | 543.6 | pc-232 | 0.241235 | 0.241235 | 0.0032 | 0.00173952 | 0.00173952
2 x END PLATE | FL16*200 | +5.150 | +5.494 | 5 | 8 | 8.5 | 0 | 17.9 | 0.2 | 200 | 16 | 343.6 | pc-231 | 0.154835 | 0.154835 | 0.0032 | 0.00109952 | 0.00109952
6 x END PLATE | FL16*200 | +10.240 | +10.584 | 5 | 8 | 8.5 | 0 | 17.9 | 0.2 | 200 | 16 | 343.6 | pc-370 | 0.154835 | 0.154835 | 0.0032 | 0.00109952 | 0.00109952
2 x END PLATE | FL16*200 | +10.240 | +10.584 | 3 | 8 | 8.5 | 0 | 17.9 | 0.2 | 200 | 16 | 343.6 | pa-158 | 0.154835 | 0.154835 | 0.0032 | 0.00109952 | 0.00109952
3 x END PLATE | PLT16*170 | +10.591 | +10.607 | 5 | 8 | 3.6 | 0 | 18.9 | 0.1 | 169.9 | 16 | 170 | pc-266 | 0.06868 | 0.06868 | 0.00272 | 0.0004624 | 0.0004624
3 x END PLATE | PLT16*170 | +10.217 | +10.233 | 5 | 8 | 3.6 | 0 | 18.9 | 0.1 | 169.9 | 16 | 170 | pc-266 | 0.06868 | 0.06868 | 0.00272 | 0.0004624 | 0.0004624
END PLATE | PLT16*170 | +10.827 | +10.843 | 3 | 8 | 3.6 | 0 | 18.9 | 0.1 | 169.9 | 16 | 170 | pa-156 | 0.06868 | 0.06868 | 0.00272 | 0.0004624 | 0.0004624
END PLATE | PLT16*170 | +10.591 | +10.607 | 3 | 8 | 3.6 | 0 | 18.9 | 0.1 | 169.9 | 16 | 170 | pa-156 | 0.06868 | 0.06868 | 0.00272 | 0.0004624 | 0.0004624
END PLATE | PLT16*170 | +10.217 | +10.233 | 3 | 8 | 10.6 | 0.1 | 17.9 | 0.2 | 169.9 | 16 | 500 | pa-193 | 0.19144 | 0.19144 | 0.008 | 0.00136 | 0.00136
END PLATE | PLT16*170 | +9.201 | +9.217 | 3 | 8 | 3.6 | 0 | 18.9 | 0.1 | 169.9 | 16 | 170 | pa-156 | 0.06868 | 0.06868 | 0.00272 | 0.0004624 | 0.0004624
END PLATE | PLT16*170 | +8.827 | +8.843 | 5 | 8 | 3.6 | 0 | 18.9 | 0.1 | 169.9 | 16 | 170 | pc-266 | 0.06868 | 0.06868 | 0.00272 | 0.0004624 | 0.0004624
END PLATE | PLT16*170 | +8.201 | +8.217 | 5 | 8 | 3.6 | 0 | 18.9 | 0.1 | 169.9 | 16 | 170 | pc-266 | 0.06868 | 0.06868 | 0.00272 | 0.0004624 | 0.0004624
2 x END PLATE | PLT20*190 | +7.494 | +8.044 | 3 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pa-31 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
8 x END PLATE | FL16*200 | +12.150 | +12.494 | 5 | 8 | 8.5 | 0 | 17.9 | 0.2 | 200 | 16 | 343.6 | pc-229 | 0.154835 | 0.154835 | 0.0032 | 0.00109952 | 0.00109952
2 x END PLATE | FL16*200 | +12.144 | +12.494 | 5 | 8 | 8.8 | 0 | 17.9 | 0.2 | 200 | 16 | 349.6 | pc-230 | 0.157427 | 0.157427 | 0.0032 | 0.00111872 | 0.00111872
6 x END PLATE | PLT16*160 | +3.056 | +3.244 | 5 | 8 | 3.8 | 0 | 18.9 | 0.1 | 159.9 | 16 | 188 | pc-262 | 0.071296 | 0.071296 | 0.00256 | 0.00048128 | 0.00048128
4 x END PLATE | PLT16*160 | +2.556 | +2.744 | 5 | 8 | 3.8 | 0 | 18.9 | 0.1 | 159.9 | 16 | 188 | pc-262 | 0.071296 | 0.071296 | 0.00256 | 0.00048128 | 0.00048128
14 x END PLATE | PLT12*140 | +8.410 | +8.574 | 5 | 8 | 2.2 | 0 | 24.6 | 0.1 | 140 | 12 | 164 | pc-108 | 0.053216 | 0.053216 | 0.00168 | 0.00027552 | 0.00027552
4 x END PLATE | PLT16*170 | +8.826 | +8.842 | 5 | 8 | 3.6 | 0 | 18.9 | 0.1 | 169.9 | 16 | 170 | pc-265 | 0.06868 | 0.06868 | 0.00272 | 0.0004624 | 0.0004624
4 x END PLATE | FL20*180 | +21.110 | +21.454 | 4 | 99 | 9.7 | 0 | 14.8 | 0.1 | 180 | 20 | 344 | pb-21 | 0.1448 | 0.1448 | 0.0036 | 0.0012384 | 0.0012384
3 x END PLATE | PLT20*190 | +21.110 | +21.454 | 4 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-18 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT12*160 | +21.266 | +21.430 | 4 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pb-54 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
END PLATE | PLT12*160 | +21.160 | +21.430 | 4 | 8 | 4.1 | 0 | 23.8 | 0.1 | 159.9 | 12 | 270 | pb-40 | 0.09672 | 0.09672 | 0.00192 | 0.0005184 | 0.0005184
END PLATE | PLT16*330 | +12.150 | +12.494 | 5 | 8 | 14.1 | 0 | 17.5 | 0.2 | 330 | 16 | 343.6 | pc-377 | 0.248331 | 0.248331 | 0.00528 | 0.00181421 | 0.00181421
2 x END PLATE | FL16*200 | +5.344 | +5.694 | 5 | 8 | 8.8 | 0 | 17.9 | 0.2 | 200 | 16 | 349.6 | pc-369 | 0.157439 | 0.157439 | 0.0032 | 0.00111881 | 0.00111881
END PLATE | FL16*200 | +5.354 | +5.694 | 5 | 8 | 8.5 | 0 | 17.9 | 0.2 | 200 | 16 | 339.6 | pc-376 | 0.153107 | 0.153107 | 0.0032 | 0.00108672 | 0.00108672
12 x END PLATE | FL16*200 | +2.400 | +2.744 | 5 | 8 | 8.5 | 0 | 17.9 | 0.2 | 200 | 16 | 343.6 | pc-370 | 0.154835 | 0.154835 | 0.0032 | 0.00109952 | 0.00109952
END PLATE | PLT20*290 | +10.852 | +11.192 | 3 | 8 | 15.5 | 0 | 14.4 | 0.2 | 290 | 20 | 339.6 | pa-29 | 0.222152 | 0.222152 | 0.0058 | 0.00196968 | 0.00196968
END PLATE | PLT20*230 | +10.850 | +11.194 | 5 | 8 | 12.4 | 0 | 14.6 | 0.2 | 230 | 20 | 343.6 | pc-60 | 0.181 | 0.181 | 0.0046 | 0.00158056 | 0.00158056
END PLATE | PLT12*164 | +15.506 | +15.670 | 5 | 99 | 2.7 | 0 | 24.3 | 0.1 | 164 | 12 | 172 | pc-118 | 0.06448 | 0.06448 | 0.002064 | 0.000338496 | 0.000338496
END PLATE | PLT12*164 | +15.506 | +15.670 | 5 | 99 | 2.5 | 0 | 24.3 | 0.1 | 164 | 12 | 165 | pc-119 | 0.062016 | 0.062016 | 0.00198 | 0.00032472 | 0.00032472
END PLATE | PLT20*225 | +10.240 | +10.584 | 5 | 8 | 11.3 | 0 | 14.6 | 0.2 | 225 | 20 | 343.6 | pc-5 | 0.16623 | 0.177364 | 0.0045 | 0.00144694 | 0.0015462
END PLATE | FL16*200 | +18.052 | +18.068 | 4 | 8 | 6.1 | 0 | 18.1 | 0.1 | 200 | 16 | 242.2 | pb-213 | 0.11103 | 0.11103 | 0.0032 | 0.00077504 | 0.00077504
END PLATE | FL16*200 | +21.086 | +21.102 | 4 | 8 | 12.1 | 0.1 | 17.7 | 0.2 | 200 | 16 | 482.7 | pb-210 | 0.214926 | 0.214926 | 0.0032 | 0.00154464 | 0.00154464
END PLATE | FL16*200 | +21.462 | +21.478 | 4 | 8 | 6.1 | 0 | 18.1 | 0.1 | 200 | 16 | 242.2 | pb-213 | 0.11103 | 0.11103 | 0.0032 | 0.00077504 | 0.00077504
END PLATE | FL16*200 | +23.944 | +23.960 | 4 | 8 | 10.9 | 0.1 | 17.8 | 0.2 | 200 | 16 | 432.7 | pb-209 | 0.193326 | 0.193326 | 0.0032 | 0.00138464 | 0.00138464
5 x END PLATE | PLT20*190 | +17.700 | +18.044 | 4 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-15 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +17.700 | +18.250 | 4 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-13 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +15.084 | +15.694 | 4 | 99 | 18.1 | 0 | 14.4 | 0.3 | 190 | 20 | 609.6 | pb-36 | 0.263632 | 0.263632 | 0.0038 | 0.00231648 | 0.00231648
2 x END PLATE | PLT20*190 | +15.350 | +15.900 | 4 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-33 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
2 x END PLATE | PLT20*190 | +15.144 | +15.694 | 4 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-34 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +10.240 | +10.840 | 3 | 99 | 18 | 0 | 14.4 | 0.3 | 190 | 20 | 599.6 | pa-39 | 0.259432 | 0.259432 | 0.0038 | 0.00227848 | 0.00227848
END PLATE | PLT20*190 | +9.964 | +10.584 | 3 | 99 | 18.5 | 0 | 14.4 | 0.3 | 190 | 20 | 619.6 | pa-38 | 0.267832 | 0.267832 | 0.0038 | 0.00235448 | 0.00235448
3 x END PLATE | PLT20*190 | +10.240 | +10.584 | 3 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pa-26 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +9.964 | +10.790 | 3 | 99 | 24.6 | 0 | 14.4 | 0.3 | 190 | 20 | 825.6 | pa-25 | 0.354352 | 0.354352 | 0.0038 | 0.00313728 | 0.00313728
END PLATE | PLT20*190 | +28.524 | +29.280 | 6 | 99 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pd-10 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
2 x END PLATE | PLT20*190 | +21.110 | +21.454 | 4 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-18 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +21.110 | +21.630 | 4 | 8 | 15.5 | 0 | 14.6 | 0.2 | 190 | 20 | 519.6 | pb-31 | 0.225832 | 0.225832 | 0.0038 | 0.00197448 | 0.00197448
3 x END PLATE | PLT20*190 | +23.968 | +24.518 | 4 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-27 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
2 x END PLATE | PLT20*190 | +23.968 | +24.312 | 4 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-18 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +9.974 | +10.850 | 3 | 8 | 26.1 | 0 | 14.4 | 0.3 | 190 | 20 | 875.6 | pa-24 | 0.375352 | 0.375352 | 0.0038 | 0.00332728 | 0.00332728
END PLATE | PLT20*190 | +15.350 | +16.000 | 4 | 8 | 19.4 | 0 | 14.4 | 0.3 | 190 | 20 | 649.6 | pb-35 | 0.280432 | 0.280432 | 0.0038 | 0.00246848 | 0.00246848
3 x END PLATE | PLT20*190 | +15.350 | +15.694 | 4 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-17 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +17.494 | +18.400 | 4 | 8 | 26.9 | 0 | 14.4 | 0.3 | 190 | 20 | 905.6 | pb-11 | 0.387952 | 0.387952 | 0.0038 | 0.00344128 | 0.00344128
END PLATE | PLT20*190 | +9.984 | +10.840 | 3 | 8 | 25.5 | 0 | 14.4 | 0.3 | 190 | 20 | 855.6 | pa-23 | 0.366952 | 0.366952 | 0.0038 | 0.00325128 | 0.00325128
END PLATE | PLT20*190 | +5.350 | +5.950 | 3 | 99 | 18 | 0 | 14.4 | 0.3 | 190 | 20 | 599.6 | pa-13 | 0.259432 | 0.259432 | 0.0038 | 0.00227848 | 0.00227848
5 x END PLATE | PLT20*190 | +5.350 | +5.694 | 3 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pa-11 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +5.074 | +5.960 | 3 | 99 | 26.4 | 0 | 14.4 | 0.3 | 190 | 20 | 885.6 | pa-8 | 0.379552 | 0.379552 | 0.0038 | 0.00336528 | 0.00336528
END PLATE | PLT20*190 | +5.350 | +5.694 | 3 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pa-10 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
5 x END PLATE | PLT20*190 | +5.350 | +5.694 | 3 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pa-26 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +5.084 | +5.694 | 3 | 8 | 18.1 | 0 | 14.4 | 0.3 | 190 | 20 | 609.6 | pa-37 | 0.263632 | 0.263632 | 0.0038 | 0.00231648 | 0.00231648
END PLATE | PLT16*260 | +5.344 | +5.694 | 5 | 8 | 10.2 | 0 | 17.7 | 0.2 | 260 | 16 | 349.6 | pc-215 | 0.181209 | 0.201299 | 0.00416 | 0.00130093 | 0.00145434
END PLATE | PLT16*240 | +5.344 | +5.694 | 3 | 8 | 9.7 | 0 | 17.8 | 0.2 | 240 | 16 | 349.6 | pa-194 | 0.173291 | 0.186675 | 0.00384 | 0.00124019 | 0.00134246
END PLATE | PLT20*190 | +10.004 | +10.790 | 3 | 99 | 23.5 | 0 | 14.4 | 0.3 | 190 | 20 | 785.6 | pa-19 | 0.337552 | 0.337552 | 0.0038 | 0.00298528 | 0.00298528
END PLATE | PLT20*190 | +10.004 | +10.584 | 3 | 99 | 17.3 | 0 | 14.4 | 0.3 | 190 | 20 | 579.6 | pa-36 | 0.251032 | 0.251032 | 0.0038 | 0.00220248 | 0.00220248
END PLATE | PLT20*190 | +15.350 | +15.694 | 4 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-10 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +17.700 | +18.044 | 4 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-18 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +17.704 | +18.250 | 4 | 99 | 16.3 | 0 | 14.4 | 0.2 | 190 | 20 | 545.6 | pb-30 | 0.236752 | 0.236752 | 0.0038 | 0.00207328 | 0.00207328
END PLATE | PLT20*190 | +21.110 | +21.454 | 4 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-17 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +21.110 | +21.660 | 4 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-28 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | FL16*200 | +5.350 | +5.694 | 3 | 8 | 8.5 | 0 | 17.9 | 0.2 | 200 | 16 | 343.6 | pa-136 | 0.154835 | 0.154835 | 0.0032 | 0.00109952 | 0.00109952
END PLATE | PLT16*240 | +5.344 | +5.694 | 3 | 8 | 9.7 | 0 | 17.8 | 0.2 | 240 | 16 | 349.6 | pa-140 | 0.173292 | 0.186675 | 0.00384 | 0.0012402 | 0.00134246
END PLATE | PLT20*190 | +28.524 | +29.280 | 6 | 99 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pd-9 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
3 x END PLATE | PLT20*190 | +20.904 | +21.454 | 4 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-26 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
2 x END PLATE | PLT20*190 | +23.762 | +24.312 | 4 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-26 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
5 x END PLATE | PLT20*190 | +5.350 | +5.694 | 3 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pa-26 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +17.700 | +18.044 | 4 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-20 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
4 x END PLATE | PLT20*190 | +10.240 | +10.584 | 3 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pa-26 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
3 x END PLATE | PLT20*190 | +10.240 | +10.584 | 3 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pa-27 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
4 x END PLATE | FL12*150 | +3.070 | +3.220 | 5 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pc-115 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
3 x END PLATE | PLT20*190 | +15.350 | +15.900 | 4 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-33 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +5.114 | +5.920 | 3 | 99 | 23.9 | 0 | 14.4 | 0.3 | 190 | 20 | 805.6 | pa-22 | 0.345952 | 0.345952 | 0.0038 | 0.00306128 | 0.00306128
END PLATE | PLT20*190 | +5.350 | +5.694 | 3 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pa-27 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +5.124 | +5.900 | 3 | 8 | 23.1 | 0 | 14.4 | 0.3 | 190 | 20 | 775.6 | pa-21 | 0.333352 | 0.333352 | 0.0038 | 0.00294728 | 0.00294728
END PLATE | PLT20*190 | +10.004 | +10.810 | 3 | 8 | 23.9 | 0 | 14.4 | 0.3 | 190 | 20 | 805.6 | pa-20 | 0.345952 | 0.345952 | 0.0038 | 0.00306128 | 0.00306128
END PLATE | PLT20*190 | +10.004 | +10.584 | 3 | 8 | 17.3 | 0 | 14.4 | 0.3 | 190 | 20 | 579.6 | pa-36 | 0.251032 | 0.251032 | 0.0038 | 0.00220248 | 0.00220248
END PLATE | PLT20*190 | +10.004 | +10.790 | 3 | 8 | 23.5 | 0 | 14.4 | 0.3 | 190 | 20 | 785.6 | pa-19 | 0.337552 | 0.337552 | 0.0038 | 0.00298528 | 0.00298528
END PLATE | PLT20*190 | +10.014 | +10.584 | 3 | 8 | 17 | 0 | 14.4 | 0.2 | 190 | 20 | 569.6 | pa-32 | 0.246832 | 0.246832 | 0.0038 | 0.00216448 | 0.00216448
END PLATE | PLT20*190 | +15.350 | +15.900 | 4 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-27 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
2 x END PLATE | PLT20*190 | +15.144 | +15.694 | 4 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-25 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +15.124 | +15.694 | 4 | 8 | 17 | 0 | 14.4 | 0.2 | 190 | 20 | 569.6 | pb-29 | 0.246832 | 0.246832 | 0.0038 | 0.00216448 | 0.00216448
2 x END PLATE | PLT20*190 | +17.700 | +18.044 | 4 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-16 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +17.494 | +18.250 | 4 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pb-7 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
2 x END PLATE | PLT20*190 | +17.700 | +18.044 | 4 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-18 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +17.494 | +18.044 | 4 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-26 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +21.110 | +21.660 | 4 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-28 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +5.350 | +5.970 | 5 | 8 | 18.5 | 0 | 14.4 | 0.3 | 190 | 20 | 619.6 | pc-30 | 0.267832 | 0.267832 | 0.0038 | 0.00235448 | 0.00235448
END PLATE | FL20*200 | +5.350 | +5.970 | 5 | 8 | 19.4 | 0 | 14.4 | 0.3 | 200 | 20 | 619.6 | pc-46 | 0.280624 | 0.280624 | 0.004 | 0.0024784 | 0.0024784
6 x END PLATE | PLT20*190 | +5.350 | +5.970 | 5 | 8 | 18.5 | 0 | 14.4 | 0.3 | 190 | 20 | 619.6 | pc-28 | 0.267832 | 0.267832 | 0.0038 | 0.00235448 | 0.00235448
END PLATE | PLT20*190 | +5.351 | +5.970 | 5 | 8 | 18.5 | 0 | 14.4 | 0.3 | 190 | 20 | 619.6 | pc-28 | 0.267832 | 0.267832 | 0.0038 | 0.00235448 | 0.00235448
END PLATE | PLT20*190 | +12.144 | +12.494 | 5 | 8 | 10.5 | 0 | 14.8 | 0.2 | 190 | 20 | 349.6 | pc-37 | 0.154432 | 0.154432 | 0.0038 | 0.00132848 | 0.00132848
7 x END PLATE | PLT20*190 | +12.144 | +12.494 | 5 | 8 | 10.5 | 0 | 14.8 | 0.2 | 190 | 20 | 349.6 | pc-2 | 0.154432 | 0.154432 | 0.0038 | 0.00132848 | 0.00132848
END PLATE | PLT20*190 | +5.004 | +6.000 | 3 | 8 | 29.7 | 0 | 14.4 | 0.3 | 190 | 20 | 995.6 | pa-7 | 0.425752 | 0.425752 | 0.0038 | 0.00378328 | 0.00378328
END PLATE | PLT20*190 | +5.350 | +5.694 | 3 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pa-28 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +5.322 | +5.694 | 5 | 8 | 11.1 | 0 | 14.8 | 0.2 | 190 | 20 | 371.6 | pc-59 | 0.163672 | 0.163672 | 0.0038 | 0.00141208 | 0.00141208
END PLATE | PLT20*190 | +15.350 | +15.694 | 5 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-58 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +15.345 | +15.694 | 5 | 8 | 10.5 | 0 | 14.8 | 0.2 | 190 | 20 | 349 | pc-56 | 0.15418 | 0.15418 | 0.0038 | 0.0013262 | 0.0013262
5 x END PLATE | PLT16*190 | +2.400 | +2.744 | 5 | 8 | 8.2 | 0 | 17.9 | 0.1 | 190 | 16 | 343.6 | pc-371 | 0.147643 | 0.147643 | 0.00304 | 0.00104454 | 0.00104454
END PLATE | PLT16*190 | +2.400 | +2.756 | 5 | 8 | 8.5 | 0 | 17.9 | 0.2 | 190 | 16 | 355.6 | pc-372 | 0.152587 | 0.152587 | 0.00304 | 0.00108102 | 0.00108102
END PLATE | PLT20*190 | +9.934 | +10.584 | 3 | 8 | 19.4 | 0 | 14.4 | 0.3 | 190 | 20 | 649.6 | pa-34 | 0.280432 | 0.280432 | 0.0038 | 0.00246848 | 0.00246848
END PLATE | PLT20*190 | +12.150 | +12.494 | 5 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-3 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
2 x END PLATE | PLT12*145 | +17.875 | +18.020 | 4 | 8 | 2.2 | 0 | 24.6 | 0.1 | 145 | 12 | 160 | pb-55 | 0.05372 | 0.05372 | 0.00192 | 0.0002784 | 0.0002784
2 x END PLATE | PLT12*160 | +15.454 | +15.670 | 4 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 215.5 | pb-57 | 0.077972 | 0.077972 | 0.00192 | 0.00041376 | 0.00041376
2 x END PLATE | FL16*300 | +12.170 | +12.470 | 5 | 99 | 5.9 | 0 | 18.4 | 0.1 | 159.9 | 16 | 160 | pc-378 | 0.11072 | 0.11072 | 0.00256 | 0.000768 | 0.000768
4 x END PLATE | PLT20*190 | +23.762 | +24.568 | 4 | 8 | 23.9 | 0 | 14.4 | 0.3 | 190 | 20 | 805.6 | pb-6 | 0.345952 | 0.345952 | 0.0038 | 0.00306128 | 0.00306128
3 x END PLATE | PLT20*190 | +17.700 | +18.044 | 4 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-15 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +15.350 | +16.105 | 5 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 754.6 | pc-8 | 0.324532 | 0.324532 | 0.0038 | 0.00286748 | 0.00286748
END PLATE | PLT20*190 | +15.344 | +15.905 | 5 | 8 | 16.7 | 0 | 14.4 | 0.2 | 190 | 20 | 560.6 | pc-52 | 0.243052 | 0.243052 | 0.0038 | 0.00213028 | 0.00213028
3 x END PLATE | PLT20*190 | +5.344 | +5.694 | 3 | 8 | 10.5 | 0 | 14.8 | 0.2 | 190 | 20 | 349.6 | pa-9 | 0.154432 | 0.154432 | 0.0038 | 0.00132848 | 0.00132848
2 x END PLATE | PLT20*190 | +9.994 | +10.840 | 3 | 8 | 25.2 | 0 | 14.4 | 0.3 | 190 | 20 | 845.6 | pa-18 | 0.362752 | 0.362752 | 0.0038 | 0.00321328 | 0.00321328
END PLATE | PLT20*190 | +5.350 | +5.694 | 3 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pa-10 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +5.134 | +5.900 | 3 | 8 | 22.7 | 0 | 14.4 | 0.3 | 190 | 20 | 765.6 | pa-17 | 0.329152 | 0.329152 | 0.0038 | 0.00290928 | 0.00290928
END PLATE | PLT20*190 | +10.034 | +10.790 | 3 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pa-16 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +17.494 | +18.250 | 4 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pb-3 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +20.904 | +21.660 | 4 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pb-7 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
2 x END PLATE | PLT20*190 | +23.762 | +24.518 | 4 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pb-7 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +15.144 | +15.900 | 4 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pb-8 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +15.350 | +15.694 | 4 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-10 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
2 x END PLATE | PLT16*170 | +19.304 | +19.955 | 4 | 8 | 14 | 0 | 17.8 | 0.2 | 169.9 | 16 | 651.5 | pb-185 | 0.247798 | 0.247798 | 0.00272 | 0.00177208 | 0.00177208
2 x END PLATE | PLT16*170 | +19.510 | +19.749 | 4 | 8 | 5.1 | 0 | 18.4 | 0.1 | 169.9 | 16 | 239.5 | pb-212 | 0.094534 | 0.094534 | 0.00272 | 0.00065144 | 0.00065144
2 x END PLATE | PLT16*170 | +26.170 | +26.409 | 6 | 8 | 5.1 | 0 | 18.4 | 0.1 | 169.9 | 16 | 239.5 | pd-124 | 0.094534 | 0.094534 | 0.00272 | 0.00065144 | 0.00065144
2 x END PLATE | PLT16*170 | +25.964 | +26.615 | 6 | 8 | 14 | 0 | 17.8 | 0.2 | 169.9 | 16 | 651.5 | pd-122 | 0.247798 | 0.247798 | 0.00272 | 0.00177208 | 0.00177208
END PLATE | PLT16*170 | +2.248 | +2.910 | 3 | 8 | 14.1 | 0 | 17.8 | 0.3 | 169.9 | 16 | 661.5 | pa-192 | 0.251518 | 0.251518 | 0.00272 | 0.00179928 | 0.00179928
2 x END PLATE | PLT16*170 | +2.454 | +2.694 | 3 | 8 | 5.1 | 0 | 18.4 | 0.1 | 169.9 | 16 | 239.5 | pa-154 | 0.094534 | 0.094534 | 0.00272 | 0.00065144 | 0.00065144
2 x END PLATE | PLT16*170 | +7.693 | +8.345 | 3 | 8 | 14 | 0 | 17.8 | 0.2 | 169.9 | 16 | 651.5 | pa-191 | 0.247798 | 0.247798 | 0.00272 | 0.00177208 | 0.00177208
2 x END PLATE | PLT16*170 | +7.899 | +8.139 | 3 | 8 | 5.1 | 0 | 18.4 | 0.1 | 169.9 | 16 | 239.5 | pa-154 | 0.094534 | 0.094534 | 0.00272 | 0.00065144 | 0.00065144
2 x END PLATE | PLT16*170 | +12.899 | +13.139 | 4 | 8 | 5.1 | 0 | 18.4 | 0.1 | 169.9 | 16 | 239.5 | pb-212 | 0.094534 | 0.094534 | 0.00272 | 0.00065144 | 0.00065144
2 x END PLATE | PLT16*170 | +12.693 | +13.345 | 4 | 8 | 14 | 0 | 17.8 | 0.2 | 169.9 | 16 | 651.5 | pb-185 | 0.247798 | 0.247798 | 0.00272 | 0.00177208 | 0.00177208
14 x END PLATE | PLT12*160 | +10.396 | +10.560 | 3 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pa-48 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
END PLATE | PLT12*164 | +10.396 | +10.560 | 3 | 8 | 2.6 | 0 | 24.3 | 0.1 | 164 | 12 | 170 | pa-61 | 0.063776 | 0.063776 | 0.00204 | 0.00033456 | 0.00033456
16 x END PLATE | FL12*180 | +10.396 | +10.584 | 3 | 8 | 3.2 | 0 | 24 | 0.1 | 180 | 12 | 188 | pa-47 | 0.076512 | 0.076512 | 0.00216 | 0.00040608 | 0.00040608
END PLATE | PLT20*190 | +23.968 | +24.312 | 4 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-19 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +20.904 | +21.454 | 4 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-25 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +20.904 | +21.660 | 4 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pb-5 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +21.110 | +21.454 | 4 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pb-17 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +17.694 | +18.044 | 4 | 8 | 10.5 | 0 | 14.8 | 0.2 | 190 | 20 | 349.6 | pb-14 | 0.154432 | 0.154432 | 0.0038 | 0.00132848 | 0.00132848
END PLATE | PLT20*190 | +15.244 | +15.694 | 4 | 8 | 13.3 | 0 | 14.6 | 0.2 | 190 | 20 | 449.6 | pb-9 | 0.196432 | 0.196432 | 0.0038 | 0.00170848 | 0.00170848
END PLATE | PLT20*190 | +15.244 | +15.900 | 4 | 8 | 19.6 | 0 | 14.4 | 0.3 | 190 | 20 | 655.6 | pb-32 | 0.282952 | 0.282952 | 0.0038 | 0.00249128 | 0.00249128
END PLATE | PLT20*190 | +15.350 | +15.694 | 5 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-11 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +17.494 | +18.250 | 4 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pb-5 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +15.344 | +15.694 | 5 | 8 | 10.5 | 0 | 14.8 | 0.2 | 190 | 20 | 349.6 | pc-10 | 0.154432 | 0.154432 | 0.0038 | 0.00132848 | 0.00132848
END PLATE | PLT20*190 | +15.144 | +15.900 | 4 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pb-4 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT12*140 | +5.506 | +5.670 | 5 | 8 | 2.2 | 0 | 24.6 | 0.1 | 140 | 12 | 164 | pc-108 | 0.053216 | 0.053216 | 0.00168 | 0.00027552 | 0.00027552
END PLATE | PLT20*190 | +10.240 | +10.840 | 3 | 8 | 18 | 0 | 14.4 | 0.3 | 190 | 20 | 599.6 | pa-33 | 0.259432 | 0.259432 | 0.0038 | 0.00227848 | 0.00227848
END PLATE | PLT20*235 | +10.234 | +10.840 | 3 | 8 | 20.3 | 0 | 14.4 | 0.3 | 235 | 20 | 605.6 | pa-6 | 0.291489 | 0.318255 | 0.0047 | 0.0025873 | 0.00284632
END PLATE | PLT20*190 | +10.234 | +10.584 | 3 | 8 | 10.5 | 0 | 14.8 | 0.2 | 190 | 20 | 349.6 | pa-4 | 0.154432 | 0.154432 | 0.0038 | 0.00132848 | 0.00132848
END PLATE | PLT20*190 | +10.034 | +10.790 | 3 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pa-15 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +5.344 | +5.970 | 5 | 8 | 18.6 | 0 | 14.4 | 0.3 | 190 | 20 | 625.6 | pc-29 | 0.270352 | 0.270352 | 0.0038 | 0.00237728 | 0.00237728
END PLATE | PLT16*159 | +5.506 | +5.665 | 3 | 8 | 3.2 | 0 | 19.1 | 0.1 | 159 | 16 | 160 | pa-155 | 0.061088 | 0.061088 | 0.00256 | 0.00040704 | 0.00040704
END PLATE | PLT20*190 | +5.134 | +5.900 | 3 | 8 | 22.7 | 0 | 14.4 | 0.3 | 190 | 20 | 765.6 | pa-14 | 0.329152 | 0.329152 | 0.0038 | 0.00290928 | 0.00290928
END PLATE | PLT20*190 | +5.350 | +5.940 | 3 | 8 | 17.6 | 0 | 14.4 | 0.3 | 190 | 20 | 589.6 | pa-12 | 0.255232 | 0.255232 | 0.0038 | 0.00224048 | 0.00224048
END PLATE | PLT20*233 | +5.344 | +5.940 | 3 | 8 | 20 | 0 | 14.4 | 0.3 | 233 | 20 | 595.6 | pa-3 | 0.285901 | 0.310694 | 0.00466 | 0.00253584 | 0.0027755
2 x END PLATE | PLT16*190 | +2.400 | +2.744 | 3 | 8 | 8.2 | 0 | 17.9 | 0.1 | 190 | 16 | 343.6 | pa-157 | 0.147643 | 0.147643 | 0.00304 | 0.00104454 | 0.00104454
16 x END PLATE | FL12*180 | +5.506 | +5.694 | 3 | 8 | 3.2 | 0 | 24 | 0.1 | 180 | 12 | 188 | pa-47 | 0.076512 | 0.076512 | 0.00216 | 0.00040608 | 0.00040608
28 x END PLATE | PLT12*160 | +5.506 | +5.670 | 3 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pa-48 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
END PLATE | PLT16*170 | +2.248 | +2.910 | 3 | 8 | 14.1 | 0 | 17.8 | 0.3 | 169.9 | 16 | 661.5 | pa-190 | 0.251518 | 0.251518 | 0.00272 | 0.00179928 | 0.00179928
2 x END PLATE | PLT12*145 | +5.525 | +5.670 | 3 | 8 | 2.2 | 0 | 24.6 | 0.1 | 145 | 12 | 160 | pa-49 | 0.05372 | 0.05372 | 0.00192 | 0.0002784 | 0.0002784
2 x END PLATE | PLT12*164 | +5.506 | +5.670 | 3 | 8 | 2.6 | 0 | 24.3 | 0.1 | 164 | 12 | 170 | pa-51 | 0.063776 | 0.063776 | 0.00204 | 0.00033456 | 0.00033456
16 x END PLATE | PLT16*160 | +2.505 | +2.720 | 5 | 8 | 4.3 | 0 | 18.6 | 0.1 | 159.9 | 16 | 215.5 | pc-264 | 0.080976 | 0.080976 | 0.00256 | 0.00055168 | 0.00055168
