Properties of the parts of a building model (IFC2X3), part 17 of 22

# IfcElementAssembly (4115)
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Steel Assembly | RIGID_FRAME | 71.4 | +31.528 | +31.728 | D-E/2-3 | 471-E-D47 | 272.118
Steel Assembly | RIGID_FRAME | 30.2 | +31.376 | +31.528 | D-E/2-3 | 471-E-D98 | 152.4
Steel Assembly | RIGID_FRAME | 27.1 | +28.728 | +28.880 | B-C/2-3 | 471-E-D101 | 152.4
Steel Assembly | RIGID_FRAME | 93.6 | +28.880 | +29.080 | B-C/2-3 | 471-E-D8 | 159.994
2 x Steel Assembly | RIGID_FRAME | 27.1 | +28.728 | +28.880 | C-D/3-4 | 471-E-D100 | 152.4
5 x Steel Assembly | RIGID_FRAME | 27.2 | +28.572 | +28.724 | C-D/2-3 | 471-E-D103 | 152.4
Steel Assembly | RIGID_FRAME | 34.4 | +28.726 | +29.080 | C-D/2-3 | 471-E-D75 | 450.745
2 x Steel Assembly | RIGID_FRAME | 33.5 | +28.572 | +28.724 | C-D/2-3 | 471-E-D104 | 152.4
Steel Assembly | RIGID_FRAME | 142.9 | +28.726 | +29.080 | C-D/2-3 | 471-E-D50 | 326.494
Steel Assembly | RIGID_FRAME | 235.7 | +48.029 | +49.012 | B-C/3 | 471-F-E24 | 365.74
Steel Assembly | RIGID_FRAME | 53.3 | +28.726 | +29.080 | C-D/2-3 | 471-E-D67 | 327.809
Steel Assembly | RIGID_FRAME | 113.3 | +55.448 | +57.870 | B-C/3 | 471-G-F384 | 250
Steel Assembly | RIGID_FRAME | 53.6 | +28.726 | +29.080 | C-D/2-3 | 471-E-D69 | 318.027
Steel Assembly | RIGID_FRAME | 53.1 | +28.726 | +29.080 | C-D/2-3 | 471-E-D57 | 340.591
Steel Assembly | RIGID_FRAME | 53.2 | +28.726 | +29.080 | C-D/2-3 | 471-E-D70 | 337.894
Steel Assembly | RIGID_FRAME | 192.7 | +66.275 | +70.364 | B-C/3 | 471-G-F389 | 219.1
Steel Assembly | RIGID_FRAME | 129.1 | +63.475 | +65.869 | B-C/3 | 471-G-F387 | 219.1
Steel Assembly | RIGID_FRAME | 229.3 | +58.045 | +63.069 | B-C/3 | 471-G-F385 | 219.1
Steel Assembly | RIGID_FRAME | 126.5 | +55.330 | +57.639 | B-C/3 | 471-G-F383 | 219.1
Steel Assembly | RIGID_FRAME | 112.2 | +53.065 | +54.924 | B-C/3 | 471-G-F381 | 219.1
4 x Steel Assembly | RIGID_FRAME | 16.3 | +28.893 | +28.973 | C-D/2-3 | 471-E-D116 | 80
Steel Assembly | RIGID_FRAME | 130.2 | +28.880 | +29.080 | C-D/2-3 | 471-E-D55 | 326.673
Steel Assembly | RIGID_FRAME | 27.9 | +28.880 | +29.080 | C-D/2-3 | 471-E-D63 | 451.115
Steel Assembly | RIGID_FRAME | 175.2 | +28.880 | +29.080 | C-D/2-3 | 471-E-D51 | 450.745
Steel Assembly | RIGID_FRAME | 186.3 | +48.725 | +52.659 | B-C/3 | 471-G-F379 | 219.1
Steel Assembly | RIGID_FRAME | 112.7 | +63.345 | +65.754 | B-C/3 | 471-G-F388 | 250
Steel Assembly | RIGID_FRAME | 224 | +58.117 | +63.199 | B-C/3 | 471-G-F386 | 250
Steel Assembly | RIGID_FRAME | 94.3 | +53.191 | +55.155 | B-C/3 | 471-G-F382 | 250
Steel Assembly | RIGID_FRAME | 182.2 | +48.812 | +52.890 | B-C/3 | 471-G-F380 | 250
Steel Assembly | RIGID_FRAME | 15.6 | +28.893 | +28.973 | C-D/2-3 | 471-E-D127 | 80
Steel Assembly | RIGID_FRAME | 46.8 | +28.877 | +29.080 | C-D/2-3 | 471-E-D162 | 330.24
Steel Assembly | RIGID_FRAME | 28.3 | +28.880 | +29.080 | C-D/2-3 | 471-E-D82 | 450.586
Steel Assembly | RIGID_FRAME | 12.6 | +28.893 | +28.973 | C-D/2-3 | 471-E-D119 | 80
Steel Assembly | RIGID_FRAME | 46.8 | +28.877 | +29.080 | C-D/2-3 | 471-E-D161 | 313.492
2 x Steel Assembly | RIGID_FRAME | 44.7 | +28.877 | +29.080 | C-D/2-3 | 471-E-D160 | 203.2
Steel Assembly | RIGID_FRAME | 180.2 | +44.292 | +44.502 | B-C/2-3 | 471-F-E224 | 193.7
Steel Assembly | RIGID_FRAME | 245.2 | +43.890 | +44.890 | B-C/3 | 471-F-E52 | 309.289
Steel Assembly | RIGID_FRAME | 180.2 | +38.755 | +38.965 | B-C/2-3 | 471-F-E224 | 193.7
Steel Assembly | RIGID_FRAME | 236.9 | +38.330 | +39.368 | B-C/3 | 471-F-E53 | 309.289
Steel Assembly | RIGID_FRAME | 180.2 | +35.987 | +36.197 | B-C/2-3 | 471-E-D170 | 193.7
Steel Assembly | RIGID_FRAME | 238.8 | +35.564 | +36.623 | B-C/3 | 471-E-D41 | 309.289
Steel Assembly | RIGID_FRAME | 180.2 | +31.445 | +31.655 | B-C/2-3 | 471-E-D170 | 193.7
Steel Assembly | RIGID_FRAME | 403.9 | +31.372 | +32.079 | C/2-3 | 471-E-D14 | 257.594
Steel Assembly | RIGID_FRAME | 238.5 | +31.020 | +32.065 | B-C/3 | 471-E-D39 | 309.289
Steel Assembly | RIGID_FRAME | 180.2 | +28.797 | +29.007 | B-C/2-3 | 471-E-D170 | 193.7
Steel Assembly | RIGID_FRAME | 249.5 | +28.376 | +29.430 | B-C/3 | 471-E-D40 | 334.289
Steel Assembly | RIGID_FRAME | 173.6 | +44.600 | +48.321 | B-C/3 | 471-F-E243 | 219.1
Steel Assembly | RIGID_FRAME | 178.1 | +44.600 | +48.319 | B-C/3 | 471-F-E244 | 219.1
Steel Assembly | RIGID_FRAME | 254.6 | +39.063 | +44.194 | B-C/3 | 471-F-E241 | 219.1
Steel Assembly | RIGID_FRAME | 234.4 | +39.168 | +44.425 | B-C/3 | 471-F-E242 | 250
Steel Assembly | RIGID_FRAME | 165.6 | +36.295 | +38.657 | B-C/3 | 471-F-E239 | 219.1
Steel Assembly | RIGID_FRAME | 218.6 | +31.748 | +35.879 | B-C/3 | 471-E-D201 | 219.1
Steel Assembly | RIGID_FRAME | 199 | +31.765 | +36.220 | B-C/3 | 471-E-D202 | 250
Steel Assembly | RIGID_FRAME | 119.7 | +29.130 | +31.678 | B-C/3 | 471-E-D200 | 250
Steel Assembly | RIGID_FRAME | 118.2 | +36.423 | +38.888 | B-C/3 | 471-F-E240 | 250
Steel Assembly | RIGID_FRAME | 158.8 | +29.102 | +31.347 | B-C/3 | 471-E-D199 | 219.1
2 x Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | B-C/3 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | C/3 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | B-C/3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 444.2 | +47.998 | +49.044 | C-D/2 | 471-F-E25 | 315.058
4 x Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | C-D/2 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | C/2 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | D/2 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 184.7 | +48.344 | +48.700 | B-C/2 | 471-F-E26 | 264.99
3 x Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | B-C/2 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | B-C/2 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 377.7 | +48.344 | +48.700 | B-C/2-3 | 471-F-E22 | 305.74
3 x Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | B-C/2-3 | 471-F-E204 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | D/2-3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | C/2-3 | 471-F-E203 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | C/2-3 | 471-F-E204 | 70
4 x Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | D/2-3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | D/2 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | C/2 | 471-F-E204 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | D/2-3 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 426.7 | +28.373 | +29.415 | E/2-3 | 471-E-D29 | 265.067
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | E/2-3 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 7.8 | +66.250 | +67.355 | E/2-3 | 471-G-F305 | 70.0002
Steel Assembly | RIGID_FRAME | 420.1 | +43.866 | +44.924 | E/2-3 | 471-F-E43 | 265.067
Steel Assembly | RIGID_FRAME | 185.5 | +43.870 | +44.927 | D-E/2 | 471-F-E41 | 362.425
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | E/2-3 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | D-E/2 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | E/2 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | D/2 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | E/2 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 186.3 | +54.596 | +55.655 | D-E/3 | 471-G-F63 | 371.244
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | D-E/3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | E/3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 437.4 | +54.621 | +55.641 | E/2-3 | 471-G-F57 | 315.058
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | E/3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | D/3 | 471-G-F309 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | E/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 7.8 | +60.735 | +61.840 | D/2-3 | 471-G-F306 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +60.735 | +61.840 | E/2-3 | 471-G-F305 | 70.0002
Steel Assembly | RIGID_FRAME | 8.2 | +60.560 | +61.840 | D-E/3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +60.560 | +61.840 | D-E/3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 95.8 | +5.256 | +5.449 | B-C/2-3 | 471-D-C373 | 210.001
Steel Assembly | RIGID_FRAME | 58.6 | +12.300 | +12.500 | A-B/2-3 | 471-D-C227 | 160
Steel Assembly | RIGID_FRAME | 96.7 | +12.300 | +12.500 | A-B/2-3 | 471-D-C238 | 160
Steel Assembly | RIGID_FRAME | 86.8 | +10.590 | +12.500 | B-C/1-2 | 471-D-C17 | 195.999
Steel Assembly | RIGID_FRAME | 86.8 | +10.590 | +12.500 | B-C/1-2 | 471-D-C16 | 196
Steel Assembly | RIGID_FRAME | 152.8 | +5.328 | +5.700 | B-C/2-3 | 471-D-C102 | 799.412
Steel Assembly | RIGID_FRAME | 22.9 | +5.500 | +5.700 | A-B/2 | 471-D-C21 | 99.9999
Steel Assembly | RIGID_FRAME | 32.8 | +5.500 | +5.700 | A-B/2-3 | 471-D-C213 | 160
Steel Assembly | RIGID_FRAME | 32.8 | +5.500 | +5.700 | A-B/2-3 | 471-D-C214 | 160
Steel Assembly | RIGID_FRAME | 22.9 | +5.500 | +5.700 | A-B/1-2 | 471-D-C21 | 99.9999
Steel Assembly | RIGID_FRAME | 117.8 | +5.346 | +5.700 | A-B/1-2 | 471-D-C192 | 160
Steel Assembly | RIGID_FRAME | 105 | +5.500 | +5.700 | A-B/1-2 | 471-D-C211 | 160
Steel Assembly | RIGID_FRAME | 495.5 | +5.328 | +5.700 | A-B/2-3 | 471-D-C44 | 533.95
7 x Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | A-B/2-3 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 28.4 | +5.500 | +5.700 | A-B/2-3 | 471-D-C267 | 160
Steel Assembly | RIGID_FRAME | 22.3 | +5.500 | +5.700 | A-B/2-3 | 471-D-C266 | 160
Steel Assembly | RIGID_FRAME | 22.9 | +5.500 | +5.700 | A-B/2-3 | 471-D-C268 | 160
2 x Steel Assembly | RIGID_FRAME | 51.8 | +5.500 | +5.700 | A-B/2-3 | 471-D-C281 | 160
Steel Assembly | RIGID_FRAME | 23.3 | +5.500 | +5.700 | A-B/2-3 | 471-D-C269 | 160
2 x Steel Assembly | RIGID_FRAME | 58.5 | +5.497 | +5.700 | B-C/2-3 | 471-D-C362 | 203.2
Steel Assembly | RIGID_FRAME | 315.6 | +5.243 | +5.462 | A-B/2-3 | 471-D-C423 | 250
Steel Assembly | RIGID_FRAME | 335.4 | +5.328 | +5.700 | A-B/2-3 | 471-D-C32 | 536.508
3 x Steel Assembly | RIGID_FRAME | 71.4 | +5.500 | +5.700 | A-B/2-3 | 471-D-C256 | 160
2 x Steel Assembly | RIGID_FRAME | 26.4 | +5.500 | +5.700 | A-B/2-3 | 471-D-C280 | 160
Steel Assembly | RIGID_FRAME | 134.6 | +5.500 | +5.700 | A-B/2-3 | 471-D-C249 | 160
2 x Steel Assembly | RIGID_FRAME | 9.7 | +17.868 | +18.020 | B-C/2-3 | 471-C-B145 | 160
Steel Assembly | RIGID_FRAME | 9.7 | +17.868 | +18.020 | B-C/2 | 471-C-B145 | 160
Steel Assembly | RIGID_FRAME | 16.3 | +17.868 | +18.020 | C-D/2-3 | 471-C-B144 | 160
3 x Steel Assembly | RIGID_FRAME | 9.7 | +17.868 | +18.020 | C-D/2 | 471-C-B145 | 160
Steel Assembly | RIGID_FRAME | 471 | +17.344 | +18.402 | C-D/2 | 471-C-B25 | 678.449
Steel Assembly | RIGID_FRAME | 164.2 | +15.256 | +15.449 | B-C/2-3 | 471-D-C416 | 210
Steel Assembly | RIGID_FRAME | 191.5 | +15.256 | +15.449 | B-C/2-3 | 471-D-C414 | 210
Steel Assembly | RIGID_FRAME | 471 | +15.328 | +16.247 | B-C/3 | 471-D-C46 | 801.656
Steel Assembly | RIGID_FRAME | 381.3 | +15.328 | +15.700 | B-C/2-3 | 471-D-C22 | 660.91
2 x Steel Assembly | RIGID_FRAME | 24 | +15.500 | +15.700 | B-C/2-3 | 471-D-C265 | 160
Steel Assembly | RIGID_FRAME | 37.1 | +15.500 | +15.700 | B-C/2-3 | 471-D-C246 | 160
Steel Assembly | RIGID_FRAME | 46.7 | +15.497 | +15.700 | B-C/2-3 | 471-D-C369 | 203.2
Steel Assembly | RIGID_FRAME | 13 | +15.513 | +15.593 | B-C/2-3 | 471-D-C327 | 80
Steel Assembly | RIGID_FRAME | 12.6 | +15.513 | +15.593 | B-C/2-3 | 471-D-C326 | 80
Steel Assembly | RIGID_FRAME | 337.9 | +15.344 | +15.700 | B-C/2 | 471-D-C30 | 343.895
Steel Assembly | RIGID_FRAME | 85 | +15.346 | +15.700 | B-C/2-3 | 471-D-C194 | 299.986
2 x Steel Assembly | RIGID_FRAME | 13.6 | +15.513 | +15.593 | B-C/2-3 | 471-D-C325 | 80
Steel Assembly | RIGID_FRAME | 84 | +15.500 | +15.700 | B-C/2-3 | 471-D-C218 | 321.222
2 x Steel Assembly | RIGID_FRAME | 14.8 | +15.513 | +15.593 | B-C/2-3 | 471-D-C332 | 80
Steel Assembly | RIGID_FRAME | 77 | +15.500 | +15.700 | B-C/2-3 | 471-D-C222 | 338.646
2 x Steel Assembly | RIGID_FRAME | 14 | +15.513 | +15.593 | B-C/2-3 | 471-D-C331 | 80
Steel Assembly | RIGID_FRAME | 80.6 | +15.500 | +15.700 | B-C/2-3 | 471-D-C219 | 337.762
2 x Steel Assembly | RIGID_FRAME | 13.5 | +15.513 | +15.593 | B-C/2-3 | 471-D-C330 | 80
Steel Assembly | RIGID_FRAME | 81 | +15.500 | +15.700 | B-C/2-3 | 471-D-C220 | 329.861
2 x Steel Assembly | RIGID_FRAME | 14.5 | +15.513 | +15.593 | B-C/2-3 | 471-D-C329 | 80
Steel Assembly | RIGID_FRAME | 80.8 | +15.500 | +15.700 | B-C/2-3 | 471-D-C221 | 334.521
Steel Assembly | RIGID_FRAME | 82.8 | +15.500 | +15.700 | B-C/2-3 | 471-D-C223 | 333.172
Steel Assembly | RIGID_FRAME | 14.2 | +15.513 | +15.593 | B-C/2-3 | 471-D-C328 | 80
Steel Assembly | RIGID_FRAME | 13 | +15.513 | +15.593 | B-C/2-3 | 471-D-C324 | 80
Steel Assembly | RIGID_FRAME | 13.5 | +15.513 | +15.593 | B-C/2-3 | 471-D-C323 | 80
Steel Assembly | RIGID_FRAME | 51.7 | +15.500 | +15.700 | B-C/1-2 | 471-D-C204 | 258.137
Steel Assembly | RIGID_FRAME | 101.2 | +15.346 | +15.700 | B-C/2-3 | 471-D-C195 | 185
2 x Steel Assembly | RIGID_FRAME | 94.2 | +15.500 | +15.700 | B-C/2-3 | 471-D-C258 | 160
Steel Assembly | RIGID_FRAME | 94.2 | +15.500 | +15.700 | B-C/2-3 | 471-D-C226 | 160
2 x Steel Assembly | RIGID_FRAME | 93.8 | +15.500 | +15.700 | B-C/3-4 | 471-D-C224 | 160
Steel Assembly | RIGID_FRAME | 94.2 | +15.500 | +15.700 | B-C/2-3 | 471-D-C225 | 160
2 x Steel Assembly | RIGID_FRAME | 16.5 | +15.513 | +15.593 | B-C/1-2 | 471-D-C301 | 80
Steel Assembly | RIGID_FRAME | 59.7 | +15.346 | +15.700 | B-C/1-2 | 471-D-C193 | 356.074
Steel Assembly | RIGID_FRAME | 34.9 | +15.500 | +15.700 | B-C/1-2 | 471-D-C207 | 265.917
2 x Steel Assembly | RIGID_FRAME | 21.2 | +15.513 | +15.593 | B-C/1-2 | 471-D-C303 | 80
2 x Steel Assembly | RIGID_FRAME | 23.7 | +15.513 | +15.593 | B-C/1-2 | 471-D-C302 | 80
Steel Assembly | RIGID_FRAME | 65.7 | +15.346 | +15.700 | B-C/1-2 | 471-D-C174 | 245.013
Steel Assembly | RIGID_FRAME | 61.7 | +15.500 | +15.700 | B-C/1-2 | 471-D-C271 | 330.027
Steel Assembly | RIGID_FRAME | 18.1 | +15.513 | +15.593 | B-C/1-2 | 471-D-C304 | 80
Steel Assembly | RIGID_FRAME | 65.5 | +15.346 | +15.700 | B-C/1-2 | 471-D-C173 | 259.801
Steel Assembly | RIGID_FRAME | 34.9 | +15.500 | +15.700 | B-C/1-2 | 471-D-C264 | 289.502
Steel Assembly | RIGID_FRAME | 59.4 | +15.500 | +15.700 | B-C/1-2 | 471-D-C205 | 245.013
Steel Assembly | RIGID_FRAME | 53.3 | +15.500 | +15.700 | B-C/1-2 | 471-D-C270 | 342.275
Steel Assembly | RIGID_FRAME | 34.7 | +15.500 | +15.700 | B-C/1-2 | 471-D-C263 | 265.917
Steel Assembly | RIGID_FRAME | 50.8 | +15.500 | +15.700 | B-C/1-2 | 471-D-C203 | 264.937
Steel Assembly | RIGID_FRAME | 33.1 | +15.500 | +15.700 | B-C/1-2 | 471-D-C206 | 160
2 x Steel Assembly | RIGID_FRAME | 21.5 | +15.500 | +15.700 | B-C/1-2 | 471-D-C245 | 160
2 x Steel Assembly | RIGID_FRAME | 19.5 | +15.500 | +15.700 | B-C/1-2 | 471-D-C244 | 160
2 x Steel Assembly | RIGID_FRAME | 25.2 | +5.500 | +5.700 | B-C/3-4 | 471-D-C277 | 160
Steel Assembly | RIGID_FRAME | 21.9 | +5.500 | +5.700 | B-C/3-4 | 471-D-C279 | 160
Steel Assembly | RIGID_FRAME | 32 | +5.500 | +5.700 | B-C/3-4 | 471-D-C278 | 160
Steel Assembly | RIGID_FRAME | 21.7 | +5.500 | +5.700 | B-C/3-4 | 471-D-C243 | 160
2 x Steel Assembly | RIGID_FRAME | 36.7 | +5.500 | +5.700 | B-C/2-3 | 471-D-C208 | 160
2 x Steel Assembly | RIGID_FRAME | 50 | +5.500 | +5.700 | B-C/2-3 | 471-D-C237 | 160
Steel Assembly | RIGID_FRAME | 94.3 | +5.500 | +5.700 | B-C/3-4 | 471-D-C251 | 205
Steel Assembly | RIGID_FRAME | 446.7 | +15.004 | +16.047 | B/2-3 | 471-D-C68 | 321.75
3 x Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | B/2-3 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 272.4 | +14.999 | +15.700 | B/1-2 | 471-D-C38 | 265
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | B/2 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +31.553 | +32.833 | D-E/2-3 | 471-E-D153 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +31.553 | +32.833 | D/2-3 | 471-E-D152 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +31.553 | +32.833 | E/2-3 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 397.5 | +31.372 | +32.079 | D/2-3 | 471-E-D26 | 265.058
Steel Assembly | RIGID_FRAME | 8.2 | +31.553 | +32.833 | D/2-3 | 471-E-D151 | 70
Steel Assembly | RIGID_FRAME | 425.4 | +31.038 | +32.079 | E/2-3 | 471-E-D21 | 265.058
3 x Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | C-D/2 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | C/2 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | D/2 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | C/2-3 | 471-E-D152 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | C/2-3 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 185 | +35.562 | +36.620 | D-E/3 | 471-E-D32 | 371.489
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | D-E/3 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | D/3 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | E/3 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 427.4 | +35.563 | +36.606 | E/2-3 | 471-E-D22 | 315.058
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | E/3 | 471-E-D152 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | E/2-3 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | D/2 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 73.8 | +36.070 | +36.270 | D-E/2-3 | 471-E-D4 | 237.526
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | D/2-3 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 397.8 | +38.682 | +39.391 | D/2-3 | 471-F-E27 | 265.067
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.143 | D/2-3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.143 | D/2 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 425 | +38.346 | +39.391 | E/2-3 | 471-F-E44 | 265.067
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.143 | E/2-3 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 184.7 | +38.333 | +39.387 | D-E/2 | 471-F-E42 | 362.425
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.143 | D-E/2 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.143 | E/2 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.143 | D/2 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.143 | E/2 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 9.2 | +28.893 | +28.973 | B-C/2-3 | 471-E-D110 | 80
Steel Assembly | RIGID_FRAME | 35.1 | +28.880 | +29.080 | B-C/2-3 | 471-E-D49 | 337.632
Steel Assembly | RIGID_FRAME | 35.1 | +28.880 | +29.080 | B-C/2-3 | 471-E-D10 | 236.09
2 x Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | B-C/2-3 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 39.1 | +28.880 | +29.080 | B-C/2-3 | 471-E-D13 | 400.942
3 x Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | C/2-3 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | C/2-3 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | C/2 | 471-E-D152 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | D/2-3 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 73.9 | +63.250 | +63.450 | D-E/2-3 | 471-G-F13 | 234.44
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | E/2-3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | D/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | E/2-3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | D/2-3 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.143 | E/2-3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.143 | D/2-3 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 7.8 | +48.700 | +49.805 | E/2-3 | 471-F-E200 | 70.0002
Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | D-E/2-3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 7.8 | +53.040 | +54.145 | D/2-3 | 471-G-F306 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +53.040 | +54.145 | E/2-3 | 471-G-F305 | 70.0002
Steel Assembly | RIGID_FRAME | 8.2 | +52.865 | +54.145 | D-E/2-3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +52.865 | +54.145 | D-E/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 7.8 | +58.020 | +59.125 | D/2-3 | 471-G-F306 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +58.020 | +59.125 | E/2-3 | 471-G-F305 | 70.0002
Steel Assembly | RIGID_FRAME | 8.2 | +57.845 | +59.125 | D-E/2-3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +57.845 | +59.125 | D-E/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 77 | +21.160 | +21.460 | C-D/1-2 | 471-C-B230 | 100
Steel Assembly | RIGID_FRAME | 84.7 | +21.104 | +21.460 | C/1-2 | 471-C-B23 | 190.75
Steel Assembly | RIGID_FRAME | 7.8 | +68.450 | +69.555 | D/2-3 | 471-G-F306 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +68.450 | +69.555 | E/2-3 | 471-G-F305 | 70.0002
Steel Assembly | RIGID_FRAME | 8.2 | +68.275 | +69.555 | D-E/2-3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +68.275 | +69.555 | D-E/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 241.5 | +21.104 | +21.460 | B-C/2-3 | 471-D-C139 | 194.782
Steel Assembly | RIGID_FRAME | 430.3 | +21.104 | +21.807 | C/2-3 | 471-C-B27 | 323.02
Steel Assembly | RIGID_FRAME | 481.6 | +20.583 | +21.885 | B-C/3 | 471-D-C136 | 351.5
Steel Assembly | RIGID_FRAME | 301.5 | +21.157 | +21.407 | B-C/2-3 | 471-D-C466 | 219.1
Steel Assembly | RIGID_FRAME | 396.6 | +69.951 | +70.650 | C-D/2 | 471-G-F53 | 265.75
4 x Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | C-D/2 | 471-G-F309 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | D/2 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 404.9 | +69.944 | +70.650 | D/2-3 | 471-G-F54 | 265.75
5 x Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | D/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | D-E/2-3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 399.8 | +69.944 | +70.650 | E/2-3 | 471-G-F58 | 265.75
Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | E/3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 163 | +69.941 | +70.650 | D-E/3 | 471-G-F76 | 265.75
Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | D-E/3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | E/3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | E/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | E/2-3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 403.2 | +69.944 | +70.650 | C/2-3 | 471-G-F40 | 263.901
3 x Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | C/2-3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 123.3 | +70.294 | +70.650 | C/3-4 | 471-G-F81 | 265.75
Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | C/3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | C/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 172.3 | +70.450 | +70.650 | C-D/3-4 | 471-G-F183 | 408.488
Steel Assembly | RIGID_FRAME | 123.3 | +70.294 | +70.650 | D/3-4 | 471-G-F79 | 265.75
3 x Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | C-D/3-4 | 471-G-F309 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | D/3-4 | 471-G-F310 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | C/3-4 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | D/3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 123.3 | +63.094 | +63.450 | C/3-4 | 471-G-F80 | 265.75
Steel Assembly | RIGID_FRAME | 123.3 | +63.094 | +63.450 | D/3-4 | 471-G-F79 | 265.75
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | C/3 | 471-G-F310 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | C-D/3-4 | 471-G-F309 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | D/3-4 | 471-G-F310 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | C/3-4 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | C/3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | D/3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | D/3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 170.3 | +55.105 | +55.305 | C-D/3-4 | 471-G-F184 | 408.488
Steel Assembly | RIGID_FRAME | 123.3 | +54.949 | +55.305 | C/3-4 | 471-G-F77 | 265.75
Steel Assembly | RIGID_FRAME | 123.3 | +54.949 | +55.305 | D/3-4 | 471-G-F78 | 265.75
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | C/3 | 471-G-F310 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | C-D/3-4 | 471-G-F309 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | D/3-4 | 471-G-F310 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | C/3-4 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | C/3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | D/3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | D/3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 172.3 | +44.375 | +44.575 | C-D/3-4 | 471-F-E72 | 408.488
Steel Assembly | RIGID_FRAME | 123.3 | +44.219 | +44.575 | C/3-4 | 471-F-E32 | 265.75
Steel Assembly | RIGID_FRAME | 123.3 | +44.219 | +44.575 | D/3-4 | 471-F-E33 | 265.75
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | C/3 | 471-F-E204 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | C-D/3-4 | 471-F-E203 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | D/3-4 | 471-F-E204 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | C/3-4 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | C/3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | D/3 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | D/3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 172.3 | +36.070 | +36.270 | C-D/3-4 | 471-E-D89 | 408.488
Steel Assembly | RIGID_FRAME | 123.2 | +35.914 | +36.270 | C/3-4 | 471-E-D24 | 265.75
Steel Assembly | RIGID_FRAME | 123.2 | +35.914 | +36.270 | D/3-4 | 471-E-D23 | 265.75
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | C/3 | 471-E-D153 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | C-D/3-4 | 471-E-D152 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | D/3-4 | 471-E-D153 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | C/3-4 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | C/3 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | D/3 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 180.2 | +24.035 | +24.245 | B-C/2-3 | 471-D-C418 | 193.7
Steel Assembly | RIGID_FRAME | 403.5 | +23.962 | +24.670 | C/2-3 | 471-C-B32 | 257.594
Steel Assembly | RIGID_FRAME | 311.4 | +23.537 | +24.743 | B-C/3 | 471-D-C137 | 324.29
Steel Assembly | RIGID_FRAME | 309.8 | +54.599 | +55.305 | C-D/3 | 471-G-F98 | 180
Steel Assembly | RIGID_FRAME | 172.3 | +28.880 | +29.080 | C-D/3-4 | 471-E-D89 | 408.488
Steel Assembly | RIGID_FRAME | 123.2 | +28.724 | +29.080 | C/3-4 | 471-E-D25 | 265.75
Steel Assembly | RIGID_FRAME | 123.2 | +28.724 | +29.080 | D/3-4 | 471-E-D23 | 265.75
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | C/3 | 471-E-D153 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | C-D/3-4 | 471-E-D152 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | D/3-4 | 471-E-D153 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | C/3-4 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | C/3 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | D/3 | 471-E-D153 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | D/2-3 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | D/3 | 471-E-D152 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | C-D/2 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | C/2 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | D/2 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 184.3 | +28.374 | +29.431 | D-E/2 | 471-E-D38 | 362.425
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | D-E/2 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | E/2 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | D/2 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 73.9 | +28.880 | +29.080 | D-E/2-3 | 471-E-D5 | 231.268
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | E/2-3 | 471-E-D152 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | D/2-3 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.185 | E/2 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 1329.2 | +0.000 | +12.500 | A/6 | 471-D-C140 | 631.994
Steel Assembly | RIGID_FRAME | 231.1 | +0.159 | +5.319 | <A/6 | 471-D-C457 | 219.1
Steel Assembly | RIGID_FRAME | 127.9 | +5.063 | +5.968 | <A/6 | 471-D-C110 | 270
Steel Assembly | RIGID_FRAME | 1342.7 | +0.000 | +12.500 | A/5 | 471-D-C143 | 632.019
Steel Assembly | RIGID_FRAME | 166 | +5.043 | +5.979 | <A/5 | 471-D-C138 | 190
Steel Assembly | RIGID_FRAME | 293.2 | +5.725 | +12.353 | <A/5 | 471-D-C461 | 219.1
Steel Assembly | RIGID_FRAME | 118.8 | +2.725 | +5.285 | <A/5 | 471-D-C463 | 219.1
Steel Assembly | RIGID_FRAME | 117.3 | +2.725 | +5.249 | <A/5 | 471-D-C462 | 219.1
Steel Assembly | RIGID_FRAME | 308.9 | +2.153 | +2.965 | <A/5 | 471-D-C6 | 1020
Steel Assembly | RIGID_FRAME | 109.5 | +0.375 | +2.475 | <A/5 | 471-D-C465 | 219.1
Steel Assembly | RIGID_FRAME | 138.9 | +0.043 | +2.475 | <A/5 | 471-D-C464 | 219.1
Steel Assembly | RIGID_FRAME | 7.8 | +2.700 | +3.805 | <A/5 | 471-D-C336 | 70.0002
Steel Assembly | RIGID_FRAME | 383.6 | +2.400 | +2.800 | A/5-6 | 471-D-C482 | 228
Steel Assembly | RIGID_FRAME | 383.6 | +2.400 | +2.800 | A/4-5 | 471-D-C482 | 228
Steel Assembly | RIGID_FRAME | 168 | +21.485 | +24.272 | B-C/3 | 471-D-C460 | 219.1
Steel Assembly | RIGID_FRAME | 850.2 | +13.504 | +21.785 | B/3 | 471-D-C144 | 304.8
Steel Assembly | RIGID_FRAME | 229 | +24.348 | +28.689 | B-C/3 | 471-E-D198 | 219.1
Steel Assembly | RIGID_FRAME | 166.1 | +21.485 | +23.937 | B-C/3 | 471-D-C459 | 219.1
Steel Assembly | RIGID_FRAME | 311.1 | +24.343 | +29.029 | B-C/3 | 471-E-D211 | 300
Steel Assembly | RIGID_FRAME | 166.1 | +21.485 | +23.937 | B-C/3 | 471-D-C479 | 300
Steel Assembly | RIGID_FRAME | 400.7 | +15.725 | +21.057 | B-C/3 | 471-D-C478 | 273.1
Steel Assembly | RIGID_FRAME | 384.5 | +15.750 | +21.079 | B-C/3 | 471-D-C477 | 273.1
Steel Assembly | RIGID_FRAME | 134.6 | -0.430 | +4.406 | A-B/2-3 | 471-0-010027 | 780.01
Steel Assembly | RIGID_FRAME | 134.6 | -0.430 | +4.406 | A-B/3-4 | 471-0-010026 | 780.01
Steel Assembly | RIGID_FRAME | 394.6 | +11.796 | +12.500 | A/5-6 | 471-D-C34 | 352.002
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A/5-6 | 471-D-C341 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A/5-6 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 441 | +11.796 | +12.500 | A/4-5 | 471-D-C39 | 356.004
4 x Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A/4-5 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 272.6 | +11.815 | +12.500 | A/3-4 | 471-D-C50 | 335.002
3 x Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A/3-4 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 464.2 | +11.793 | +12.500 | A/2-3 | 471-D-C23 | 291.753
4 x Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A/2-3 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A/3 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A/5-6 | 471-D-C343 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A/4-5 | 471-D-C343 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A/2-3 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 122.9 | +11.876 | +12.500 | <A/6 | 471-D-C95 | 355.088
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | <A/6 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 540.1 | +11.811 | +12.500 | A-B/6 | 471-D-C118 | 569.506
5 x Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A-B/6 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 57.5 | +12.300 | +12.500 | <A/5-6 | 471-D-C197 | 215.001
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | <A/6 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 58.7 | +5.500 | +5.700 | <A/5-6 | 471-D-C198 | 215
2 x Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | <A/5-6 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 43.5 | +5.370 | +5.700 | <A/5-6 | 471-D-C201 | 317.747
Steel Assembly | RIGID_FRAME | 14.2 | +5.525 | +5.700 | A/5-6 | 471-D-C486 | 205
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | A/5-6 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 14.2 | +5.525 | +5.700 | A/5-6 | 471-D-C485 | 205
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | A/5-6 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 150.2 | +9.000 | +9.200 | A/5-6 | 471-D-C20 | 75
Steel Assembly | RIGID_FRAME | 289.2 | +5.700 | +13.983 | <A/5-6 | 471-0-010028 | 780.01
Steel Assembly | RIGID_FRAME | 11.6 | +5.614 | +5.700 | <A/5-6 | 471-D-C299 | 160
Steel Assembly | RIGID_FRAME | 41.9 | +5.370 | +5.700 | <A/5-6 | 471-D-C200 | 262.748
Steel Assembly | RIGID_FRAME | 384.2 | +4.992 | +6.048 | A/5-6 | 471-D-C122 | 201.751
Steel Assembly | RIGID_FRAME | 14.8 | +5.513 | +5.593 | <A/5-6 | 471-D-C322 | 80
Steel Assembly | RIGID_FRAME | 224.5 | -0.270 | +7.183 | <A/6 | 471-0-010029 | 780.01
Steel Assembly | RIGID_FRAME | 13.1 | +12.400 | +12.500 | A/5-6 | 471-D-C484 | 140
Steel Assembly | RIGID_FRAME | 14.5 | +12.313 | +12.393 | <A/5-6 | 471-D-C300 | 80
Steel Assembly | RIGID_FRAME | 42.5 | +12.170 | +12.500 | <A/5-6 | 471-D-C166 | 264.237
Steel Assembly | RIGID_FRAME | 37.1 | +12.170 | +12.500 | <A/5-6 | 471-D-C199 | 160
Steel Assembly | RIGID_FRAME | 83.3 | +12.170 | +12.500 | A-B/5-6 | 471-D-C228 | 160
Steel Assembly | RIGID_FRAME | 286.1 | +5.500 | +12.076 | <A/6 | 471-D-C458 | 250
Steel Assembly | RIGID_FRAME | 281.1 | +5.725 | +12.119 | <A/6 | 471-D-C456 | 219.1
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.830 | <A/5-6 | 471-D-C340 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.630 | <A/5-6 | 471-D-C340 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.830 | <A/5-6 | 471-D-C339 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/6 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 361.6 | +11.796 | +12.500 | B/5-6 | 471-D-C64 | 271.75
2 x Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/5-6 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 375.2 | +11.796 | +12.500 | B/4-5 | 471-D-C66 | 271.75
2 x Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/4-5 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 466.5 | +11.793 | +12.840 | B/2-3 | 471-D-C71 | 321.75
3 x Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/2-3 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 269.1 | +11.764 | +12.851 | B/3-4 | 471-D-C76 | 315
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/3-4 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/6 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/5 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/5 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/4 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/4 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/3 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/3 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 26.6 | +15.192 | +15.344 | B-C/2-3 | 471-D-C294 | 152.4
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/2 | 471-D-C343 | 70
2 x Steel Assembly | RIGID_FRAME | 94.2 | +15.500 | +15.700 | B-C/2-3 | 471-D-C247 | 160
Steel Assembly | RIGID_FRAME | 39.8 | +5.497 | +5.700 | A-B/1-2 | 471-D-C368 | 203.2
Steel Assembly | RIGID_FRAME | 149.1 | +5.700 | +5.900 | A-B/4-5 | 471-D-C187 | 307.8
4 x Steel Assembly | RIGID_FRAME | 8.2 | +5.725 | +7.005 | A-B/4-5 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 215.6 | +5.700 | +5.900 | A-B/4-5 | 471-D-C186 | 307.8
4 x Steel Assembly | RIGID_FRAME | 8.2 | +5.725 | +7.005 | A-B/4-5 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.725 | +7.005 | A/4-5 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.725 | +7.005 | A/4-5 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 151.9 | +5.700 | +5.900 | A-B/3-5 | 471-D-C189 | 307.8
Steel Assembly | RIGID_FRAME | 152.8 | +5.700 | +5.900 | A-B/3-5 | 471-D-C188 | 395.585
Steel Assembly | RIGID_FRAME | 8.2 | +5.725 | +7.005 | A-B/4 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.725 | +7.005 | A-B/4 | 471-D-C342 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +5.725 | +7.005 | A-B/3-4 | 471-D-C343 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +5.725 | +7.005 | A-B/3-4 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.725 | +7.005 | A-B/3 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.725 | +7.005 | A-B/3 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 163 | +12.170 | +12.500 | <A/2-3 | 471-D-C1 | 1448.85
Steel Assembly | RIGID_FRAME | 115.8 | +9.835 | +10.165 | <A/2-3 | 471-D-C7 | 1020
Steel Assembly | RIGID_FRAME | 115.8 | +7.635 | +7.965 | <A/3-4 | 471-D-C7 | 1020
Steel Assembly | RIGID_FRAME | 444.6 | +9.800 | +10.200 | A/2-3 | 471-D-C480 | 228
Steel Assembly | RIGID_FRAME | 273.6 | +7.600 | +8.000 | A/3-4 | 471-D-C481 | 228
Steel Assembly | RIGID_FRAME | 135.6 | +5.256 | +5.449 | A-B/1-2 | 471-D-C389 | 210
Steel Assembly | RIGID_FRAME | 610.2 | +5.150 | +6.073 | A-B/1 | 471-D-C37 | 620.921
Steel Assembly | RIGID_FRAME | 188.4 | +5.256 | +5.449 | A-B/1-2 | 471-D-C388 | 210
Steel Assembly | RIGID_FRAME | 179.8 | +5.256 | +5.449 | A-B/1-2 | 471-D-C387 | 210
Steel Assembly | RIGID_FRAME | 539.1 | +5.328 | +6.133 | A-B/2 | 471-D-C58 | 478.017
Steel Assembly | RIGID_FRAME | 308.9 | +5.328 | +5.700 | A-B/1-2 | 471-D-C99 | 776.12
3 x Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | A-B/1-2 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 185 | +5.344 | +5.700 | A-B/1-2 | 471-D-C109 | 270
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | B/1-2 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 185 | +5.344 | +5.700 | A-B/1-2 | 471-D-C60 | 270
2 x Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | A-B/1-2 | 471-D-C342 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | B/1-2 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 310.1 | +4.965 | +6.049 | B/1-2 | 471-D-C74 | 315
2 x Steel Assembly | RIGID_FRAME | 30.4 | +7.950 | +8.150 | A-B/1-2 | 471-D-C165 | 140
2 x Steel Assembly | RIGID_FRAME | 55.8 | +7.950 | +8.150 | A-B/1-2 | 471-D-C191 | 104
2 x Steel Assembly | RIGID_FRAME | 58.9 | +5.700 | +8.150 | A-B/1-2 | 471-D-C168 | 160
2 x Steel Assembly | RIGID_FRAME | 57.6 | +5.700 | +8.150 | A-B/1-2 | 471-D-C169 | 160
Steel Assembly | RIGID_FRAME | 30.4 | +5.500 | +5.700 | A-B/2-3 | 471-D-C257 | 160
2 x Steel Assembly | RIGID_FRAME | 22.1 | +5.500 | +5.700 | A-B/1-2 | 471-D-C241 | 160
Steel Assembly | RIGID_FRAME | 143.9 | +5.370 | +5.700 | <A/4-5 | 471-D-C3 | 1050
Steel Assembly | RIGID_FRAME | 9.2 | +5.713 | +5.793 | A/4-5 | 471-D-C316 | 80
Steel Assembly | RIGID_FRAME | 18.1 | +5.713 | +5.793 | A-B/4-5 | 471-D-C319 | 80
Steel Assembly | RIGID_FRAME | 18.1 | +5.713 | +5.793 | A-B/4-5 | 471-D-C318 | 80
2 x Steel Assembly | RIGID_FRAME | 9.2 | +5.713 | +5.793 | A-B/4-5 | 471-D-C316 | 80
2 x Steel Assembly | RIGID_FRAME | 18.4 | +5.713 | +5.793 | A-B/4-5 | 471-D-C317 | 80
Steel Assembly | RIGID_FRAME | 9.2 | +5.713 | +5.793 | A-B/4 | 471-D-C316 | 80
Steel Assembly | RIGID_FRAME | 18.3 | +5.713 | +5.793 | A-B/3-4 | 471-D-C320 | 80
Steel Assembly | RIGID_FRAME | 18 | +5.713 | +5.793 | A-B/3-4 | 471-D-C321 | 80
Steel Assembly | RIGID_FRAME | 9.2 | +5.713 | +5.793 | A-B/3-4 | 471-D-C316 | 80
Steel Assembly | RIGID_FRAME | 9.2 | +5.713 | +5.793 | A-B/3 | 471-D-C316 | 80
Steel Assembly | RIGID_FRAME | 274.8 | +5.428 | +5.648 | A-B/3-4 | 471-D-C420 | 250
Steel Assembly | RIGID_FRAME | 543.9 | +5.344 | +6.133 | A-B/4 | 471-D-C47 | 696.538
Steel Assembly | RIGID_FRAME | 202.7 | +5.428 | +5.648 | A-B/3-4 | 471-D-C421 | 250
Steel Assembly | RIGID_FRAME | 540.1 | +5.344 | +6.133 | A-B/3 | 471-D-C59 | 466.859
Steel Assembly | RIGID_FRAME | 66.3 | +55.305 | +58.283 | C-D/2-3 | 471-G-F321 | 725
Steel Assembly | RIGID_FRAME | 46.4 | +55.105 | +55.305 | C-D/2-3 | 471-G-F144 | 292.846
Steel Assembly | RIGID_FRAME | 129.7 | +55.105 | +55.305 | C-D/2-3 | 471-G-F127 | 324.291
Steel Assembly | RIGID_FRAME | 132.6 | +36.070 | +36.270 | C-D/2-3 | 471-E-D206 | 351.525
Steel Assembly | RIGID_FRAME | 180.2 | +36.070 | +36.270 | C-D/2-3 | 471-E-D205 | 450.448
Steel Assembly | RIGID_FRAME | 66.3 | +55.305 | +58.283 | C-D/2-3 | 471-G-F322 | 725
Steel Assembly | RIGID_FRAME | 36.9 | +55.307 | +56.600 | C-D/2-3 | 471-G-F344 | 225
Steel Assembly | RIGID_FRAME | 37 | +55.305 | +56.600 | C-D/2-3 | 471-G-F347 | 225
Steel Assembly | RIGID_FRAME | 36.5 | +55.307 | +56.600 | C-D/2-3 | 471-G-F343 | 200
Steel Assembly | RIGID_FRAME | 36.6 | +55.305 | +56.600 | C-D/2-3 | 471-G-F346 | 200
Steel Assembly | RIGID_FRAME | 36.5 | +55.307 | +56.600 | C-D/2-3 | 471-G-F342 | 200
Steel Assembly | RIGID_FRAME | 36.6 | +55.305 | +56.600 | C-D/2-3 | 471-G-F345 | 200
Steel Assembly | RIGID_FRAME | 343.5 | +56.600 | +56.800 | C-D/2-3 | 471-G-F226 | 1369.99
4 x Steel Assembly | RIGID_FRAME | 8.2 | +56.625 | +57.905 | C-D/2-3 | 471-G-F309 | 70
4 x Steel Assembly | RIGID_FRAME | 8.2 | +56.625 | +57.905 | C-D/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 10.8 | +56.696 | +56.780 | C-D/2-3 | 471-G-F391 | 84
Steel Assembly | RIGID_FRAME | 10.8 | +56.696 | +56.780 | C-D/2-3 | 471-G-F390 | 84
Steel Assembly | RIGID_FRAME | 8.2 | +56.655 | +57.935 | C-D/2-3 | 471-G-F298 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +56.655 | +57.935 | C-D/2-3 | 471-G-F297 | 70
Steel Assembly | RIGID_FRAME | 227.5 | +15.700 | +23.013 | C/2-3 | 471-0-010015 | 780.01
Steel Assembly | RIGID_FRAME | 250.7 | +37.900 | +38.100 | C-D/2-3 | 471-F-E149 | 1369.99
3 x Steel Assembly | RIGID_FRAME | 8.2 | +37.925 | +39.205 | C-D/2-3 | 471-F-E204 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +37.925 | +39.205 | C-D/2-3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 72.8 | +36.270 | +39.633 | C-D/2-3 | 471-F-E213 | 725
Steel Assembly | RIGID_FRAME | 10.8 | +37.996 | +38.080 | C-D/2-3 | 471-F-E246 | 84
Steel Assembly | RIGID_FRAME | 8.2 | +37.955 | +39.235 | C-D/2-3 | 471-F-E195 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +37.955 | +39.235 | C-D/2-3 | 471-F-E194 | 70
Steel Assembly | RIGID_FRAME | 72.8 | +36.270 | +39.633 | C-D/2-3 | 471-F-E212 | 725
Steel Assembly | RIGID_FRAME | 10.8 | +37.996 | +38.080 | C-D/2-3 | 471-F-E245 | 84
Steel Assembly | RIGID_FRAME | 44.7 | +36.272 | +37.900 | C-D/2-3 | 471-F-E218 | 200
Steel Assembly | RIGID_FRAME | 44.7 | +36.272 | +37.900 | C-D/2-3 | 471-F-E217 | 200
Steel Assembly | RIGID_FRAME | 44.7 | +36.272 | +37.900 | C-D/2-3 | 471-F-E220 | 200
Steel Assembly | RIGID_FRAME | 44.7 | +36.272 | +37.900 | C-D/2-3 | 471-F-E219 | 200
Steel Assembly | RIGID_FRAME | 101.8 | +12.056 | +12.249 | A-B/2-3 | 471-D-C394 | 210
Steel Assembly | RIGID_FRAME | 526.7 | +12.128 | +12.500 | A-B/2-3 | 471-D-C27 | 524.821
Steel Assembly | RIGID_FRAME | 162.2 | +12.056 | +12.249 | A-B/2-3 | 471-D-C395 | 210
Steel Assembly | RIGID_FRAME | 147.9 | +12.128 | +12.500 | A-B/2-3 | 471-D-C90 | 778.898
Steel Assembly | RIGID_FRAME | 93.4 | +12.056 | +12.249 | A-B/2-3 | 471-D-C396 | 210
Steel Assembly | RIGID_FRAME | 148.7 | +12.128 | +12.500 | A-B/2-3 | 471-D-C100 | 780.043
Steel Assembly | RIGID_FRAME | 105 | +12.056 | +12.249 | A-B/2-3 | 471-D-C399 | 210
Steel Assembly | RIGID_FRAME | 539.5 | +12.128 | +12.500 | A-B/2-3 | 471-D-C29 | 801.627
Steel Assembly | RIGID_FRAME | 167 | +12.056 | +12.249 | A-B/3-4 | 471-D-C400 | 210
Steel Assembly | RIGID_FRAME | 540.7 | +11.811 | +12.500 | A-B/4 | 471-D-C54 | 500.528
Steel Assembly | RIGID_FRAME | 133.6 | +12.056 | +12.249 | A-B/2-3 | 471-D-C397 | 210
Steel Assembly | RIGID_FRAME | 528.6 | +12.128 | +12.500 | A-B/2-3 | 471-D-C26 | 524.239
Steel Assembly | RIGID_FRAME | 139.6 | +12.056 | +12.249 | A-B/2-3 | 471-D-C398 | 210
Steel Assembly | RIGID_FRAME | 170.7 | +12.128 | +12.500 | A-B/2-3 | 471-D-C92 | 794.148
Steel Assembly | RIGID_FRAME | 173.9 | +12.128 | +12.500 | A-B/2-3 | 471-D-C91 | 797.186
Steel Assembly | RIGID_FRAME | 142 | +12.056 | +12.249 | A-B/3-4 | 471-D-C402 | 210
Steel Assembly | RIGID_FRAME | 533 | +11.811 | +12.500 | A-B/3 | 471-D-C53 | 484.124
Steel Assembly | RIGID_FRAME | 165.2 | +12.056 | +12.249 | A-B/3-4 | 471-D-C401 | 210
Steel Assembly | RIGID_FRAME | 286.8 | +12.128 | +12.500 | A-B/3-4 | 471-D-C52 | 926.826
Steel Assembly | RIGID_FRAME | 283.6 | +12.128 | +12.500 | A-B/3-4 | 471-D-C51 | 802.827
Steel Assembly | RIGID_FRAME | 159.8 | +12.056 | +12.249 | A-B/5-6 | 471-D-C407 | 210
Steel Assembly | RIGID_FRAME | 135.4 | +12.056 | +12.249 | A-B/5-6 | 471-D-C408 | 210
Steel Assembly | RIGID_FRAME | 230.6 | +12.128 | +12.500 | A-B/5-6 | 471-D-C69 | 801.709
Steel Assembly | RIGID_FRAME | 158.6 | +12.056 | +12.249 | A-B/5-6 | 471-D-C406 | 210
Steel Assembly | RIGID_FRAME | 541.6 | +11.811 | +12.500 | A-B/5 | 471-D-C55 | 502.925
Steel Assembly | RIGID_FRAME | 226 | +12.128 | +12.500 | A-B/5-6 | 471-D-C70 | 805.743
Steel Assembly | RIGID_FRAME | 122.1 | +12.056 | +12.249 | A-B/5-6 | 471-D-C409 | 210
Steel Assembly | RIGID_FRAME | 133 | +12.056 | +12.249 | A-B/5-6 | 471-D-C410 | 210
Steel Assembly | RIGID_FRAME | 95.3 | +12.056 | +12.249 | A-B/5-6 | 471-D-C411 | 210
Steel Assembly | RIGID_FRAME | 148.7 | +12.128 | +12.500 | A-B/5-6 | 471-D-C93 | 789.972
Steel Assembly | RIGID_FRAME | 568 | +12.128 | +12.500 | A-B/5-6 | 471-D-C28 | 788.988
Steel Assembly | RIGID_FRAME | 146.1 | +12.128 | +12.500 | A-B/5-6 | 471-D-C94 | 780.745
Steel Assembly | RIGID_FRAME | 71.7 | +12.056 | +12.249 | A-B/2-3 | 471-D-C392 | 210
Steel Assembly | RIGID_FRAME | 638.3 | +11.811 | +12.500 | A-B/2 | 471-D-C56 | 793.935
2 x Steel Assembly | RIGID_FRAME | 76.7 | +12.056 | +12.249 | A-B/2-3 | 471-D-C393 | 210
Steel Assembly | RIGID_FRAME | 90.2 | +12.128 | +12.500 | A-B/2-3 | 471-D-C115 | 749.802
Steel Assembly | RIGID_FRAME | 64.1 | +12.056 | +12.249 | A-B/2-3 | 471-D-C413 | 210
Steel Assembly | RIGID_FRAME | 90.6 | +12.128 | +12.500 | A-B/2-3 | 471-D-C114 | 755.964
2 x Steel Assembly | RIGID_FRAME | 211.4 | +12.056 | +12.249 | A-B/1-2 | 471-D-C412 | 210
Steel Assembly | RIGID_FRAME | 499.3 | +12.128 | +12.500 | A-B/1 | 471-D-C57 | 572.064
Steel Assembly | RIGID_FRAME | 178.4 | +12.056 | +12.249 | A-B/4-5 | 471-D-C403 | 210
Steel Assembly | RIGID_FRAME | 563.4 | +12.128 | +12.500 | A-B/4-5 | 471-D-C24 | 577.272
Steel Assembly | RIGID_FRAME | 174.5 | +12.056 | +12.249 | A-B/4-5 | 471-D-C404 | 210
Steel Assembly | RIGID_FRAME | 263.3 | +12.128 | +12.500 | A-B/4-5 | 471-D-C63 | 803.764
2 x Steel Assembly | RIGID_FRAME | 51.1 | +12.144 | +12.500 | A-B/2-3 | 471-D-C133 | 200
Steel Assembly | RIGID_FRAME | 560.1 | +12.128 | +12.500 | A-B/4-5 | 471-D-C25 | 560.502
Steel Assembly | RIGID_FRAME | 155 | +12.056 | +12.249 | A-B/4-5 | 471-D-C405 | 210
Steel Assembly | RIGID_FRAME | 269.1 | +12.128 | +12.500 | A-B/4-5 | 471-D-C62 | 803.736
2 x Steel Assembly | RIGID_FRAME | 40.9 | +12.144 | +12.500 | A-B/4-5 | 471-D-C116 | 200
2 x Steel Assembly | RIGID_FRAME | 40.4 | +12.144 | +12.500 | A-B/4-5 | 471-D-C132 | 200
Steel Assembly | RIGID_FRAME | 227.9 | +15.344 | +15.700 | B/3-4 | 471-D-C98 | 275
Steel Assembly | RIGID_FRAME | 536.4 | +14.850 | +15.522 | B/4-5 | 471-D-C344 | 575
Steel Assembly | RIGID_FRAME | 459.8 | +18.250 | +18.700 | B/4-5 | 471-D-C346 | 250
Steel Assembly | RIGID_FRAME | 26.9 | +19.116 | +19.472 | B/4 | 471-D-C135 | 190
Steel Assembly | RIGID_FRAME | 221.7 | +17.094 | +17.450 | B/3-4 | 471-D-C130 | 190
Steel Assembly | RIGID_FRAME | 243.8 | +18.817 | +19.472 | B/3-4 | 471-D-C128 | 190
Steel Assembly | RIGID_FRAME | 368.7 | +15.328 | +15.700 | B-C/4 | 471-D-C35 | 569.781
Steel Assembly | RIGID_FRAME | 58.8 | +60.535 | +60.735 | D-E/2-3 | 471-G-F11 | 230.627
Steel Assembly | RIGID_FRAME | 887.5 | +0.000 | +7.201 | B/3 | 471-D-C148 | 560
Steel Assembly | RIGID_FRAME | 907.2 | +0.000 | +7.201 | B/4 | 471-D-C151 | 637.941
Steel Assembly | RIGID_FRAME | 899.9 | +0.000 | +7.201 | B/5 | 471-D-C157 | 642.224
Steel Assembly | RIGID_FRAME | 911.8 | +0.000 | +7.201 | B/6 | 471-D-C142 | 642.224
Steel Assembly | RIGID_FRAME | 506.2 | +14.850 | +15.522 | B/5-6 | 471-D-C345 | 575
Steel Assembly | RIGID_FRAME | 346 | +16.773 | +17.450 | B/5-6 | 471-D-C123 | 190
Steel Assembly | RIGID_FRAME | 1077.3 | +6.702 | +17.450 | B/6 | 471-D-C158 | 304.8
Steel Assembly | RIGID_FRAME | 346 | +16.773 | +17.450 | B/4-5 | 471-D-C123 | 190
Steel Assembly | RIGID_FRAME | 1174.5 | +6.702 | +18.700 | B/5 | 471-D-C156 | 304.8
Steel Assembly | RIGID_FRAME | 1266.5 | +6.702 | +19.472 | B/4 | 471-D-C155 | 415.053
Steel Assembly | RIGID_FRAME | 836 | +6.702 | +14.003 | B/3 | 471-D-C154 | 304.8
Steel Assembly | RIGID_FRAME | 1259 | +6.702 | +19.572 | B/2 | 471-D-C153 | 304.8
Steel Assembly | RIGID_FRAME | 10.8 | +70.470 | +70.540 | D-E/2-3 | 471-G-F296 | 70
Steel Assembly | RIGID_FRAME | 36 | +70.450 | +70.650 | D-E/2-3 | 471-G-F2 | 405.943
Steel Assembly | RIGID_FRAME | 9.4 | +70.470 | +70.540 | D-E/2-3 | 471-G-F295 | 70
Steel Assembly | RIGID_FRAME | 12.8 | +68.270 | +68.340 | D-E/2-3 | 471-G-F294 | 70
Steel Assembly | RIGID_FRAME | 358.9 | +14.599 | +15.300 | B/3-4 | 471-D-C347 | 575
Steel Assembly | RIGID_FRAME | 13.8 | +66.070 | +66.140 | D-E/2-3 | 471-G-F293 | 70
Steel Assembly | RIGID_FRAME | 33.7 | +66.050 | +66.250 | E/2-3 | 471-G-F1 | 305.215
Steel Assembly | RIGID_FRAME | 185.9 | +12.525 | +14.925 | B/3-4 | 471-D-C433 | 219.1
Steel Assembly | RIGID_FRAME | 246.7 | +15.215 | +17.079 | B/5-6 | 471-D-C454 | 219.1
Steel Assembly | RIGID_FRAME | 246.7 | +15.215 | +17.079 | B/4-5 | 471-D-C454 | 219.1
Steel Assembly | RIGID_FRAME | 14.2 | +48.520 | +48.590 | D-E/2-3 | 471-F-E193 | 70
Steel Assembly | RIGID_FRAME | 29.3 | +48.500 | +48.700 | E/2-3 | 471-F-E18 | 310.45
Steel Assembly | RIGID_FRAME | 78.5 | +46.813 | +48.700 | D-E/2-3 | 471-F-E8 | 136
Steel Assembly | RIGID_FRAME | 109.1 | +48.500 | +51.153 | D-E/2-3 | 471-G-F22 | 136
Steel Assembly | RIGID_FRAME | 302.6 | +12.525 | +15.319 | B/2-3 | 471-D-C432 | 219.1
Steel Assembly | RIGID_FRAME | 311.3 | +5.775 | +12.069 | B/3-4 | 471-D-C436 | 219.1
Steel Assembly | RIGID_FRAME | 364.9 | +5.725 | +12.119 | B/4-5 | 471-D-C425 | 219.1
Steel Assembly | RIGID_FRAME | 364.9 | +5.725 | +12.119 | B/5-6 | 471-D-C425 | 219.1
Steel Assembly | RIGID_FRAME | 360.8 | +4.992 | +6.048 | B/5-6 | 471-D-C121 | 190
Steel Assembly | RIGID_FRAME | 362.7 | +4.992 | +6.048 | B/4-5 | 471-D-C49 | 190
Steel Assembly | RIGID_FRAME | 270.4 | +4.949 | +6.080 | B/3-4 | 471-D-C131 | 315
Steel Assembly | RIGID_FRAME | 392.4 | +5.725 | +12.119 | B/2-3 | 471-D-C435 | 219.1
Steel Assembly | RIGID_FRAME | 455.9 | +4.991 | +6.052 | B/2-3 | 471-D-C31 | 203.5
Steel Assembly | RIGID_FRAME | 261 | +5.725 | +10.209 | B/1-2 | 471-D-C434 | 219.1
Steel Assembly | RIGID_FRAME | 310.7 | +9.885 | +10.925 | B/1-2 | 471-D-C112 | 196.75
Steel Assembly | RIGID_FRAME | 178.7 | +10.615 | +12.119 | B/1-2 | 471-D-C447 | 219.1
Steel Assembly | RIGID_FRAME | 309.2 | +11.809 | +12.840 | B/1-2 | 471-D-C75 | 315
2 x Steel Assembly | RIGID_FRAME | 148.7 | +12.525 | +15.314 | B/1-2 | 471-D-C448 | 219.1
Steel Assembly | RIGID_FRAME | 309.6 | +15.725 | +19.101 | B/2-3 | 471-D-C453 | 219.1
Steel Assembly | RIGID_FRAME | 168.3 | +18.357 | +19.101 | B/3-4 | 471-D-C455 | 219.1
Steel Assembly | RIGID_FRAME | 465.9 | +18.780 | +19.572 | B/2-3 | 471-D-C126 | 605
Steel Assembly | RIGID_FRAME | 26.9 | +19.116 | +19.472 | B/3 | 471-D-C135 | 190
Steel Assembly | RIGID_FRAME | 16.5 | +63.270 | +63.340 | D-E/2-3 | 471-G-F288 | 70
Steel Assembly | RIGID_FRAME | 15.6 | +63.270 | +63.340 | D-E/2-3 | 471-G-F289 | 70
Steel Assembly | RIGID_FRAME | 12.8 | +60.555 | +60.625 | D-E/2-3 | 471-G-F290 | 70
Steel Assembly | RIGID_FRAME | 117.8 | +55.105 | +58.020 | D-E/2-3 | 471-G-F5 | 136
Steel Assembly | RIGID_FRAME | 117.8 | +57.820 | +60.735 | D-E/2-3 | 471-G-F10 | 136
Steel Assembly | RIGID_FRAME | 11.6 | +57.840 | +57.910 | D-E/2-3 | 471-G-F291 | 70
Steel Assembly | RIGID_FRAME | 27.4 | +57.820 | +58.020 | E/2-3 | 471-G-F34 | 310.521
Steel Assembly | RIGID_FRAME | 27.4 | +57.820 | +58.020 | D/2-3 | 471-G-F35 | 310.521
Steel Assembly | RIGID_FRAME | 15.8 | +55.125 | +55.195 | D-E/2-3 | 471-G-F292 | 70
Steel Assembly | RIGID_FRAME | 11.6 | +52.860 | +52.930 | D-E/2-3 | 471-G-F291 | 70
Steel Assembly | RIGID_FRAME | 27.4 | +52.840 | +53.040 | D/2-3 | 471-G-F33 | 310.521
Steel Assembly | RIGID_FRAME | 27.4 | +52.840 | +53.040 | E/2-3 | 471-G-F32 | 310.521
Steel Assembly | RIGID_FRAME | 57.5 | +50.953 | +51.153 | D-E/2-3 | 471-G-F187 | 280.927
Steel Assembly | RIGID_FRAME | 58.8 | +50.953 | +51.153 | D-E/2-3 | 471-G-F31 | 230.627
Steel Assembly | RIGID_FRAME | 86.3 | +50.953 | +53.040 | D/2-3 | 471-G-F19 | 136
Steel Assembly | RIGID_FRAME | 86.3 | +50.953 | +53.040 | D-E/2-3 | 471-G-F21 | 136
Steel Assembly | RIGID_FRAME | 109.1 | +48.500 | +51.153 | E/2-3 | 471-G-F4 | 136
Steel Assembly | RIGID_FRAME | 12.8 | +50.973 | +51.043 | D-E/2-3 | 471-G-F290 | 70
Steel Assembly | RIGID_FRAME | 7.8 | +51.153 | +52.258 | D/2-3 | 471-G-F306 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +51.153 | +52.258 | E/2-3 | 471-G-F305 | 70.0002
Steel Assembly | RIGID_FRAME | 30.2 | +50.801 | +50.953 | D-E/2-3 | 471-G-F215 | 152.4
Steel Assembly | RIGID_FRAME | 8.2 | +50.978 | +52.258 | D-E/2-3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +50.978 | +52.258 | D-E/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 57.5 | +46.813 | +47.013 | D-E/2-3 | 471-F-E84 | 280.927
Steel Assembly | RIGID_FRAME | 58.8 | +46.813 | +47.013 | D-E/2-3 | 471-F-E17 | 230.627
Steel Assembly | RIGID_FRAME | 78.5 | +46.813 | +48.700 | D/2-3 | 471-F-E7 | 136
Steel Assembly | RIGID_FRAME | 108.8 | +44.375 | +47.013 | D-E/2-3 | 471-F-E5 | 136
Steel Assembly | RIGID_FRAME | 108.8 | +44.375 | +47.013 | E/2-3 | 471-F-E6 | 136
Steel Assembly | RIGID_FRAME | 12.8 | +46.833 | +46.903 | D-E/2-3 | 471-F-E192 | 70
Steel Assembly | RIGID_FRAME | 7.8 | +47.013 | +48.118 | D/2-3 | 471-F-E201 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +47.013 | +48.118 | E/2-3 | 471-F-E200 | 70.0002
Steel Assembly | RIGID_FRAME | 30.2 | +46.661 | +46.813 | D-E/2-3 | 471-F-E142 | 152.4
Steel Assembly | RIGID_FRAME | 8.2 | +46.838 | +48.118 | D-E/2-3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +46.838 | +48.118 | D-E/2-3 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 118.7 | +41.606 | +44.575 | D-E/2-3 | 471-F-E1 | 136
Steel Assembly | RIGID_FRAME | 118.7 | +41.606 | +44.575 | D/2-3 | 471-F-E3 | 136
Steel Assembly | RIGID_FRAME | 15 | +44.395 | +44.465 | D-E/2-3 | 471-F-E191 | 70
Steel Assembly | RIGID_FRAME | 12.8 | +41.626 | +41.696 | D-E/2-3 | 471-F-E192 | 70
Steel Assembly | RIGID_FRAME | 57.5 | +41.606 | +41.806 | D-E/2-3 | 471-F-E84 | 280.927
Steel Assembly | RIGID_FRAME | 58.8 | +41.606 | +41.806 | D-E/2-3 | 471-F-E17 | 230.627
Steel Assembly | RIGID_FRAME | 118.7 | +38.838 | +41.806 | D-E/2-3 | 471-F-E2 | 136
Steel Assembly | RIGID_FRAME | 118.7 | +38.838 | +41.806 | E/2-3 | 471-F-E4 | 136
Steel Assembly | RIGID_FRAME | 7.8 | +41.806 | +42.911 | D/2-3 | 471-F-E201 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +41.806 | +42.911 | E/2-3 | 471-F-E200 | 70.0002
Steel Assembly | RIGID_FRAME | 30.2 | +41.454 | +41.606 | D-E/2-3 | 471-F-E142 | 152.4
Steel Assembly | RIGID_FRAME | 8.2 | +41.631 | +42.911 | D-E/2-3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +41.631 | +42.911 | D-E/2-3 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 118.7 | +36.070 | +39.038 | D-E/2-3 | 471-F-E1 | 136
Steel Assembly | RIGID_FRAME | 118.7 | +36.070 | +39.038 | D/2-3 | 471-F-E3 | 136
Steel Assembly | RIGID_FRAME | 15 | +38.858 | +38.928 | D-E/2-3 | 471-F-E191 | 70
Steel Assembly | RIGID_FRAME | 206.4 | +69.951 | +70.650 | C-D/3 | 471-G-F82 | 180
2 x Steel Assembly | RIGID_FRAME | 109.5 | +70.294 | +70.650 | C-D/3 | 471-G-F70 | 190
Steel Assembly | RIGID_FRAME | 53.2 | +70.450 | +70.650 | C-D/3-4 | 471-G-F177 | 332.719
Steel Assembly | RIGID_FRAME | 53.3 | +70.450 | +70.650 | C-D/3-4 | 471-G-F176 | 332.719
Steel Assembly | RIGID_FRAME | 53.6 | +70.450 | +70.650 | C-D/3-4 | 471-G-F180 | 314.617
Steel Assembly | RIGID_FRAME | 53.5 | +70.450 | +70.650 | C-D/3-4 | 471-G-F174 | 323.651
Steel Assembly | RIGID_FRAME | 130.2 | +66.050 | +66.250 | C-D/2-3 | 471-G-F141 | 326.673
Steel Assembly | RIGID_FRAME | 46.6 | +66.050 | +66.250 | C-D/2-3 | 471-G-F160 | 345.692
Steel Assembly | RIGID_FRAME | 253.2 | +62.762 | +63.450 | C-D/3 | 471-G-F64 | 180
Steel Assembly | RIGID_FRAME | 63.5 | +63.094 | +63.450 | C-D/3 | 471-G-F45 | 190
Steel Assembly | RIGID_FRAME | 106.9 | +63.094 | +63.450 | C-D/3 | 471-G-F65 | 190
Steel Assembly | RIGID_FRAME | 63.5 | +54.949 | +55.305 | C-D/3 | 471-G-F60 | 190
Steel Assembly | RIGID_FRAME | 296.4 | +43.887 | +44.575 | C-D/3 | 471-F-E35 | 180
2 x Steel Assembly | RIGID_FRAME | 63.5 | +44.219 | +44.575 | C-D/3 | 471-F-E38 | 190
Steel Assembly | RIGID_FRAME | 297.7 | +35.572 | +36.270 | C-D/3 | 471-E-D28 | 180
2 x Steel Assembly | RIGID_FRAME | 63 | +35.914 | +36.270 | C-D/3 | 471-E-D30 | 190
Steel Assembly | RIGID_FRAME | 297.1 | +28.382 | +29.080 | C-D/3 | 471-E-D27 | 180
Steel Assembly | RIGID_FRAME | 63 | +28.724 | +29.080 | C-D/3 | 471-E-D31 | 190
Steel Assembly | RIGID_FRAME | 63 | +28.724 | +29.080 | C-D/3 | 471-E-D30 | 190
Steel Assembly | RIGID_FRAME | 53.6 | +55.105 | +55.305 | C-D/3-4 | 471-G-F180 | 314.617
Steel Assembly | RIGID_FRAME | 53.5 | +55.105 | +55.305 | C-D/3-4 | 471-G-F174 | 323.651
Steel Assembly | RIGID_FRAME | 53.2 | +55.105 | +55.305 | C-D/3-4 | 471-G-F177 | 332.719
Steel Assembly | RIGID_FRAME | 53.3 | +55.105 | +55.305 | C-D/3-4 | 471-G-F176 | 332.719
Steel Assembly | RIGID_FRAME | 53.5 | +55.105 | +55.305 | C-D/3-4 | 471-G-F175 | 323.651
Steel Assembly | RIGID_FRAME | 53.6 | +44.375 | +44.575 | C-D/3-4 | 471-F-E70 | 314.617
Steel Assembly | RIGID_FRAME | 53.5 | +44.375 | +44.575 | C-D/3-4 | 471-F-E130 | 323.651
Steel Assembly | RIGID_FRAME | 53.2 | +44.375 | +44.575 | C-D/3-4 | 471-F-E133 | 332.719
Steel Assembly | RIGID_FRAME | 53.3 | +44.375 | +44.575 | C-D/3-4 | 471-F-E132 | 332.719
Steel Assembly | RIGID_FRAME | 53.5 | +44.375 | +44.575 | C-D/3-4 | 471-F-E131 | 323.651
Steel Assembly | RIGID_FRAME | 53.6 | +36.070 | +36.270 | C-D/3-4 | 471-E-D87 | 314.617
Steel Assembly | RIGID_FRAME | 53.5 | +36.070 | +36.270 | C-D/3-4 | 471-E-D83 | 323.651
Steel Assembly | RIGID_FRAME | 53.2 | +36.070 | +36.270 | C-D/3-4 | 471-E-D86 | 332.719
Steel Assembly | RIGID_FRAME | 53.3 | +36.070 | +36.270 | C-D/3-4 | 471-E-D85 | 332.719
Steel Assembly | RIGID_FRAME | 53.5 | +36.070 | +36.270 | C-D/3-4 | 471-E-D84 | 323.651
Steel Assembly | RIGID_FRAME | 53.6 | +28.880 | +29.080 | C-D/3-4 | 471-E-D87 | 314.617
Steel Assembly | RIGID_FRAME | 53.5 | +28.880 | +29.080 | C-D/3-4 | 471-E-D83 | 323.651
Steel Assembly | RIGID_FRAME | 53.2 | +28.880 | +29.080 | C-D/3-4 | 471-E-D86 | 332.719
Steel Assembly | RIGID_FRAME | 53.3 | +28.880 | +29.080 | C-D/3-4 | 471-E-D85 | 332.719
Steel Assembly | RIGID_FRAME | 53.5 | +28.880 | +29.080 | C-D/3-4 | 471-E-D84 | 323.651
Steel Assembly | RIGID_FRAME | 17 | +36.090 | +36.160 | D-E/2-3 | 471-E-D142 | 70
