Properties of the parts of a building model (IFC2X3), part 5 of 22

# IfcBeam: UC305*305*158 (28)
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Volume (m3) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | +0.040 | +12.000 | 3 | 3 | 1889.7 | 0.2 | 22.3 | 11960 | ma-183 | 21.9981 | 0.237789 | 1866.65
COLUMN | +0.040 | +12.000 | 3 | 3 | 1889.7 | 0.2 | 22.3 | 11960 | ma-185 | 21.9981 | 0.237789 | 1866.65
COLUMN | +0.040 | +12.000 | 3 | 3 | 1889.7 | 0.2 | 22.3 | 11960 | ma-182 | 21.9981 | 0.237789 | 1866.65
COLUMN | +0.040 | +12.000 | 3 | 3 | 1889.7 | 0.2 | 22.3 | 11960 | ma-181 | 21.9981 | 0.237789 | 1866.65
COLUMN | +0.040 | +12.000 | 3 | 3 | 1889.7 | 0.2 | 22.3 | 11960 | ma-184 | 21.9981 | 0.237789 | 1866.65
COLUMN | +0.040 | +12.000 | 3 | 3 | 1889.7 | 0.2 | 22.3 | 11960 | ma-180 | 21.9981 | 0.237789 | 1866.65
COLUMN | +0.040 | +12.000 | 3 | 3 | 1889.7 | 0.2 | 22.3 | 11960 | ma-179 | 21.9981 | 0.237789 | 1866.65
COLUMN | +12.002 | +18.400 | 4 | 3 | 1010.9 | 0.1 | 12 | 6398 | mb-200 | 11.7679 | 0.127205 | 998.562
COLUMN | +12.002 | +25.302 | 4 | 3 | 2101.4 | 0.3 | 24.8 | 13300 | mb-199 | 24.4627 | 0.264431 | 2075.78
COLUMN | +25.304 | +37.269 | 6 | 10 | 1890.5 | 0.2 | 22.4 | 11965 | md-146 | 22.0073 | 0.237889 | 1867.43
COLUMN | +25.304 | +37.269 | 6 | 10 | 1890.5 | 0.2 | 22.4 | 11965 | md-145 | 22.0073 | 0.237889 | 1867.43
COLUMN | +12.002 | +25.302 | 4 | 3 | 2101.4 | 0.3 | 24.8 | 13300 | mb-198 | 24.4627 | 0.264431 | 2075.78
COLUMN | +12.002 | +25.302 | 4 | 3 | 2101.4 | 0.3 | 24.8 | 13300 | mb-197 | 24.4627 | 0.264431 | 2075.78
COLUMN | +12.002 | +25.302 | 4 | 3 | 2101.4 | 0.3 | 24.8 | 13300 | mb-196 | 24.4627 | 0.264431 | 2075.78
COLUMN | +12.002 | +16.000 | 4 | 3 | 631.7 | 0.1 | 7.4 | 3998 | mb-195 | 7.35354 | 0.0794884 | 623.984
COLUMN | +12.002 | +18.050 | 4 | 3 | 955.6 | 0.1 | 11.3 | 6048 | mb-194 | 11.1241 | 0.120247 | 943.936
COLUMN | +12.002 | +18.050 | 4 | 3 | 955.6 | 0.1 | 11.3 | 6048 | mb-193 | 11.1241 | 0.120247 | 943.936
COLUMN | +0.040 | +12.000 | 3 | 3 | 1889.7 | 0.2 | 22.3 | 11960 | ma-178 | 21.9981 | 0.237789 | 1866.65
COLUMN | +25.304 | +37.269 | 6 | 10 | 1890.5 | 0.2 | 22.4 | 11965 | md-143 | 22.0073 | 0.237889 | 1867.43
COLUMN | +12.002 | +25.302 | 4 | 3 | 2101.4 | 0.3 | 24.8 | 13300 | mb-192 | 24.4627 | 0.264431 | 2075.78
COLUMN | +25.304 | +37.269 | 6 | 10 | 1890.5 | 0.2 | 22.4 | 11965 | md-142 | 22.0073 | 0.237889 | 1867.43
COLUMN | +12.002 | +25.302 | 4 | 3 | 2101.4 | 0.3 | 24.8 | 13300 | mb-191 | 24.4627 | 0.264431 | 2075.78
COLUMN | +25.304 | +37.269 | 6 | 10 | 1890.5 | 0.2 | 22.4 | 11965 | md-141 | 22.0073 | 0.237889 | 1867.43
COLUMN | +25.304 | +37.269 | 6 | 10 | 1890.5 | 0.2 | 22.4 | 11965 | md-144 | 22.0073 | 0.237889 | 1867.43

# IfcBeam: UC305*305*97 (42)
In: Undefined
Description: UC305*305*97; Material: STEEL/S355JR
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 18.4 m2; Height: 307.8 mm; Width: 304.8 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Volume (m3) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | +6.702 | +17.450 | 5 | 3 | 1041.5 | 0.1 | 19.5 | 10748 | mc-164 | 19.2271 | 0.130375 | 1023.44
COLUMN | +6.702 | +18.700 | 5 | 3 | 1162.6 | 0.1 | 21.8 | 11998 | mc-162 | 21.4633 | 0.145537 | 1142.47
COLUMN | +6.702 | +19.472 | 5 | 3 | 1237.4 | 0.2 | 23.2 | 12770 | mc-161 | 22.8443 | 0.154902 | 1215.98
COLUMN | +6.702 | +13.502 | 5 | 3 | 658.9 | 0.1 | 12.4 | 6800 | mc-160 | 12.1645 | 0.082485 | 647.507
2 x COLUMN | +3.550 | +12.090 | 153 | 2 | 827.5 | 0.1 | 15.5 | 8540 | 471-0-010012 | 15.2772 | 0.103591 | 813.192
COLUMN | +3.550 | +12.090 | 153 | 2 | 827.5 | 0.1 | 15.5 | 8540 | 471-0-010010 | 15.2772 | 0.103591 | 813.192
COLUMN | +3.550 | +12.090 | 153 | 2 | 827.5 | 0.1 | 15.5 | 8540 | 471-0-010011 | 15.2772 | 0.103591 | 813.192
COLUMN | +3.550 | +12.090 | 153 | 2 | 827.5 | 0.1 | 15.5 | 8540 | 471-0-010009 | 15.2772 | 0.103591 | 813.192
COLUMN | +6.702 | +19.572 | 5 | 3 | 1247.1 | 0.2 | 23.4 | 12870 | mc-159 | 23.0232 | 0.156115 | 1225.5
COLUMN | +6.702 | +15.700 | 5 | 3 | 871.9 | 0.1 | 16.4 | 8998 | mc-158 | 16.0966 | 0.109147 | 856.804
COLUMN | +0.025 | +6.700 | 5 | 3 | 646.8 | 0.1 | 12.1 | 6675 | mc-157 | 11.9409 | 0.0809687 | 635.604
COLUMN | +0.025 | +12.500 | 5 | 3 | 1208.8 | 0.2 | 22.7 | 12475 | mc-155 | 22.3166 | 0.151323 | 1187.89
COLUMN | +0.025 | +6.700 | 5 | 3 | 646.8 | 0.1 | 12.1 | 6675 | mc-154 | 11.9409 | 0.0809687 | 635.604
COLUMN | +0.025 | +12.500 | 5 | 3 | 1208.8 | 0.2 | 22.6 | 12475 | mc-153 | 22.3166 | 0.150791 | 1183.71
COLUMN | +0.025 | +6.700 | 5 | 3 | 646.8 | 0.1 | 12.1 | 6675 | mc-152 | 11.9409 | 0.0809687 | 635.604
COLUMN | +0.025 | +12.500 | 5 | 3 | 1208.8 | 0.2 | 22.7 | 12475 | mc-151 | 22.3166 | 0.151323 | 1187.89
COLUMN | +0.025 | +6.700 | 5 | 3 | 646.8 | 0.1 | 12.1 | 6675 | mc-156 | 11.9409 | 0.0809687 | 635.604
COLUMN | +13.504 | +21.785 | 5 | 3 | 802.4 | 0.1 | 15.1 | 8281 | mc-150 | 14.8139 | 0.10045 | 788.53
COLUMN | +49.703 | +59.203 | 8 | 3 | 920.6 | 0.1 | 17.3 | 9500 | mf-104 | 16.9946 | 0.115236 | 904.605
COLUMN | +49.703 | +59.203 | 8 | 3 | 920.6 | 0.1 | 17.3 | 9500 | mf-103 | 16.9946 | 0.115236 | 904.605
COLUMN | +59.205 | +70.650 | 8 | 3 | 1109 | 0.1 | 20.8 | 11445 | mf-101 | 20.474 | 0.138829 | 1089.81
COLUMN | +59.205 | +70.650 | 8 | 3 | 1109 | 0.1 | 20.8 | 11445 | mf-100 | 20.474 | 0.138829 | 1089.81
COLUMN | +0.025 | +6.700 | 5 | 3 | 646.8 | 0.1 | 12.1 | 6675 | mc-163 | 11.9409 | 0.0809687 | 635.604
COLUMN | +0.025 | +12.500 | 5 | 3 | 1208.8 | 0.2 | 22.7 | 12475 | mc-149 | 22.3166 | 0.151323 | 1187.89
COLUMN | +49.703 | +59.203 | 8 | 3 | 920.6 | 0.1 | 17.3 | 9500 | mf-99 | 16.9946 | 0.115236 | 904.605
COLUMN | +59.205 | +70.650 | 8 | 3 | 1109 | 0.1 | 20.8 | 11445 | mf-98 | 20.474 | 0.138829 | 1089.81
COLUMN | +59.205 | +70.650 | 8 | 3 | 1109 | 0.1 | 20.8 | 11445 | mf-97 | 20.474 | 0.138829 | 1089.81
COLUMN | +49.703 | +59.203 | 8 | 3 | 920.6 | 0.1 | 17.3 | 9500 | mf-102 | 16.9946 | 0.115236 | 904.605
COLUMN | +59.205 | +70.650 | 8 | 3 | 1109 | 0.1 | 20.8 | 11445 | mf-96 | 20.474 | 0.138829 | 1089.81
COLUMN | +0.025 | +6.700 | 5 | 3 | 646.8 | 0.1 | 12.1 | 6675 | mc-148 | 11.9409 | 0.0809687 | 635.604
COLUMN | +0.025 | +12.500 | 5 | 3 | 1208.8 | 0.2 | 22.7 | 12475 | mc-146 | 22.3166 | 0.151323 | 1187.89
COLUMN | +0.025 | +12.500 | 5 | 3 | 1208.8 | 0.2 | 22.7 | 12475 | mc-147 | 22.3166 | 0.151323 | 1187.89
COLUMN | +59.205 | +70.650 | 8 | 3 | 1109 | 0.1 | 20.8 | 11445 | mf-95 | 20.474 | 0.138829 | 1089.81
COLUMN | +49.703 | +59.203 | 8 | 3 | 920.6 | 0.1 | 17.3 | 9500 | mf-94 | 16.9946 | 0.115236 | 904.605
COLUMN | +49.703 | +59.203 | 8 | 3 | 920.6 | 0.1 | 17.3 | 9500 | mf-93 | 16.9946 | 0.115236 | 904.605
COLUMN | +37.271 | +49.701 | 7 | 3 | 1204.5 | 0.2 | 22.6 | 12430 | me-60 | 22.2361 | 0.150778 | 1183.6
COLUMN | +37.271 | +49.701 | 7 | 3 | 1204.5 | 0.2 | 22.6 | 12430 | me-59 | 22.2361 | 0.150778 | 1183.6
COLUMN | +37.271 | +49.701 | 7 | 3 | 1204.5 | 0.2 | 22.6 | 12430 | me-58 | 22.2361 | 0.150778 | 1183.6
COLUMN | +37.271 | +49.701 | 7 | 3 | 1204.5 | 0.2 | 22.6 | 12430 | me-57 | 22.2361 | 0.150778 | 1183.6
COLUMN | +37.271 | +49.701 | 7 | 3 | 1204.5 | 0.2 | 22.6 | 12430 | me-56 | 22.2361 | 0.150778 | 1183.6
COLUMN | +37.271 | +49.701 | 7 | 3 | 1204.5 | 0.2 | 22.6 | 12430 | me-55 | 22.2361 | 0.150778 | 1183.6

# IfcCovering: SASOL SPEC SP-80-02-REV 4 (9338)
Material: Undefined/Undefined

# IfcDiscreteAccessory: ASS. PART (6)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Phase: 7; Class: 13
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x ASS. PART | L80*80*8 | +37.910 | +37.990 | 14 | 0.1 | 32.3 | 0.5 | 80 | 80 | 1447.3 | me-104 | 0.450723 | 0.00122675 | 0.00175996 | 0.00177552
ASS. PART | PC200*75 | +37.900 | +38.100 | 25.5 | 0.1 | 27.8 | 0.6 | 200 | 75 | 1050 | me-177 | 0.708975 | 0.00309554 | 0.00319095 | 0.00325032
ASS. PART | PC200*75 | +37.900 | +38.100 | 29.2 | 0.1 | 27.8 | 0.8 | 200 | 75 | 1200 | me-176 | 0.810257 | 0.00309554 | 0.0036468 | 0.00371465
ASS. PART | PC200*75 | +37.900 | +38.100 | 59.6 | 0.2 | 27.8 | 1.7 | 200 | 75 | 2454 | me-174 | 1.65698 | 0.00309554 | 0.00745771 | 0.00759646
ASS. PART | PC200*75 | +37.900 | +38.100 | 29.2 | 0.1 | 27.8 | 0.8 | 200 | 75 | 1200 | me-175 | 0.810257 | 0.00309554 | 0.0036468 | 0.00371465

# IfcDiscreteAccessory: BASE PLATE (44)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
3 x BASE PLATE | PLT12*250 | +0.000 | +0.012 | 5 | 1 | 5.9 | 0.1 | 23.3 | 0.1 | 250 | 12 | 250 | pc-61 | 0.137 | 0.0625 | 0.000144 | 0.00075
12 x BASE PLATE | PLT25*560 | +0.000 | +0.025 | 5 | 1 | 61.5 | 0.3 | 11.1 | 0.6 | 560 | 25 | 560 | pc-429 | 0.6832 | 0.3136 | 0.000625 | 0.00784
12 x BASE PLATE | PLT40*560 | +0.000 | +0.040 | 3 | 1 | 98.5 | 0.3 | 7.3 | 0.6 | 560 | 40 | 560 | pa-238 | 0.7168 | 0.3136 | 0.0016 | 0.012544
16 x BASE PLATE | FL10*80 | +5.614 | +5.694 | 3 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pa-62 | 0.0304 | 0.0304 | 0.0016 | 0.000128
BASE PLATE | PLT16*220 | +2.750 | +2.766 | 5 | 8 | 6.3 | 0.1 | 18.1 | 0.1 | 220 | 16 | 230 | pc-364 | 0.1156 | 0.1156 | 0.00352 | 0.0008096

# IfcDiscreteAccessory: BEAM (133)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
BEAM | PFC200*75 | +70.308 | +70.450 | 8 | 3 | 3.4 | 0 | 27.8 | 0.1 | 200 | 75 | 141.6 | mf-48 | 0.0956103 | 0.00309554 | 0.000430322 | 0.000438329
BEAM | PFC200*75 | +65.908 | +66.050 | 8 | 3 | 3.4 | 0 | 27.8 | 0.1 | 200 | 75 | 141.6 | mf-48 | 0.0956103 | 0.00309554 | 0.000430322 | 0.000438329
BEAM | PFC200*75 | +54.963 | +55.105 | 8 | 3 | 3.4 | 0 | 27.8 | 0.1 | 200 | 75 | 141.6 | mf-48 | 0.0956103 | 0.00309554 | 0.000430322 | 0.000438329
2 x BEAM | PFC200*75 | +2.500 | +2.700 | 5 | 4 | 7.7 | 0 | 27.8 | 0.2 | 200 | 75 | 316.5 | mc-38 | 0.213729 | 0.00309554 | 0.000843744 | 0.000979847
BEAM | PFC200*75 | +2.500 | +2.700 | 5 | 4 | 7.7 | 0 | 27.8 | 0.2 | 200 | 75 | 316.5 | mc-36 | 0.213729 | 0.00309554 | 0.000843744 | 0.000979847
3 x BEAM | IPE200 | +15.358 | +15.500 | 5 | 23 | 3.2 | 0 | 34.3 | 0.1 | 200 | 100 | 141.6 | mc-192 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
4 x BEAM | SHS250*250*10.0 | +14.950 | +15.200 | 5 | 6 | 23 | 0.1 | 13.3 | 0.3 | 250 | 250 | 315 | mc-323 | 0.30148 | 0.00926115 | 0.003024 | 0.00291726
BEAM | UB356*171*51 | +19.116 | +19.472 | 5 | 6 | 20.6 | 0.1 | 26.8 | 0.6 | 355.6 | 171.5 | 404.3 | mc-140 | 0.551837 | 0.00649682 | 0.00257608 | 0.00262634
3 x BEAM | IPE200 | +5.358 | +5.500 | 5 | 23 | 3.2 | 0 | 34.3 | 0.1 | 200 | 100 | 141.6 | mc-192 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
BEAM | PFC200*75 | +13.900 | +14.100 | 5 | 3 | 26 | 0.1 | 27.8 | 0.6 | 200 | 75 | 1070.2 | mc-32 | 0.722585 | 0.00309554 | 0.003039 | 0.00331271
BEAM | PFC200*75 | +13.900 | +14.100 | 5 | 3 | 26 | 0.1 | 27.8 | 0.6 | 200 | 75 | 1070.2 | mc-31 | 0.722585 | 0.00309554 | 0.003039 | 0.00331271
BEAM | PFC200*75 | +12.510 | +14.100 | 5 | 3 | 59.1 | 0 | 27.8 | 1.6 | 200 | 75 | 2432 | mc-30 | 1.64213 | 0.00309554 | 0.00705153 | 0.00752839
BEAM | PFC200*75 | +12.510 | +14.100 | 5 | 3 | 59.1 | 0 | 27.8 | 1.6 | 200 | 75 | 2432 | mc-29 | 1.64213 | 0.00309554 | 0.00705153 | 0.00752839
6 x BEAM | IPE200 | +21.118 | +21.260 | 4 | 23 | 3.2 | 0 | 34.3 | 0.1 | 200 | 100 | 141.6 | mb-91 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
3 x BEAM | IPE200 | +17.708 | +17.850 | 4 | 23 | 3.2 | 0 | 34.3 | 0.1 | 200 | 100 | 141.6 | mb-91 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
BEAM | IPE200 | +15.358 | +15.500 | 4 | 23 | 3.2 | 0 | 34.3 | 0.1 | 200 | 100 | 141.6 | mb-91 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
12 x BEAM | IPE200 | +10.248 | +10.390 | 3 | 23 | 3.2 | 0 | 34.3 | 0.1 | 200 | 100 | 141.6 | ma-98 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
BEAM | IPE180 | +10.248 | +10.390 | 3 | 23 | 2.7 | 0 | 37.1 | 0.1 | 180 | 91 | 141.6 | ma-223 | 0.0988295 | 0.0023949 | 0.000329248 | 0.000339118
3 x BEAM | IPE200 | +5.358 | +5.500 | 3 | 23 | 3.2 | 0 | 34.3 | 0.1 | 200 | 100 | 141.6 | ma-98 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
BEAM | PFC200*75 | +68.250 | +68.450 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 99.5 | mf-46 | 0.0671839 | 0.00309554 | 0.000195778 | 0.000308007
BEAM | PFC200*75 | +68.250 | +68.450 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 99.5 | mf-47 | 0.0671839 | 0.00309554 | 0.000195778 | 0.000308007
BEAM | PFC200*75 | +63.250 | +63.450 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100.7 | mf-44 | 0.0679765 | 0.00309554 | 0.000201896 | 0.00031164
BEAM | PFC200*75 | +63.250 | +63.450 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100.7 | mf-45 | 0.0679765 | 0.00309554 | 0.000201896 | 0.00031164
BEAM | PFC200*75 | +57.820 | +58.020 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100.7 | mf-44 | 0.0679904 | 0.00309554 | 0.000201959 | 0.000311704
BEAM | PFC200*75 | +57.820 | +58.020 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100.7 | mf-45 | 0.0679904 | 0.00309554 | 0.000201959 | 0.000311704
BEAM | PFC200*75 | +52.840 | +53.040 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.7 | mf-42 | 0.0686991 | 0.00309554 | 0.000207383 | 0.000314953
BEAM | PFC200*75 | +52.840 | +53.040 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.7 | mf-43 | 0.0686991 | 0.00309554 | 0.000207383 | 0.000314953
BEAM | PFC200*75 | +44.375 | +44.575 | 7 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100 | me-9 | 0.0674673 | 0.00309554 | 0.000197979 | 0.000309306
BEAM | PFC200*75 | +44.375 | +44.575 | 7 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100 | me-10 | 0.0674673 | 0.00309554 | 0.000197979 | 0.000309306
BEAM | PFC200*75 | +38.838 | +39.038 | 7 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100 | me-9 | 0.0674765 | 0.00309554 | 0.00019805 | 0.000309348
BEAM | PFC200*75 | +38.838 | +39.038 | 7 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100 | me-10 | 0.0674765 | 0.00309554 | 0.00019805 | 0.000309348
BEAM | PFC200*75 | +33.799 | +33.999 | 6 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.7 | md-16 | 0.0686201 | 0.00309554 | 0.000206791 | 0.000314591
BEAM | PFC200*75 | +33.799 | +33.999 | 6 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.7 | md-17 | 0.0686201 | 0.00309554 | 0.000206791 | 0.000314591
BEAM | PFC200*75 | +28.880 | +29.080 | 6 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.4 | md-16 | 0.0684655 | 0.00309554 | 0.000205619 | 0.000313882
BEAM | PFC200*75 | +28.880 | +29.080 | 6 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.4 | md-17 | 0.0684655 | 0.00309554 | 0.000205619 | 0.000313882
BEAM | PFC200*75 | +24.118 | +24.318 | 4 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.4 | mb-18 | 0.0684419 | 0.00309554 | 0.000205438 | 0.000313774
BEAM | PFC200*75 | +24.118 | +24.318 | 4 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.4 | mb-19 | 0.0684419 | 0.00309554 | 0.000205438 | 0.000313774
BEAM | PFC200*75 | +15.500 | +15.700 | 4 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100.2 | mb-16 | 0.0676298 | 0.00309554 | 0.000199234 | 0.000310051
BEAM | PFC200*75 | +15.500 | +15.700 | 4 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100.2 | mb-17 | 0.0676298 | 0.00309554 | 0.000199234 | 0.000310051
BEAM | PFC200*75 | +66.050 | +66.250 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 99.5 | mf-47 | 0.0671866 | 0.00309554 | 0.000195791 | 0.000308019
BEAM | PFC200*75 | +66.050 | +66.250 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 99.5 | mf-46 | 0.0671866 | 0.00309554 | 0.000195791 | 0.000308019
BEAM | PFC200*75 | +60.535 | +60.735 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100.7 | mf-45 | 0.0679746 | 0.00309554 | 0.000201888 | 0.000311632
BEAM | PFC200*75 | +60.535 | +60.735 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100.7 | mf-44 | 0.0679746 | 0.00309554 | 0.000201888 | 0.000311632
BEAM | PFC200*75 | +55.105 | +55.305 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.7 | mf-43 | 0.068691 | 0.00309554 | 0.000207325 | 0.000314916
BEAM | PFC200*75 | +55.105 | +55.305 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.7 | mf-42 | 0.068691 | 0.00309554 | 0.000207325 | 0.000314916
BEAM | PFC200*75 | +50.953 | +51.153 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.7 | mf-43 | 0.0686992 | 0.00309554 | 0.000207387 | 0.000314954
BEAM | PFC200*75 | +50.953 | +51.153 | 8 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.7 | mf-42 | 0.0686992 | 0.00309554 | 0.000207387 | 0.000314954
BEAM | PFC200*75 | +46.813 | +47.013 | 7 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 102 | me-12 | 0.0688643 | 0.00309554 | 0.000208628 | 0.000315711
BEAM | PFC200*75 | +46.813 | +47.013 | 7 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 102 | me-11 | 0.0688643 | 0.00309554 | 0.000208628 | 0.000315711
BEAM | PFC200*75 | +41.606 | +41.806 | 7 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100 | me-10 | 0.0674747 | 0.00309554 | 0.000198042 | 0.00030934
BEAM | PFC200*75 | +41.606 | +41.806 | 7 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100 | me-9 | 0.0674747 | 0.00309554 | 0.000198042 | 0.00030934
BEAM | PFC200*75 | +36.070 | +36.270 | 6 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.7 | md-17 | 0.0686221 | 0.00309554 | 0.000206799 | 0.0003146
BEAM | PFC200*75 | +36.070 | +36.270 | 6 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.7 | md-16 | 0.0686221 | 0.00309554 | 0.000206799 | 0.0003146
BEAM | PFC200*75 | +31.528 | +31.728 | 6 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.7 | md-17 | 0.0686372 | 0.00309554 | 0.000206914 | 0.00031467
BEAM | PFC200*75 | +31.528 | +31.728 | 6 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.7 | md-16 | 0.0686372 | 0.00309554 | 0.000206914 | 0.00031467
BEAM | PFC200*75 | +21.260 | +21.460 | 4 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.7 | mb-19 | 0.0685946 | 0.00309554 | 0.000206592 | 0.000314474
BEAM | PFC200*75 | +21.260 | +21.460 | 4 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 101.7 | mb-18 | 0.0685946 | 0.00309554 | 0.000206592 | 0.000314474
BEAM | PFC200*75 | +17.850 | +18.050 | 4 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100.3 | mb-17 | 0.0677225 | 0.00309554 | 0.000199948 | 0.000310476
BEAM | PFC200*75 | +17.850 | +18.050 | 4 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100.3 | mb-16 | 0.0677225 | 0.00309554 | 0.000199948 | 0.000310476
BEAM | PFC200*75 | +12.945 | +13.145 | 4 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100.2 | mb-17 | 0.0676298 | 0.00309554 | 0.000199234 | 0.000310051
BEAM | PFC200*75 | +12.945 | +13.145 | 4 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 100.2 | mb-16 | 0.0676298 | 0.00309554 | 0.000199234 | 0.000310051
BEAM | PFC200*75 | +7.945 | +8.145 | 3 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 102 | ma-11 | 0.0687884 | 0.00309554 | 0.000208059 | 0.000315362
BEAM | PFC200*75 | +7.945 | +8.145 | 3 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 102 | ma-12 | 0.0687884 | 0.00309554 | 0.000208059 | 0.000315362
BEAM | PFC200*75 | +10.390 | +10.590 | 3 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 102 | ma-12 | 0.068789 | 0.00309554 | 0.000208056 | 0.000315365
BEAM | PFC200*75 | +10.390 | +10.590 | 3 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 102 | ma-11 | 0.068789 | 0.00309554 | 0.000208056 | 0.000315365
BEAM | PFC200*75 | +5.500 | +5.700 | 3 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 99.5 | ma-10 | 0.0671838 | 0.00309554 | 0.000195778 | 0.000308006
BEAM | PFC200*75 | +5.500 | +5.700 | 3 | 3 | 2.5 | 0 | 27.8 | 0.1 | 200 | 75 | 99.5 | ma-9 | 0.0671838 | 0.00309554 | 0.000195778 | 0.000308006
BEAM | PFC200*75 | +15.500 | +15.700 | 5 | 3 | 4.5 | 0 | 27.8 | 0.1 | 200 | 75 | 180.9 | mc-42 | 0.122112 | 0.00309554 | 0.000363654 | 0.000559829
BEAM | PFC200*75 | +15.500 | +15.700 | 5 | 3 | 4.5 | 0 | 27.8 | 0.1 | 200 | 75 | 180.9 | mc-41 | 0.122112 | 0.00309554 | 0.000363654 | 0.000559829
BEAM | PFC200*75 | +12.300 | +12.500 | 5 | 3 | 4.9 | 0 | 27.8 | 0.1 | 200 | 75 | 196.6 | mc-40 | 0.13274 | 0.00309554 | 0.000415227 | 0.000608551
BEAM | PFC200*75 | +12.300 | +12.500 | 5 | 3 | 4.9 | 0 | 27.8 | 0.1 | 200 | 75 | 196.6 | mc-39 | 0.13274 | 0.00309554 | 0.000415227 | 0.000608551
BEAM | PFC200*75 | +9.900 | +10.100 | 5 | 3 | 2.3 | 0 | 27.8 | 0 | 200 | 75 | 93.6 | mc-23 | 0.063238 | 0.00309554 | 0.000178019 | 0.000289917
BEAM | PFC200*75 | +9.900 | +10.100 | 5 | 3 | 2.3 | 0 | 27.8 | 0 | 200 | 75 | 93.6 | mc-20 | 0.063238 | 0.00309554 | 0.000178019 | 0.000289917
BEAM | PFC200*75 | +7.700 | +7.900 | 5 | 3 | 2.3 | 0 | 27.8 | 0 | 200 | 75 | 93.6 | mc-23 | 0.063238 | 0.00309554 | 0.000178019 | 0.000289917
BEAM | PFC200*75 | +7.700 | +7.900 | 5 | 3 | 2.3 | 0 | 27.8 | 0 | 200 | 75 | 93.6 | mc-20 | 0.063238 | 0.00309554 | 0.000178019 | 0.000289917
BEAM | PFC200*75 | +5.500 | +5.700 | 5 | 3 | 2.3 | 0 | 27.8 | 0 | 200 | 75 | 93.6 | mc-23 | 0.063238 | 0.00309554 | 0.000178019 | 0.000289917
BEAM | PFC200*75 | +5.500 | +5.700 | 5 | 3 | 2.3 | 0 | 27.8 | 0 | 200 | 75 | 93.6 | mc-20 | 0.063238 | 0.00309554 | 0.000178019 | 0.000289917
BEAM | PFC200*75 | +2.500 | +2.700 | 5 | 3 | 2.3 | 0 | 27.8 | 0 | 200 | 75 | 93.6 | mc-23 | 0.063238 | 0.00309554 | 0.000178019 | 0.000289917
BEAM | PFC200*75 | +2.500 | +2.700 | 5 | 4 | 7.7 | 0 | 27.8 | 0.2 | 200 | 75 | 316.5 | mc-35 | 0.213729 | 0.00309554 | 0.000843744 | 0.000979847
BEAM | PFC200*75 | +2.500 | +2.700 | 5 | 3 | 2.5 | 0 | 27.8 | 0 | 200 | 75 | 98.5 | mc-22 | 0.0665086 | 0.00309554 | 0.000192739 | 0.000304911
BEAM | PFC200*75 | +2.500 | +2.700 | 5 | 3 | 2.5 | 0 | 27.8 | 0 | 200 | 75 | 98.5 | mc-21 | 0.0665086 | 0.00309554 | 0.000192739 | 0.000304911
BEAM | PFC200*75 | +5.500 | +5.700 | 5 | 3 | 2.5 | 0 | 27.8 | 0 | 200 | 75 | 98.5 | mc-22 | 0.0665086 | 0.00309554 | 0.000192739 | 0.000304911
BEAM | PFC200*75 | +5.500 | +5.700 | 5 | 3 | 2.5 | 0 | 27.8 | 0 | 200 | 75 | 98.5 | mc-21 | 0.0665086 | 0.00309554 | 0.000192739 | 0.000304911
BEAM | PFC200*75 | +7.700 | +7.900 | 5 | 3 | 2.5 | 0 | 27.8 | 0 | 200 | 75 | 98.5 | mc-22 | 0.0665086 | 0.00309554 | 0.000192739 | 0.000304911
BEAM | PFC200*75 | +7.700 | +7.900 | 5 | 3 | 2.5 | 0 | 27.8 | 0 | 200 | 75 | 98.5 | mc-21 | 0.0665086 | 0.00309554 | 0.000192739 | 0.000304911
BEAM | PFC200*75 | +9.900 | +10.100 | 5 | 3 | 2.5 | 0 | 27.8 | 0 | 200 | 75 | 98.5 | mc-22 | 0.0665086 | 0.00309554 | 0.000192739 | 0.000304911
BEAM | PFC200*75 | +9.900 | +10.100 | 5 | 3 | 2.5 | 0 | 27.8 | 0 | 200 | 75 | 98.5 | mc-21 | 0.0665086 | 0.00309554 | 0.000192739 | 0.000304911
BEAM | PFC200*75 | +12.300 | +12.500 | 5 | 3 | 2.5 | 0 | 27.8 | 0 | 200 | 75 | 98.5 | mc-22 | 0.0665086 | 0.00309554 | 0.000192739 | 0.000304911
BEAM | PFC200*75 | +12.300 | +12.500 | 5 | 3 | 2.5 | 0 | 27.8 | 0 | 200 | 75 | 98.5 | mc-21 | 0.0665086 | 0.00309554 | 0.000192739 | 0.000304911
BEAM | UC152*152*23 | +17.898 | +18.050 | 4 | 14 | 8.1 | 0 | 38.7 | 0.3 | 152.4 | 152.4 | 347.6 | mb-94 | 0.309025 | 0.00292994 | 0.000925297 | 0.0010183
BEAM | PFC200*75 | +5.500 | +5.700 | 5 | 4 | 20.3 | 0.1 | 27.8 | 0.5 | 200 | 75 | 833.1 | mc-10 | 0.562501 | 0.00309554 | 0.00229529 | 0.0025788
BEAM | PFC200*75 | +7.700 | +7.900 | 5 | 4 | 20.3 | 0.1 | 27.8 | 0.5 | 200 | 75 | 833.1 | mc-7 | 0.562501 | 0.00309554 | 0.00229529 | 0.0025788
BEAM | PFC200*75 | +9.900 | +10.100 | 5 | 4 | 20.3 | 0.1 | 27.8 | 0.5 | 200 | 75 | 833.1 | mc-7 | 0.562501 | 0.00309554 | 0.00229529 | 0.0025788
BEAM | PFC200*75 | +2.500 | +2.700 | 5 | 3 | 2.3 | 0 | 27.8 | 0 | 200 | 75 | 93.6 | mc-20 | 0.063238 | 0.00309554 | 0.000178019 | 0.000289917
BEAM | PFC200*75 | +5.500 | +5.700 | 5 | 4 | 20.3 | 0.1 | 27.8 | 0.5 | 200 | 75 | 833.1 | mc-6 | 0.562501 | 0.00309554 | 0.00229529 | 0.0025788
BEAM | PFC200*75 | +7.700 | +7.900 | 5 | 4 | 20.3 | 0.1 | 27.8 | 0.5 | 200 | 75 | 833.1 | mc-6 | 0.562501 | 0.00309554 | 0.00229529 | 0.0025788
BEAM | PFC200*75 | +9.900 | +10.100 | 5 | 4 | 20.3 | 0.1 | 27.8 | 0.5 | 200 | 75 | 833.1 | mc-6 | 0.562501 | 0.00309554 | 0.00229529 | 0.0025788
BEAM | PFC200*75 | +9.900 | +10.100 | 5 | 4 | 25 | 0.1 | 27.8 | 0.6 | 200 | 75 | 1027 | mc-18 | 0.693445 | 0.00309554 | 0.00312105 | 0.00317912
BEAM | PFC200*75 | +7.700 | +7.900 | 5 | 4 | 25 | 0.1 | 27.8 | 0.6 | 200 | 75 | 1027 | mc-18 | 0.693445 | 0.00309554 | 0.00312105 | 0.00317912
BEAM | PFC200*75 | +5.500 | +5.700 | 5 | 4 | 31.7 | 0.1 | 27.8 | 0.8 | 200 | 75 | 1305.3 | mc-16 | 0.881323 | 0.00309554 | 0.00396665 | 0.00404045
BEAM | PFC200*75 | +2.500 | +2.700 | 5 | 4 | 25 | 0.1 | 27.8 | 0.6 | 200 | 75 | 1027 | mc-14 | 0.693445 | 0.00309554 | 0.00312105 | 0.00317912
BEAM | PFC200*75 | +2.500 | +2.700 | 5 | 4 | 25 | 0.1 | 27.8 | 0.6 | 200 | 75 | 1027 | mc-13 | 0.693445 | 0.00309554 | 0.00312105 | 0.00317912
BEAM | PFC200*75 | +12.300 | +12.500 | 5 | 7 | 30.4 | 0.1 | 27.8 | 0.8 | 200 | 75 | 1253.1 | mc-1 | 0.846112 | 0.00309554 | 0.00380817 | 0.00387903
BEAM | PFC200*75 | +12.300 | +12.500 | 5 | 7 | 28.2 | 0.1 | 27.8 | 0.8 | 200 | 75 | 1166.5 | mc-37 | 0.787661 | 0.00309554 | 0.00342689 | 0.00361106
BEAM | PFC200*75 | +12.300 | +12.500 | 5 | 7 | 28.2 | 0.1 | 27.8 | 0.8 | 200 | 75 | 1166.5 | mc-34 | 0.787661 | 0.00309554 | 0.00342689 | 0.00361106

# IfcDiscreteAccessory: BENT PLATE (22)
In: Undefined
Description: FL6*50; Material: STEEL/S355JR
Tekla Common - Class: 8
Tekla Quantity - Weight: 0.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 48.6 m2; Net surface area: 0 m2; Height: 50 mm; Width: 6 mm; Length: 231 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - NetArea: 0.027816 m2; GrossArea: 0.027816 m2; CrossSectionArea: 0.0003 m2; NetVolume: 0.0000729 m3; GrossVolume: 0.0000729 m3
Name | Bottom elevation | Top elevation | Phase | Reference
BENT PLATE | +13.587 | +13.637 | 1 | p010069
BENT PLATE | +6.787 | +6.837 | 1 | p010068
BENT PLATE | +57.858 | +57.907 | 8 | pf-284
BENT PLATE | +57.858 | +57.907 | 8 | pf-283
BENT PLATE | +39.157 | +39.208 | 7 | pe-203
BENT PLATE | +39.157 | +39.208 | 7 | pe-202
BENT PLATE | +67.338 | +67.388 | 1 | p010068
BENT PLATE | +71.737 | +71.787 | 1 | p010068
BENT PLATE | +64.537 | +64.587 | 1 | p010069
BENT PLATE | +56.392 | +56.442 | 1 | p010068
BENT PLATE | +49.787 | +49.837 | 1 | p010069
BENT PLATE | +45.662 | +45.712 | 1 | p010068
BENT PLATE | +40.125 | +40.175 | 1 | p010069
BENT PLATE | +37.357 | +37.407 | 1 | p010068
BENT PLATE | +3.837 | +3.887 | 1 | p010069
BENT PLATE | +3.837 | +3.887 | 1 | p010068
BENT PLATE | +9.692 | +9.742 | 1 | p010069
BENT PLATE | +12.287 | +12.337 | 1 | p010069
BENT PLATE | +6.588 | +6.638 | 1 | p010068
BENT PLATE | +30.167 | +30.217 | 1 | p010069
BENT PLATE | +22.547 | +22.598 | 1 | p010068
BENT PLATE | +19.137 | +19.188 | 1 | p010068

# IfcDiscreteAccessory: CLEAT (182)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x CLEAT | L60*60*6 | +9.075 | +9.135 | 1 | 8 | 2.5 | 43 | 0.1 | 60 | 60 | 458.6 | m010016 | 0.106915 | 0.000690446 | 0.000313682 | 0.000316638
2 x CLEAT | L60*60*6 | +12.425 | +12.485 | 1 | 8 | 1.3 | 43 | 0.1 | 60 | 60 | 245 | m010015 | 0.0571178 | 0.000690446 | 0.000167581 | 0.00016916
2 x CLEAT | L60*60*6 | +5.625 | +5.685 | 1 | 8 | 1.3 | 43 | 0.1 | 60 | 60 | 245 | m010015 | 0.0571178 | 0.000690446 | 0.000167581 | 0.00016916
2 x CLEAT | L70*70*8 | +55.235 | +55.305 | 8 | 6 | 1 | 32.6 | 0 | 70 | 70 | 122.2 | mf-332 | 0.0332707 | 0.00106497 | 0.000100568 | 0.000130134
2 x CLEAT | L70*70*8 | +55.235 | +55.305 | 8 | 6 | 1 | 32.6 | 0 | 70 | 70 | 122.2 | mf-331 | 0.0332707 | 0.00106497 | 0.000100568 | 0.000130134
CLEAT | L70*70*8 | +36.200 | +36.270 | 6 | 6 | 1 | 32.6 | 0 | 70 | 70 | 122.2 | md-171 | 0.0332707 | 0.00106497 | 0.000100568 | 0.000130134
2 x CLEAT | L70*70*8 | +36.200 | +36.270 | 6 | 6 | 1 | 32.6 | 0 | 70 | 70 | 122.2 | md-170 | 0.0332707 | 0.00106497 | 0.000100568 | 0.000130134
CLEAT | L70*70*8 | +36.200 | +36.270 | 6 | 6 | 0.7 | 32.6 | 0 | 70 | 70 | 98.2 | md-169 | 0.0267373 | 0.00106497 | 0.000103699 | 0.00010458
4 x CLEAT | L60*60*6 | +56.710 | +56.770 | 8 | 8 | 1.3 | 43 | 0.1 | 60 | 60 | 230 | mf-257 | 0.0536205 | 0.000690446 | 0.00015732 | 0.000158802
4 x CLEAT | L60*60*6 | +38.010 | +38.070 | 7 | 8 | 1.3 | 43 | 0.1 | 60 | 60 | 230 | me-166 | 0.0536205 | 0.000690446 | 0.00015732 | 0.000158802
2 x CLEAT | L60*60*6 | +70.410 | +70.470 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
2 x CLEAT | L60*60*6 | +66.120 | +66.180 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
2 x CLEAT | L60*60*6 | +63.210 | +63.270 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
2 x CLEAT | L60*60*6 | +57.891 | +57.950 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
2 x CLEAT | L60*60*6 | +52.910 | +52.970 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
2 x CLEAT | L60*60*6 | +55.065 | +55.125 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
2 x CLEAT | L60*60*6 | +48.570 | +48.630 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
2 x CLEAT | L60*60*6 | +44.335 | +44.395 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
2 x CLEAT | L60*60*6 | +38.798 | +38.858 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
2 x CLEAT | L60*60*6 | +36.030 | +36.090 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
2 x CLEAT | L60*60*6 | +31.598 | +31.658 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
2 x CLEAT | L60*60*8 | +14.040 | +14.100 | 5 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mc-398 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +10.040 | +10.100 | 5 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mc-398 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +7.840 | +7.900 | 5 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mc-398 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +5.640 | +5.700 | 5 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mc-398 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +2.640 | +2.700 | 5 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mc-398 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +66.190 | +66.250 | 8 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mf-289 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +60.675 | +60.735 | 8 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mf-289 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +55.245 | +55.305 | 8 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mf-289 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +51.093 | +51.153 | 8 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mf-289 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +46.953 | +47.013 | 7 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | me-183 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +41.746 | +41.806 | 7 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | me-183 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +36.210 | +36.270 | 7 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | me-183 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +31.668 | +31.728 | 6 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | md-147 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +68.390 | +68.450 | 8 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mf-289 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +63.390 | +63.450 | 8 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mf-289 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +57.960 | +58.020 | 8 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mf-289 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +52.980 | +53.040 | 8 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mf-289 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +48.640 | +48.700 | 8 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mf-289 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +44.515 | +44.575 | 7 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | me-183 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +38.978 | +39.038 | 7 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | me-183 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +33.939 | +33.999 | 6 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | md-147 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +29.020 | +29.080 | 6 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | md-147 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +24.258 | +24.318 | 6 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | md-147 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +26.355 | +26.415 | 6 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | md-147 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +21.400 | +21.460 | 4 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mb-201 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +17.990 | +18.050 | 4 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mb-201 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +19.695 | +19.755 | 4 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mb-201 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +15.640 | +15.700 | 4 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mb-201 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +13.085 | +13.145 | 4 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mb-201 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +10.530 | +10.590 | 4 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | mb-201 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +8.085 | +8.145 | 3 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | ma-190 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +5.640 | +5.700 | 3 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | ma-190 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
2 x CLEAT | L60*60*8 | +2.640 | +2.700 | 3 | 8 | 1.5 | 32.9 | 0 | 60 | 60 | 200 | ma-190 | 0.0466265 | 0.000903185 | 0.0001792 | 0.000180637
CLEAT | L70*70*8 | +6.025 | +6.095 | 3 | 82 | 0.7 | 32.6 | 0 | 70 | 70 | 70 | ma-220 | 0.0190592 | 0.00106497 | 0.00007392 | 0.0000745477
CLEAT | L70*70*8 | +6.025 | +6.095 | 3 | 82 | 0.7 | 32.6 | 0 | 70 | 70 | 70 | ma-220 | 0.0190592 | 0.00106497 | 0.00007392 | 0.0000745478
2 x CLEAT | L70*70*8 | +5.700 | +5.770 | 3 | 82 | 0.7 | 32.6 | 0 | 70 | 70 | 70 | ma-220 | 0.0190592 | 0.00106497 | 0.00007392 | 0.0000745478
2 x CLEAT | L60*60*6 | +3.155 | +3.215 | 5 | 8 | 1.3 | 43 | 0.1 | 60 | 60 | 219.9 | mc-348 | 0.0512893 | 0.000690446 | 0.00015048 | 0.000151899
4 x CLEAT | L60*60*6 | +2.625 | +2.685 | 1 | 8 | 1.3 | 43 | 0.1 | 60 | 60 | 219.9 | m010014 | 0.0512892 | 0.000690446 | 0.00015048 | 0.000151898
2 x CLEAT | L150*150*15 | +5.024 | +5.314 | 5 | 82 | 9.7 | 17.3 | 0.2 | 149.9 | 150 | 290 | mc-445 | 0.170017 | 0.00430573 | 0.00123975 | 0.00124866
2 x CLEAT | L150*150*15 | +6.930 | +7.220 | 5 | 82 | 9.7 | 17.3 | 0.2 | 149.9 | 150 | 290 | mc-445 | 0.170017 | 0.00430573 | 0.00123975 | 0.00124866
10 x CLEAT | L150*150*15 | +8.880 | +9.170 | 5 | 82 | 9.7 | 17.3 | 0.2 | 149.9 | 150 | 290 | mc-445 | 0.170017 | 0.00430573 | 0.00123975 | 0.00124866
10 x CLEAT | L150*150*15 | +10.880 | +11.170 | 5 | 82 | 9.7 | 17.3 | 0.2 | 149.9 | 150 | 290 | mc-445 | 0.170017 | 0.00430573 | 0.00123975 | 0.00124866
2 x CLEAT | L150*150*15 | +7.880 | +8.170 | 5 | 82 | 9.7 | 17.3 | 0.2 | 149.9 | 150 | 290 | mc-445 | 0.170017 | 0.00430573 | 0.00123975 | 0.00124866
4 x CLEAT | L150*150*15 | +5.180 | +5.470 | 5 | 82 | 9.7 | 17.3 | 0.2 | 149.9 | 150 | 290 | mc-445 | 0.170017 | 0.00430573 | 0.00123975 | 0.00124866
2 x CLEAT | L60*60*6 | +5.375 | +5.435 | 1 | 8 | 1.6 | 43 | 0.1 | 60 | 60 | 304.4 | m010013 | 0.0709541 | 0.000690446 | 0.000208176 | 0.000210138
2 x CLEAT | L60*60*6 | +9.075 | +9.135 | 1 | 8 | 1.6 | 43 | 0.1 | 60 | 60 | 304.4 | m010013 | 0.0709541 | 0.000690446 | 0.000208176 | 0.000210138
2 x CLEAT | L60*60*6 | +11.070 | +11.130 | 1 | 8 | 1.7 | 43 | 0.1 | 60 | 60 | 317.2 | m010012 | 0.0739497 | 0.000690446 | 0.000216965 | 0.00021901
2 x CLEAT | L60*60*6 | +5.370 | +5.430 | 1 | 8 | 2.1 | 43 | 0.1 | 60 | 60 | 394.4 | m010011 | 0.091936 | 0.000690446 | 0.000269736 | 0.000272278
2 x CLEAT | L60*60*6 | +28.840 | +28.900 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
2 x CLEAT | L60*60*6 | +24.188 | +24.248 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
2 x CLEAT | L60*60*6 | +17.920 | +17.980 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
2 x CLEAT | L60*60*6 | +21.210 | +21.270 | 1 | 8 | 2.2 | 43 | 0.1 | 60 | 60 | 404.4 | m010010 | 0.0942674 | 0.000690446 | 0.000276576 | 0.000279182
4 x CLEAT | L60*60*6 | +2.163 | +2.303 | 5 | 82 | 0.7 | 43 | 0 | 60 | 60 | 140 | mc-347 | 0.0326386 | 0.000690446 | 0.00009576 | 0.0000966624
8 x CLEAT | L60*60*6 | +2.163 | +2.303 | 3 | 82 | 0.7 | 43 | 0 | 60 | 60 | 140 | ma-170 | 0.0326386 | 0.000690446 | 0.00009576 | 0.0000966624
2 x CLEAT | L60*60*6 | +7.723 | +7.849 | 5 | 82 | 0.7 | 43 | 0 | 60 | 60 | 125.8 | mc-346 | 0.0293164 | 0.000690446 | 0.000086013 | 0.0000868236
2 x CLEAT | L60*60*6 | +7.723 | +7.849 | 5 | 82 | 0.7 | 43 | 0 | 60 | 60 | 125.8 | mc-345 | 0.0293164 | 0.000690446 | 0.000086013 | 0.0000868236

# IfcDiscreteAccessory: END PLATE (3408)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
4 x END PLATE | PLT12*140 | +60.513 | +60.705 | 8 | 8 | 2.5 | 0 | 24.4 | 0.1 | 140 | 12 | 191.5 | pf-60 | 0.061576 | 0.061576 | 0.00168 | 0.00032172 | 0.00032172
4 x END PLATE | PLT12*140 | +68.228 | +68.420 | 8 | 8 | 2.5 | 0 | 24.4 | 0.1 | 140 | 12 | 191.5 | pf-60 | 0.061576 | 0.061576 | 0.00168 | 0.00032172 | 0.00032172
16 x END PLATE | FL12*180 | +66.056 | +66.244 | 8 | 8 | 3.2 | 0 | 24 | 0.1 | 180 | 12 | 188 | pf-50 | 0.076512 | 0.076512 | 0.00216 | 0.00040608 | 0.00040608
16 x END PLATE | FL12*180 | +55.111 | +55.299 | 8 | 8 | 3.2 | 0 | 24 | 0.1 | 180 | 12 | 188 | pf-50 | 0.076512 | 0.076512 | 0.00216 | 0.00040608 | 0.00040608
16 x END PLATE | FL12*180 | +70.456 | +70.644 | 8 | 8 | 3.2 | 0 | 24 | 0.1 | 180 | 12 | 188 | pf-50 | 0.076512 | 0.076512 | 0.00216 | 0.00040608 | 0.00040608
8 x END PLATE | FL12*110 | +63.256 | +63.444 | 8 | 8 | 1.9 | 0 | 24.9 | 0 | 110 | 12 | 188 | pf-43 | 0.048512 | 0.048512 | 0.00132 | 0.00024816 | 0.00024816
11 x END PLATE | FL16*200 | +63.156 | +63.444 | 8 | 8 | 7.2 | 0 | 18.1 | 0.1 | 200 | 16 | 288 | pf-264 | 0.130816 | 0.130816 | 0.0032 | 0.0009216 | 0.0009216
8 x END PLATE | FL16*200 | +63.156 | +63.444 | 8 | 8 | 7.2 | 0 | 18.1 | 0.1 | 200 | 16 | 288 | pf-264 | 0.130804 | 0.130804 | 0.0032 | 0.000921511 | 0.000921511
3 x END PLATE | FL16*180 | +63.180 | +63.420 | 8 | 8 | 5.4 | 0 | 18.4 | 0.1 | 180 | 16 | 239.9 | pf-265 | 0.09984 | 0.09984 | 0.00288 | 0.0006912 | 0.0006912
END PLATE | PLT12*160 | +63.253 | +63.420 | 8 | 8 | 2.5 | 0 | 24.3 | 0.1 | 159.9 | 12 | 167.2 | pf-55 | 0.0613568 | 0.0613568 | 0.00192 | 0.000321024 | 0.000321024
END PLATE | PLT12*160 | +63.253 | +63.444 | 8 | 8 | 2.9 | 0 | 24.3 | 0.1 | 159.9 | 12 | 191.2 | pf-56 | 0.0696128 | 0.0696128 | 0.00192 | 0.000367104 | 0.000367104
4 x END PLATE | FL16*200 | +63.156 | +63.444 | 8 | 99 | 7.2 | 0 | 18.1 | 0.1 | 200 | 16 | 288 | pf-264 | 0.130816 | 0.130816 | 0.0032 | 0.0009216 | 0.0009216
4 x END PLATE | FL16*180 | +63.180 | +63.420 | 8 | 99 | 5.4 | 0 | 18.4 | 0.1 | 180 | 16 | 239.9 | pf-265 | 0.09984 | 0.09984 | 0.00288 | 0.0006912 | 0.0006912
2 x END PLATE | PLT12*160 | +63.094 | +63.106 | 8 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pf-53 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
8 x END PLATE | PLT12*160 | +63.256 | +63.420 | 8 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pf-44 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
4 x END PLATE | PLT12*160 | +63.256 | +63.444 | 8 | 99 | 2.8 | 0 | 24.3 | 0.1 | 159.9 | 12 | 188 | pf-57 | 0.068512 | 0.068512 | 0.00192 | 0.00036096 | 0.00036096
8 x END PLATE | FL12*150 | +63.270 | +63.420 | 8 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pf-46 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
10 x END PLATE | FL16*200 | +63.156 | +63.420 | 8 | 8 | 6.6 | 0 | 18.1 | 0.1 | 200 | 16 | 264 | pf-262 | 0.120448 | 0.120448 | 0.0032 | 0.0008448 | 0.0008448
2 x END PLATE | FL16*200 | +63.156 | +63.425 | 8 | 8 | 6.8 | 0 | 18.1 | 0.1 | 200 | 16 | 269 | pf-263 | 0.122608 | 0.122608 | 0.0032 | 0.0008608 | 0.0008608
6 x END PLATE | FL16*200 | +63.256 | +63.420 | 8 | 1 | 4.1 | 0 | 18.8 | 0.1 | 164 | 16 | 164 | pf-216 | 0.077248 | 0.077248 | 0.0032 | 0.0005248 | 0.0005248
END PLATE | FL16*200 | +63.156 | +63.444 | 8 | 1 | 7.2 | 0 | 18.1 | 0.1 | 200 | 16 | 288 | pf-261 | 0.130816 | 0.130816 | 0.0032 | 0.0009216 | 0.0009216
5 x END PLATE | FL16*200 | +63.156 | +63.420 | 8 | 1 | 6.6 | 0 | 18.1 | 0.1 | 200 | 16 | 264 | pf-260 | 0.120448 | 0.120448 | 0.0032 | 0.0008448 | 0.0008448
END PLATE | PLT12*160 | +63.096 | +63.108 | 8 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pf-53 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
END PLATE | PLT12*160 | +70.296 | +70.308 | 8 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pf-53 | 0.076768 | 0.076768 | 0.002544 | 0.00040704 | 0.00040704
END PLATE | PLT12*140.4 | +70.474 | +70.614 | 8 | 8 | 2.1 | 0 | 24.6 | 0.1 | 140.4 | 12 | 160 | pf-54 | 0.0521376 | 0.0521376 | 0.00192 | 0.000269568 | 0.000269568
30 x END PLATE | FL12*150 | +70.470 | +70.620 | 8 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pf-46 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
3 x END PLATE | PLT12*160 | +70.296 | +70.308 | 8 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pf-53 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
END PLATE | PLT12*95 | +70.296 | +70.308 | 8 | 8 | 1.9 | 0 | 25.1 | 0 | 95 | 12 | 212 | pf-42 | 0.047648 | 0.047648 | 0.002544 | 0.00024168 | 0.00024168
7 x END PLATE | PLT12*160 | +65.896 | +65.908 | 8 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pf-53 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
END PLATE | PLT12*95 | +65.896 | +65.908 | 8 | 8 | 1.9 | 0 | 25.1 | 0 | 95 | 12 | 212 | pf-42 | 0.047648 | 0.047648 | 0.002544 | 0.00024168 | 0.00024168
END PLATE | PLT12*160 | +63.096 | +63.108 | 8 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pf-53 | 0.076768 | 0.076768 | 0.002544 | 0.00040704 | 0.00040704
END PLATE | PLT12*160 | +60.486 | +60.498 | 8 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pf-53 | 0.076768 | 0.076768 | 0.002544 | 0.00040704 | 0.00040704
3 x END PLATE | PLT12*160 | +54.951 | +54.963 | 8 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pf-53 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
2 x END PLATE | FL12*180 | +69.151 | +69.451 | 8 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pf-51 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | FL12*180 | +70.282 | +70.294 | 8 | 8 | 5.1 | 0.1 | 23.5 | 0.1 | 180 | 12 | 300 | pf-48 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | PLT20*331.6 | +70.306 | +70.638 | 8 | 8 | 36.4 | 0 | 13.9 | 0.5 | 331.6 | 20 | 700 | pf-24 | 0.505504 | 0.505504 | 0.014 | 0.0046424 | 0.0046424
6 x END PLATE | PLT16*160 | +70.324 | +70.620 | 8 | 8 | 5.9 | 0 | 18.4 | 0.1 | 159.9 | 16 | 295.6 | pf-258 | 0.109171 | 0.109171 | 0.00256 | 0.000756736 | 0.000756736
6 x END PLATE | FL12*70 | +70.456 | +70.644 | 8 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pf-40 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
6 x END PLATE | PLT20*190 | +70.300 | +70.644 | 8 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pf-21 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
2 x END PLATE | FL12*180 | +61.951 | +62.251 | 8 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pf-51 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | FL12*180 | +63.082 | +63.094 | 8 | 8 | 5.1 | 0.1 | 23.5 | 0.1 | 180 | 12 | 300 | pf-48 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | PLT20*331.6 | +63.106 | +63.438 | 8 | 8 | 36.4 | 0 | 13.9 | 0.5 | 331.6 | 20 | 700 | pf-24 | 0.505504 | 0.505504 | 0.014 | 0.0046424 | 0.0046424
16 x END PLATE | FL12*70 | +63.256 | +63.444 | 8 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pf-40 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
6 x END PLATE | PLT16*160 | +63.124 | +63.420 | 8 | 8 | 5.9 | 0 | 18.4 | 0.1 | 159.9 | 16 | 295.6 | pf-258 | 0.109171 | 0.109171 | 0.00256 | 0.000756736 | 0.000756736
4 x END PLATE | PLT20*190 | +63.100 | +63.444 | 8 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pf-21 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT12*95 | +54.951 | +54.963 | 8 | 8 | 1.9 | 0 | 25.1 | 0 | 95 | 12 | 212 | pf-42 | 0.047648 | 0.047648 | 0.002544 | 0.00024168 | 0.00024168
2 x END PLATE | FL12*180 | +53.806 | +54.106 | 8 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pf-51 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | FL12*180 | +54.937 | +54.949 | 8 | 8 | 5.1 | 0.1 | 23.5 | 0.1 | 180 | 12 | 300 | pf-48 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | PLT20*331.6 | +54.961 | +55.293 | 8 | 8 | 36.4 | 0 | 13.9 | 0.5 | 331.6 | 20 | 700 | pf-24 | 0.505504 | 0.505504 | 0.014 | 0.0046424 | 0.0046424
16 x END PLATE | FL12*70 | +55.111 | +55.299 | 8 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pf-40 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
6 x END PLATE | PLT16*160 | +54.979 | +55.275 | 8 | 8 | 5.9 | 0 | 18.4 | 0.1 | 159.9 | 16 | 295.6 | pf-258 | 0.109171 | 0.109171 | 0.00256 | 0.000756736 | 0.000756736
3 x END PLATE | PLT20*190 | +54.955 | +55.299 | 8 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pf-20 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT16*280 | +70.079 | +70.624 | 8 | 8 | 19.2 | 0 | 17.3 | 0.3 | 280 | 16 | 545 | pf-214 | 0.331579 | 0.331579 | 0.00448 | 0.00244144 | 0.00244144
8 x END PLATE | PLT12*160 | +63.256 | +63.420 | 8 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pf-44 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
5 x END PLATE | PLT12*160 | +63.256 | +63.444 | 8 | 8 | 2.8 | 0 | 24.3 | 0.1 | 159.9 | 12 | 188 | pf-57 | 0.068512 | 0.068512 | 0.00192 | 0.00036096 | 0.00036096
33 x END PLATE | PLT12*160 | +48.506 | +48.670 | 7 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pe-53 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
4 x END PLATE | PLT16*160 | +48.374 | +48.670 | 7 | 8 | 5.9 | 0 | 18.4 | 0.1 | 159.9 | 16 | 295.6 | pe-172 | 0.109171 | 0.109171 | 0.00256 | 0.000756736 | 0.000756736
10 x END PLATE | PLT12*160 | +48.346 | +48.358 | 7 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pe-63 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
57 x END PLATE | FL12*150 | +48.520 | +48.670 | 7 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pe-54 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
4 x END PLATE | PLT12*140 | +50.931 | +51.123 | 8 | 8 | 2.5 | 0 | 24.4 | 0.1 | 140 | 12 | 191.5 | pf-60 | 0.061576 | 0.061576 | 0.00168 | 0.00032172 | 0.00032172
4 x END PLATE | PLT12*140 | +46.791 | +46.983 | 7 | 8 | 2.5 | 0 | 24.4 | 0.1 | 140 | 12 | 191.5 | pe-62 | 0.061576 | 0.061576 | 0.00168 | 0.00032172 | 0.00032172
END PLATE | FL12*100 | +44.221 | +44.233 | 7 | 8 | 1.9 | 0 | 24.9 | 0 | 100 | 12 | 212 | pe-52 | 0.049888 | 0.049888 | 0.002544 | 0.0002544 | 0.0002544
4 x END PLATE | PLT12*160 | +44.221 | +44.233 | 7 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pe-63 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
END PLATE | PLT12*160 | +44.221 | +44.233 | 7 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pe-63 | 0.076768 | 0.076768 | 0.002544 | 0.00040704 | 0.00040704
30 x END PLATE | FL12*150 | +44.395 | +44.545 | 7 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pe-54 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
4 x END PLATE | PLT12*140 | +41.584 | +41.776 | 7 | 8 | 2.5 | 0 | 24.4 | 0.1 | 140 | 12 | 191.5 | pe-62 | 0.061576 | 0.061576 | 0.00168 | 0.00032172 | 0.00032172
4 x END PLATE | PLT12*140 | +33.777 | +33.969 | 6 | 8 | 2.5 | 0 | 24.4 | 0.1 | 140 | 12 | 191.5 | pd-44 | 0.061576 | 0.061576 | 0.00168 | 0.00032172 | 0.00032172
4 x END PLATE | PLT12*140 | +26.194 | +26.385 | 6 | 8 | 2.5 | 0 | 24.4 | 0.1 | 140 | 12 | 191.5 | pd-44 | 0.061576 | 0.061576 | 0.00168 | 0.00032172 | 0.00032172
END PLATE | FL12*100 | +38.684 | +38.696 | 7 | 8 | 1.9 | 0 | 24.9 | 0 | 100 | 12 | 212 | pe-52 | 0.049888 | 0.049888 | 0.002544 | 0.0002544 | 0.0002544
2 x END PLATE | PLT12*160 | +35.916 | +35.928 | 6 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pd-41 | 0.076768 | 0.076768 | 0.002544 | 0.00040704 | 0.00040704
32 x END PLATE | FL12*150 | +36.090 | +36.240 | 6 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pd-36 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
END PLATE | PLT12*140.4 | +36.094 | +36.234 | 6 | 8 | 2.1 | 0 | 24.6 | 0.1 | 140.4 | 12 | 160 | pd-45 | 0.0521376 | 0.0521376 | 0.00192 | 0.000269568 | 0.000269568
2 x END PLATE | PLT12*160 | +35.916 | +35.928 | 6 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pd-41 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
END PLATE | PLT12*94 | +44.281 | +44.569 | 7 | 8 | 2.6 | 0 | 24.8 | 0.1 | 94 | 12 | 288 | pe-44 | 0.063312 | 0.063312 | 0.001128 | 0.000324864 | 0.000324864
3 x END PLATE | PLT12*94 | +44.225 | +44.569 | 7 | 8 | 2.9 | 0 | 24.8 | 0.1 | 94 | 12 | 343.6 | pe-43 | 0.0750992 | 0.0750992 | 0.001128 | 0.000387581 | 0.000387581
5 x END PLATE | PLT12*94 | +44.281 | +44.569 | 7 | 8 | 2.6 | 0 | 24.8 | 0.1 | 94 | 12 | 288 | pe-42 | 0.063312 | 0.063312 | 0.001128 | 0.000324864 | 0.000324864
END PLATE | FL12*70 | +44.281 | +44.569 | 7 | 8 | 1.9 | 0 | 25.8 | 0 | 70 | 12 | 288 | pe-51 | 0.048912 | 0.048912 | 0.00084 | 0.00024192 | 0.00024192
9 x END PLATE | FL12*70 | +44.381 | +44.569 | 7 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pe-49 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
2 x END PLATE | FL12*180 | +43.108 | +43.408 | 7 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pe-58 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
4 x END PLATE | FL12*180 | +44.205 | +44.217 | 7 | 8 | 5.1 | 0.1 | 23.5 | 0.1 | 180 | 12 | 300 | pe-57 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | PLT16*160 | +44.249 | +44.545 | 7 | 8 | 5.9 | 0 | 18.4 | 0.1 | 159.9 | 16 | 295.6 | pe-172 | 0.109171 | 0.109171 | 0.00256 | 0.000756736 | 0.000756736
3 x END PLATE | PLT20*190 | +44.225 | +44.569 | 7 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pe-27 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +44.225 | +44.569 | 7 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pe-30 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT12*94 | +35.926 | +36.258 | 6 | 8 | 2.9 | 0 | 24.8 | 0.1 | 94 | 12 | 331.6 | pd-32 | 0.0725552 | 0.0725552 | 0.001128 | 0.000374045 | 0.000374045
4 x END PLATE | PLT12*94 | +35.976 | +36.264 | 6 | 8 | 2.6 | 0 | 24.8 | 0.1 | 94 | 12 | 288 | pd-30 | 0.063312 | 0.063312 | 0.001128 | 0.000324864 | 0.000324864
11 x END PLATE | FL12*70 | +36.076 | +36.264 | 6 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pd-24 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
2 x END PLATE | PLT12*94 | +35.920 | +36.264 | 6 | 8 | 2.9 | 0 | 24.8 | 0.1 | 94 | 12 | 343.6 | pd-31 | 0.0750992 | 0.0750992 | 0.001128 | 0.000387581 | 0.000387581
2 x END PLATE | FL12*180 | +34.806 | +35.106 | 6 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pd-39 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
4 x END PLATE | FL12*180 | +35.900 | +35.912 | 6 | 8 | 5.1 | 0.1 | 23.5 | 0.1 | 180 | 12 | 300 | pd-40 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | PLT16*160 | +35.944 | +36.240 | 6 | 8 | 5.9 | 0 | 18.4 | 0.1 | 159.9 | 16 | 295.6 | pd-152 | 0.109171 | 0.109171 | 0.00256 | 0.000756736 | 0.000756736
4 x END PLATE | PLT20*190 | +35.920 | +36.264 | 6 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pd-16 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +35.920 | +36.264 | 6 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pd-17 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT12*94 | +28.736 | +29.068 | 6 | 8 | 2.9 | 0 | 24.8 | 0.1 | 94 | 12 | 331.6 | pd-32 | 0.0725552 | 0.0725552 | 0.001128 | 0.000374045 | 0.000374045
4 x END PLATE | PLT12*94 | +28.786 | +29.074 | 6 | 8 | 2.6 | 0 | 24.8 | 0.1 | 94 | 12 | 288 | pd-30 | 0.063312 | 0.063312 | 0.001128 | 0.000324864 | 0.000324864
13 x END PLATE | FL12*70 | +28.886 | +29.074 | 6 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pd-24 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
2 x END PLATE | PLT12*94 | +28.730 | +29.074 | 6 | 8 | 2.9 | 0 | 24.8 | 0.1 | 94 | 12 | 343.6 | pd-31 | 0.0750992 | 0.0750992 | 0.001128 | 0.000387581 | 0.000387581
2 x END PLATE | FL12*180 | +27.616 | +27.916 | 6 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pd-39 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
4 x END PLATE | FL12*180 | +28.710 | +28.722 | 6 | 8 | 5.1 | 0.1 | 23.5 | 0.1 | 180 | 12 | 300 | pd-40 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | PLT16*160 | +28.754 | +29.050 | 6 | 8 | 5.9 | 0 | 18.4 | 0.1 | 159.9 | 16 | 295.6 | pd-152 | 0.109171 | 0.109171 | 0.00256 | 0.000756736 | 0.000756736
3 x END PLATE | PLT20*190 | +28.730 | +29.074 | 6 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pd-16 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
3 x END PLATE | PLT20*190 | +28.730 | +29.074 | 6 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pd-17 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
7 x END PLATE | PLT12*160 | +28.726 | +28.738 | 6 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pd-41 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
4 x END PLATE | PLT12*160 | +28.883 | +29.050 | 6 | 8 | 2.5 | 0 | 24.3 | 0.1 | 159.9 | 12 | 167.2 | pd-43 | 0.0613568 | 0.0613568 | 0.00192 | 0.000321024 | 0.000321024
32 x END PLATE | FL12*150 | +28.900 | +29.050 | 6 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pd-36 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
2 x END PLATE | PLT20*190 | +62.894 | +63.650 | 8 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pf-14 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +57.464 | +58.014 | 8 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-10 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +54.749 | +55.299 | 8 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-10 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +52.484 | +53.034 | 8 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-10 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +44.019 | +44.775 | 7 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pe-26 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +38.472 | +39.032 | 7 | 8 | 16.7 | 0 | 14.4 | 0.2 | 190 | 20 | 559.6 | pe-22 | 0.242632 | 0.242632 | 0.0038 | 0.00212648 | 0.00212648
END PLATE | PLT20*190 | +35.714 | +36.264 | 6 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pd-15 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +31.172 | +31.722 | 6 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pd-15 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | FL10*70 | +66.250 | +66.260 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +60.735 | +60.745 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
40 x END PLATE | PLT12*160 | +12.306 | +12.470 | 5 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pc-114 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
2 x END PLATE | PLT12*160 | +12.306 | +12.470 | 5 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pc-106 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
4 x END PLATE | PLT12*94 | +5.506 | +5.694 | 5 | 8 | 1.7 | 0 | 25.3 | 0 | 94 | 12 | 188 | pc-104 | 0.042112 | 0.042112 | 0.001128 | 0.000212064 | 0.000212064
30 x END PLATE | FL12*150 | +5.520 | +5.670 | 5 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pc-115 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
51 x END PLATE | PLT12*160 | +5.506 | +5.670 | 5 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pc-114 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
33 x END PLATE | PLT12*160 | +5.506 | +5.670 | 5 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pc-114 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
6 x END PLATE | PLT12*140.4 | +17.874 | +18.014 | 4 | 8 | 2.1 | 0 | 24.6 | 0.1 | 140.4 | 12 | 160 | pb-71 | 0.0521376 | 0.0521376 | 0.00192 | 0.000269568 | 0.000269568
2 x END PLATE | PLT12*140.4 | +17.874 | +18.014 | 4 | 8 | 2.1 | 0 | 24.6 | 0.1 | 140.4 | 12 | 160 | pb-70 | 0.0521376 | 0.0521376 | 0.00192 | 0.000269568 | 0.000269568
36 x END PLATE | FL12*150 | +15.520 | +15.670 | 5 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pc-115 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
12 x END PLATE | PLT12*140 | +15.506 | +15.670 | 5 | 8 | 2.2 | 0 | 24.6 | 0.1 | 140 | 12 | 164 | pc-108 | 0.053216 | 0.053216 | 0.00168 | 0.00027552 | 0.00027552
4 x END PLATE | PLT12*160 | +15.506 | +15.670 | 5 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pc-116 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
7 x END PLATE | PLT12*140 | +15.506 | +15.670 | 5 | 99 | 2.2 | 0 | 24.6 | 0.1 | 140 | 12 | 164 | pc-108 | 0.053216 | 0.053216 | 0.00168 | 0.00027552 | 0.00027552
8 x END PLATE | PLT12*160 | +15.506 | +15.670 | 5 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pc-114 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
20 x END PLATE | PLT12*160 | +15.506 | +15.670 | 5 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pc-114 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
END PLATE | FL10*70 | +48.700 | +48.710 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +53.040 | +53.050 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
