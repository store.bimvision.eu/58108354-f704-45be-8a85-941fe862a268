Properties of the parts of a building model (IFC2X3), part 4 of 22

# IfcBeam: UB254*146*31 (56)
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BEAM | +46.761 | +47.013 | 7 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | me-163 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +41.554 | +41.806 | 7 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | me-162 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +41.554 | +41.806 | 7 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | me-161 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +60.483 | +60.735 | 8 | 4 | 73.3 | 0.3 | 2.5 | 2356.2 | mf-248 | 2356.2 | 2.50311 | 0.00923329 | 72.4813
BEAM | +60.483 | +60.735 | 8 | 4 | 73.3 | 0.3 | 2.5 | 2356.2 | mf-247 | 2356.2 | 2.50311 | 0.00923329 | 72.4813
2 x BEAM | +68.198 | +68.450 | 8 | 4 | 73.3 | 0.3 | 2.5 | 2356.2 | mf-247 | 2356.2 | 2.50311 | 0.00923329 | 72.4813
2 x BEAM | +50.901 | +51.153 | 8 | 4 | 73.3 | 0.3 | 2.5 | 2356.2 | mf-247 | 2356.2 | 2.50311 | 0.00923329 | 72.4813
2 x BEAM | +46.761 | +47.013 | 7 | 4 | 73.3 | 0.3 | 2.5 | 2356.2 | me-160 | 2356.2 | 2.50311 | 0.00923329 | 72.4813
2 x BEAM | +41.554 | +41.806 | 7 | 4 | 73.3 | 0.3 | 2.5 | 2356.2 | me-160 | 2356.2 | 2.50311 | 0.00923329 | 72.4813
2 x BEAM | +33.747 | +33.999 | 6 | 4 | 72.7 | 0.3 | 2.5 | 2336.8 | md-130 | 2336.8 | 2.4825 | 0.00915726 | 71.8845
BEAM | +19.504 | +19.755 | 4 | 4 | 72.7 | 0.3 | 2.5 | 2336.8 | mb-168 | 2336.8 | 2.4825 | 0.00915726 | 71.8845
CRAWL BEAM | +7.698 | +7.950 | 5 | 6 | 83.4 | 0.3 | 3 | 2679 | mc-324 | 2679 | 2.84604 | 0.0104982 | 82.4112

# IfcBeam: UB254*146*37 (3)
In: Undefined
Description: UB254*146*37; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +2.138; Top elevation: +2.394; Class: 6
Tekla Quantity - Weight: 221.4 kg; Volume: 0 m3; Gross footprint area: 0.9 m2; Area per tons: 28.9 m2; Net surface area: 6.5 m2; Height: 256 mm; Width: 146.4 mm; Length: 5985.8 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 5985.75 mm; OuterSurfaceArea: 6.41644 m2; NetVolume: 0.0279354 m3; NetWeight: 219.293 kg
Name | Phase | Reference
2 x CRAWL BEAMS | 3 | ma-224
CRAWL BEAM | 5 | mc-466

# IfcBeam: UB356*171*51 (379)
In: Undefined
Description: UB356*171*51; Material: STEEL/S355JR
Tekla Quantity - Area per tons: 26.8 m2; Height: 355.6 mm; Width: 171.5 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BEAM | +70.294 | +70.650 | 8 | 7 | 176.3 | 0 | 0.6 | 4.7 | 3456.7 | mf-92 | 3456.7 | 4.7187 | 0.0213964 | 167.962
BEAM | +70.294 | +70.650 | 8 | 7 | 63.1 | 0 | 0.2 | 1.6 | 1236.7 | mf-91 | 1236.7 | 1.6882 | 0.00724949 | 56.9085
BEAM | +70.294 | +70.650 | 8 | 7 | 68.1 | 0 | 0.2 | 1.9 | 1335.9 | mf-89 | 1335.9 | 1.82362 | 0.008513 | 66.827
BEAM | +70.294 | +70.650 | 8 | 7 | 68.1 | 0 | 0.2 | 1.9 | 1335.9 | mf-88 | 1335.9 | 1.82362 | 0.008513 | 66.827
BEAM | +70.294 | +70.650 | 8 | 7 | 354.8 | 0 | 1.2 | 9.5 | 6956.7 | mf-90 | 6956.7 | 9.49651 | 0.0437001 | 343.046
BEAM | +63.094 | +63.450 | 8 | 7 | 176.3 | 0 | 0.6 | 4.7 | 3456.7 | mf-92 | 3456.7 | 4.7187 | 0.0213964 | 167.962
BEAM | +63.094 | +63.450 | 8 | 7 | 63.1 | 0 | 0.2 | 1.6 | 1236.7 | mf-91 | 1236.7 | 1.6882 | 0.00724949 | 56.9085
BEAM | +63.094 | +63.450 | 8 | 7 | 68.1 | 0 | 0.2 | 1.9 | 1335.9 | mf-89 | 1335.9 | 1.82362 | 0.008513 | 66.827
BEAM | +63.094 | +63.450 | 8 | 7 | 68.1 | 0 | 0.2 | 1.9 | 1335.9 | mf-88 | 1335.9 | 1.82362 | 0.008513 | 66.827
BEAM | +63.094 | +63.450 | 8 | 7 | 354.8 | 0 | 1.2 | 9.5 | 6956.7 | mf-90 | 6956.7 | 9.49651 | 0.0437001 | 343.046
BEAM | +54.949 | +55.305 | 8 | 7 | 176.3 | 0 | 0.6 | 4.7 | 3456.7 | mf-92 | 3456.7 | 4.7187 | 0.0213964 | 167.962
BEAM | +54.949 | +55.305 | 8 | 7 | 63.1 | 0 | 0.2 | 1.6 | 1236.7 | mf-91 | 1236.7 | 1.6882 | 0.00724949 | 56.9085
BEAM | +54.949 | +55.305 | 8 | 7 | 68.1 | 0 | 0.2 | 1.9 | 1335.9 | mf-89 | 1335.9 | 1.82362 | 0.008513 | 66.827
BEAM | +54.949 | +55.305 | 8 | 7 | 68.1 | 0 | 0.2 | 1.9 | 1335.9 | mf-88 | 1335.9 | 1.82362 | 0.008513 | 66.827
BEAM | +54.949 | +55.305 | 8 | 7 | 354.8 | 0 | 1.2 | 9.5 | 6956.7 | mf-90 | 6956.7 | 9.49651 | 0.0437001 | 343.046
2 x BEAM | +44.219 | +44.575 | 7 | 7 | 55.5 | 0 | 0.2 | 1.5 | 1089.2 | me-54 | 1089.2 | 1.48686 | 0.00694091 | 54.4862
BEAM | +44.219 | +44.575 | 7 | 7 | 354.8 | 0 | 1.2 | 9.5 | 6956.7 | me-52 | 6956.7 | 9.49651 | 0.0437001 | 343.046
2 x BEAM | +35.914 | +36.270 | 6 | 7 | 66.6 | 0 | 0.2 | 1.7 | 1305.9 | md-42 | 1305.9 | 1.78267 | 0.00832182 | 65.3263
BEAM | +35.914 | +36.270 | 6 | 7 | 354.8 | 0 | 1.2 | 9.5 | 6956.7 | md-41 | 6956.7 | 9.49651 | 0.0437001 | 343.046
2 x BEAM | +28.724 | +29.080 | 6 | 7 | 66.6 | 0 | 0.2 | 1.7 | 1305.9 | md-42 | 1305.9 | 1.78267 | 0.00832182 | 65.3263
BEAM | +28.724 | +29.080 | 6 | 7 | 354.8 | 0 | 1.2 | 9.5 | 6956.7 | md-41 | 6956.7 | 9.49651 | 0.0437001 | 343.046
BEAM | +21.104 | +21.460 | 5 | 7 | 222.5 | 0 | 0.6 | 5.9 | 4362.7 | mc-145 | 4362.72 | 5.9555 | 0.0270051 | 211.99
BEAM | +5.344 | +5.700 | 5 | 7 | 100.5 | 0 | 0.3 | 2.7 | 1970.1 | mc-144 | 1970.1 | 2.68936 | 0.0125544 | 98.5523
BEAM | +28.724 | +29.080 | 6 | 7 | 163.9 | 0 | 0.6 | 4.5 | 3213.4 | md-40 | 3213.4 | 4.38658 | 0.0204773 | 160.747
BEAM | +63.094 | +63.450 | 8 | 7 | 98.5 | 0 | 0.3 | 2.7 | 1931.1 | mf-85 | 1931.1 | 2.63612 | 0.0123059 | 96.6014
BEAM | +57.664 | +58.020 | 8 | 7 | 98.5 | 0 | 0.3 | 2.7 | 1931.1 | mf-85 | 1931.1 | 2.63612 | 0.0123059 | 96.6013
BEAM | +54.949 | +55.305 | 8 | 7 | 98.5 | 0 | 0.3 | 2.7 | 1931.1 | mf-85 | 1931.1 | 2.63612 | 0.0123059 | 96.6013
BEAM | +52.684 | +53.040 | 8 | 7 | 98.5 | 0 | 0.3 | 2.7 | 1931.1 | mf-85 | 1931.1 | 2.63612 | 0.0123059 | 96.6013
BEAM | +44.219 | +44.575 | 7 | 7 | 164.4 | 0 | 0.6 | 4.5 | 3223.1 | me-51 | 3223.1 | 4.39982 | 0.0205391 | 161.232
BEAM | +38.682 | +39.038 | 7 | 7 | 164.4 | 0 | 0.6 | 4.5 | 3223.1 | me-51 | 3223.1 | 4.39982 | 0.0205391 | 161.232
BEAM | +35.914 | +36.270 | 6 | 7 | 163.9 | 0 | 0.6 | 4.5 | 3213.4 | md-40 | 3213.4 | 4.38658 | 0.0204773 | 160.747
BEAM | +31.372 | +31.728 | 6 | 7 | 163.9 | 0 | 0.6 | 4.5 | 3213.4 | md-40 | 3213.4 | 4.38657 | 0.0204773 | 160.747
BEAM | +23.962 | +24.318 | 5 | 7 | 163.9 | 0 | 0.6 | 4.5 | 3213.4 | mc-143 | 3213.4 | 4.38657 | 0.0204773 | 160.747
BEAM | +21.104 | +21.460 | 5 | 7 | 313.1 | 0 | 1.1 | 8.5 | 6138.5 | mc-142 | 6138.5 | 8.37959 | 0.0391175 | 307.072
BEAM | +5.344 | +5.700 | 5 | 7 | 77.7 | 0 | 0.3 | 2.1 | 1524.1 | mc-126 | 1524.1 | 2.08053 | 0.0097123 | 76.2416
BEAM | +5.344 | +5.700 | 5 | 23 | 162.7 | 0 | 0.5 | 4.5 | 3189.5 | mc-125 | 3189.5 | 4.35395 | 0.020325 | 159.551
2 x BEAM | +19.116 | +19.472 | 5 | 6 | 16.7 | 0 | 0.1 | 0.5 | 326.1 | mc-141 | 326.1 | 0.445155 | 0.00207807 | 16.3128
BEAM | +19.116 | +19.472 | 5 | 6 | 201.3 | 0 | 0.6 | 5.5 | 3946.1 | mc-136 | 3946.1 | 5.38677 | 0.0251464 | 197.4
BEAM | +19.116 | +19.472 | 5 | 6 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mc-135 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +17.094 | +17.450 | 5 | 6 | 201.3 | 0 | 0.6 | 5.5 | 3946.1 | mc-136 | 3946.1 | 5.38677 | 0.0251464 | 197.4
2 x BEAM | +17.094 | +17.450 | 5 | 6 | 303.3 | 0 | 0.9 | 8.2 | 5946.1 | mc-133 | 5946.1 | 8.11695 | 0.0378914 | 297.448
BEAM | +70.294 | +70.650 | 8 | 13 | 156 | 0 | 0.5 | 4.1 | 3058 | mf-82 | 3058 | 4.17444 | 0.019487 | 152.973
BEAM | +70.294 | +70.650 | 8 | 7 | 89.5 | 0 | 0.3 | 2.5 | 1754.1 | mf-75 | 1754.08 | 2.39447 | 0.0111778 | 87.7459
BEAM | +65.894 | +66.250 | 8 | 14 | 89.5 | 0 | 0.3 | 2.5 | 1754.1 | mf-75 | 1754.08 | 2.39447 | 0.0111778 | 87.7459
BEAM | +65.894 | +66.250 | 8 | 13 | 156 | 0 | 0.5 | 4.1 | 3058 | mf-74 | 3058 | 4.17444 | 0.019487 | 152.973
BEAM | +63.094 | +63.450 | 8 | 14 | 86.9 | 0 | 0.3 | 2.5 | 1704.1 | mf-71 | 1704.09 | 2.32623 | 0.0108593 | 85.2453
BEAM | +63.094 | +63.450 | 8 | 13 | 204.4 | 0 | 0.6 | 5.6 | 4008 | mf-70 | 4008 | 5.47127 | 0.0255409 | 200.496
BEAM | +54.949 | +55.305 | 8 | 14 | 43.6 | 0 | 0.1 | 1.3 | 854.1 | mf-68 | 854.091 | 1.16591 | 0.00544268 | 42.725
BEAM | +54.949 | +55.305 | 8 | 13 | 247.8 | 0 | 0.9 | 6.7 | 4858 | mf-87 | 4858 | 6.6316 | 0.0309575 | 243.016
BEAM | +48.344 | +48.700 | 7 | 14 | 43.6 | 0 | 0.1 | 1.3 | 854.1 | me-46 | 854.093 | 1.16591 | 0.00544269 | 42.7251
BEAM | +48.344 | +48.700 | 7 | 13 | 247.8 | 0 | 0.9 | 6.7 | 4858 | me-45 | 4858 | 6.6316 | 0.0309575 | 243.016
BEAM | +44.219 | +44.575 | 7 | 14 | 43.6 | 0 | 0.1 | 1.3 | 854.1 | me-46 | 854.094 | 1.16591 | 0.0054427 | 42.7252
BEAM | +44.219 | +44.575 | 7 | 13 | 247.8 | 0 | 0.9 | 6.7 | 4858 | me-43 | 4858 | 6.6316 | 0.0309575 | 243.016
BEAM | +35.914 | +36.270 | 6 | 14 | 43.1 | 0 | 0.1 | 1.3 | 844.4 | md-36 | 844.396 | 1.15268 | 0.0053809 | 42.2401
BEAM | +35.914 | +36.270 | 6 | 13 | 247.8 | 0 | 0.9 | 6.7 | 4858 | md-34 | 4858 | 6.6316 | 0.0309575 | 243.016
BEAM | +28.724 | +29.080 | 6 | 14 | 43.1 | 0 | 0.1 | 1.3 | 844.4 | md-36 | 844.398 | 1.15268 | 0.00538091 | 42.2401
BEAM | +28.724 | +29.080 | 6 | 13 | 247.8 | 0 | 0.9 | 6.7 | 4858 | md-34 | 4858 | 6.6316 | 0.0309575 | 243.016
2 x BEAM | +70.294 | +70.650 | 8 | 7 | 104.7 | 0 | 0.3 | 3 | 2053.1 | mf-81 | 2053.05 | 2.80259 | 0.013083 | 102.702
2 x BEAM | +63.094 | +63.450 | 8 | 14 | 104.7 | 0 | 0.3 | 3 | 2053.1 | mf-81 | 2053.05 | 2.80259 | 0.013083 | 102.702
2 x BEAM | +54.949 | +55.305 | 8 | 14 | 104.7 | 0 | 0.3 | 3 | 2053.1 | mf-81 | 2053.05 | 2.80259 | 0.013083 | 102.702
BEAM | +48.344 | +48.700 | 7 | 14 | 354.8 | 0 | 1.2 | 9.5 | 6956.7 | me-42 | 6956.7 | 9.49651 | 0.0437001 | 343.046
2 x BEAM | +48.344 | +48.700 | 7 | 14 | 130.5 | 0 | 0.3 | 3.5 | 2558.1 | me-53 | 2558.05 | 3.49196 | 0.0163011 | 127.964
2 x BEAM | +44.219 | +44.575 | 7 | 14 | 104.7 | 0 | 0.3 | 3 | 2053.1 | me-41 | 2053.05 | 2.80259 | 0.013083 | 102.702
2 x BEAM | +35.914 | +36.270 | 6 | 14 | 104.7 | 0 | 0.3 | 2.8 | 2050.2 | md-32 | 2050.15 | 2.79864 | 0.0130645 | 102.557
2 x BEAM | +28.724 | +29.080 | 6 | 14 | 104.7 | 0 | 0.3 | 2.8 | 2050.2 | md-32 | 2050.15 | 2.79864 | 0.0130645 | 102.557
BEAM | +28.724 | +29.080 | 6 | 14 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | md-29 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +28.724 | +29.080 | 6 | 14 | 43.1 | 0 | 0.1 | 1.3 | 844.4 | md-36 | 844.402 | 1.15268 | 0.00538093 | 42.2403
BEAM | +28.724 | +29.080 | 6 | 14 | 354 | 0 | 1.2 | 9.6 | 6940.3 | md-28 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +28.724 | +29.080 | 6 | 14 | 354 | 0 | 1.2 | 9.6 | 6940.3 | md-27 | 6940.3 | 9.47412 | 0.0442269 | 347.181
2 x BEAM | +5.344 | +5.700 | 5 | 23 | 110.2 | 0 | 0.3 | 3 | 2160.5 | mc-120 | 2160.5 | 2.94927 | 0.0137677 | 108.077
2 x BEAM | +5.344 | +5.700 | 5 | 23 | 100 | 0 | 0.3 | 2.7 | 1960.5 | mc-119 | 1960.5 | 2.67625 | 0.0124932 | 98.072
BEAM | +7.488 | +7.844 | 3 | 5 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | ma-60 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +21.104 | +21.460 | 4 | 13 | 247.8 | 0 | 0.9 | 6.7 | 4860 | mb-56 | 4860 | 6.63433 | 0.0309703 | 243.116
2 x BEAM | +21.104 | +21.460 | 4 | 7 | 43.1 | 0 | 0.1 | 1.3 | 844.4 | mb-50 | 844.4 | 1.15268 | 0.00538092 | 42.2402
BEAM | +5.144 | +5.500 | 5 | 12 | 303.8 | 0 | 0.9 | 8.1 | 5956.7 | mc-104 | 5956.7 | 8.13142 | 0.0373276 | 293.022
BEAM | +5.144 | +5.500 | 5 | 5 | 303.8 | 0 | 0.9 | 8.1 | 5956.7 | mc-103 | 5956.7 | 8.13142 | 0.0373276 | 293.022
BEAM | +5.144 | +5.500 | 5 | 5 | 303.8 | 0 | 0.9 | 8.1 | 5956.7 | mc-102 | 5956.7 | 8.13142 | 0.0373276 | 293.022
BEAM | +5.144 | +5.500 | 5 | 5 | 346.6 | 0 | 1.2 | 9.5 | 6796.3 | mc-101 | 6796.35 | 9.27762 | 0.0433096 | 339.98
BEAM | +5.144 | +5.500 | 5 | 5 | 346.6 | 0 | 1.2 | 9.5 | 6796.3 | mc-100 | 6796.35 | 9.27762 | 0.0433096 | 339.98
BEAM | +11.844 | +12.200 | 5 | 12 | 296.8 | 0 | 0.9 | 8.1 | 5819.6 | mc-139 | 5819.6 | 7.94427 | 0.0370853 | 291.119
2 x BEAM | +10.844 | +11.200 | 5 | 5 | 293.8 | 0 | 0.9 | 8.1 | 5760.5 | mc-99 | 5760.5 | 7.86359 | 0.0367087 | 288.163
BEAM | +7.844 | +8.200 | 5 | 5 | 357.1 | 0 | 1.2 | 9.6 | 7001.1 | mc-88 | 7001.1 | 9.55712 | 0.0446144 | 350.223
BEAM | +6.894 | +7.250 | 5 | 5 | 342.7 | 0 | 1.2 | 9.2 | 6718.8 | mc-114 | 6718.8 | 9.17175 | 0.0428154 | 336.101
BEAM | +10.234 | +10.590 | 5 | 14 | 425.8 | 0.1 | 1.5 | 11.6 | 8348.2 | mc-82 | 8348.2 | 11.396 | 0.0531987 | 417.61
BEAM | +4.989 | +5.344 | 5 | 5 | 342.7 | 0 | 1.2 | 9.2 | 6718.8 | mc-114 | 6718.8 | 9.17175 | 0.0428154 | 336.101
BEAM | +5.344 | +5.700 | 5 | 23 | 425.8 | 0.1 | 1.5 | 11.6 | 8348.2 | mc-79 | 8348.2 | 11.396 | 0.0531987 | 417.61
3 x BEAM | +12.144 | +12.500 | 5 | 7 | 425.8 | 0.1 | 1.5 | 11.6 | 8348.2 | mc-76 | 8348.2 | 11.396 | 0.0531987 | 417.61
2 x BEAM | +5.344 | +5.700 | 3 | 23 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | ma-51 | 2328.8 | 3.17902 | 0.0148402 | 116.496
BEAM | +10.234 | +10.590 | 3 | 14 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | ma-48 | 2328.8 | 3.17902 | 0.0148402 | 116.496
3 x BEAM | +17.694 | +18.050 | 4 | 14 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | mb-46 | 2328.8 | 3.17902 | 0.0148402 | 116.496
2 x BEAM | +21.104 | +21.460 | 4 | 7 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | mb-46 | 2328.8 | 3.17902 | 0.0148402 | 116.496
2 x BEAM | +23.962 | +24.318 | 4 | 23 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | mb-46 | 2328.8 | 3.17902 | 0.0148402 | 116.496
2 x BEAM | +15.344 | +15.700 | 4 | 23 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | mb-46 | 2328.8 | 3.17902 | 0.0148402 | 116.496
BEAM | +15.344 | +15.700 | 4 | 23 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | mb-43 | 6628.8 | 9.04889 | 0.0422419 | 331.599
2 x BEAM | +12.144 | +12.500 | 5 | 7 | 46.7 | 0 | 0.2 | 1.3 | 915.5 | mc-129 | 915.5 | 1.24974 | 0.005834 | 45.7969
BEAM | +12.144 | +12.500 | 5 | 7 | 99.6 | 0 | 0.3 | 2.7 | 1953.5 | mc-118 | 1953.5 | 2.6667 | 0.0124486 | 97.7218
2 x BEAM | +12.144 | +12.500 | 5 | 7 | 32.7 | 0 | 0.1 | 0.8 | 641.4 | mc-138 | 641.5 | 0.875704 | 0.00408794 | 32.0904
2 x BEAM | +12.144 | +12.500 | 5 | 7 | 191.8 | 0 | 0.6 | 5.2 | 3760.5 | mc-75 | 3760.5 | 5.13341 | 0.0239637 | 188.115
2 x BEAM | +12.144 | +12.500 | 5 | 7 | 21.9 | 0 | 0.1 | 0.6 | 432.2 | mc-137 | 432.25 | 0.59006 | 0.00275451 | 21.6229
BEAM | +5.344 | +5.700 | 3 | 23 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | ma-42 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +5.344 | +5.700 | 3 | 23 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | ma-59 | 2328.8 | 3.17902 | 0.0148402 | 116.496
BEAM | +5.344 | +5.700 | 3 | 23 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | ma-58 | 2328.8 | 3.17902 | 0.0148402 | 116.496
2 x BEAM | +5.344 | +5.700 | 3 | 23 | 201 | 0 | 0.6 | 5.5 | 3940.3 | ma-57 | 3940.3 | 5.37886 | 0.0251095 | 197.109
BEAM | +5.344 | +5.700 | 3 | 23 | 354 | 0 | 1.2 | 9.6 | 6940.3 | ma-39 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +5.344 | +5.700 | 3 | 23 | 221.4 | 0 | 0.6 | 5.9 | 4340.3 | ma-38 | 4340.3 | 5.92489 | 0.0276585 | 217.119
BEAM | +5.344 | +5.700 | 3 | 23 | 201 | 0 | 0.6 | 5.5 | 3940.3 | ma-56 | 3940.3 | 5.37886 | 0.0251095 | 197.109
BEAM | +5.344 | +5.700 | 3 | 23 | 221.4 | 0 | 0.6 | 5.9 | 4340.3 | ma-55 | 4340.3 | 5.92489 | 0.0276585 | 217.119
BEAM | +10.234 | +10.590 | 3 | 14 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | ma-54 | 2328.8 | 3.17902 | 0.0148402 | 116.496
BEAM | +10.234 | +10.590 | 3 | 14 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | ma-51 | 2328.8 | 3.17902 | 0.0148402 | 116.496
BEAM | +10.234 | +10.590 | 3 | 14 | 354 | 0 | 1.2 | 9.6 | 6940.3 | ma-47 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +10.234 | +10.590 | 3 | 14 | 354 | 0 | 1.2 | 9.6 | 6940.3 | ma-41 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +10.234 | +10.590 | 3 | 14 | 221.4 | 0 | 0.6 | 5.9 | 4340.3 | ma-37 | 4340.3 | 5.92489 | 0.0276585 | 217.119
BEAM | +10.234 | +10.590 | 5 | 14 | 221.8 | 0 | 0.6 | 5.9 | 4346.1 | mc-127 | 4346.1 | 5.93281 | 0.0276954 | 217.409
2 x BEAM | +17.694 | +18.050 | 4 | 14 | 221.4 | 0 | 0.6 | 5.9 | 4340.3 | mb-41 | 4340.3 | 5.92489 | 0.0276585 | 217.119
BEAM | +17.694 | +18.050 | 4 | 14 | 354 | 0 | 1.2 | 9 | 6940.3 | mb-38 | 6940.3 | 9.47412 | 0.0412934 | 324.153
BEAM | +17.694 | +18.050 | 4 | 14 | 354 | 0 | 1.2 | 9 | 6940.3 | mb-37 | 6940.3 | 9.47412 | 0.0412934 | 324.153
2 x BEAM | +28.724 | +29.080 | 6 | 14 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | md-39 | 2328.8 | 3.17902 | 0.0148402 | 116.496
BEAM | +35.914 | +36.270 | 6 | 14 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | md-37 | 2328.8 | 3.17902 | 0.0148402 | 116.496
BEAM | +35.914 | +36.270 | 6 | 14 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | md-39 | 2328.8 | 3.17902 | 0.0148402 | 116.496
BEAM | +35.914 | +36.270 | 6 | 14 | 354 | 0 | 1.2 | 9.6 | 6940.3 | md-25 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +44.219 | +44.575 | 7 | 14 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | me-50 | 2348.2 | 3.2055 | 0.0149639 | 117.466
BEAM | +44.219 | +44.575 | 7 | 14 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | me-47 | 2348.2 | 3.2055 | 0.0149639 | 117.466
2 x BEAM | +48.344 | +48.700 | 7 | 14 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | me-50 | 2348.2 | 3.2055 | 0.0149639 | 117.466
BEAM | +48.344 | +48.700 | 7 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | me-44 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +54.949 | +55.305 | 8 | 14 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | mf-69 | 2348.2 | 3.2055 | 0.0149639 | 117.466
BEAM | +54.949 | +55.305 | 8 | 14 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | mf-84 | 2348.2 | 3.2055 | 0.0149639 | 117.466
BEAM | +70.294 | +70.650 | 8 | 7 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | mf-80 | 2348.2 | 3.2055 | 0.0149639 | 117.466
BEAM | +70.294 | +70.650 | 8 | 7 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | mf-84 | 2348.2 | 3.2055 | 0.0149639 | 117.466
2 x BEAM | +5.344 | +5.700 | 5 | 23 | 201.3 | 0 | 0.6 | 5.5 | 3946.1 | mc-136 | 3946.1 | 5.38677 | 0.0251464 | 197.4
BEAM | +5.344 | +5.700 | 5 | 23 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mc-135 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +5.344 | +5.700 | 5 | 23 | 303.3 | 0 | 0.9 | 8.2 | 5946.1 | mc-73 | 5946.1 | 8.11695 | 0.0378914 | 297.448
BEAM | +5.344 | +5.700 | 5 | 23 | 303.3 | 0 | 0.9 | 8.2 | 5946.1 | mc-72 | 5946.1 | 8.11695 | 0.0378914 | 297.448
BEAM | +15.344 | +15.700 | 5 | 23 | 313.1 | 0 | 1.1 | 8.5 | 6138.5 | mc-70 | 6138.5 | 8.37959 | 0.0391175 | 307.072
BEAM | +15.344 | +15.700 | 5 | 23 | 313.1 | 0 | 1.1 | 8.5 | 6138.5 | mc-69 | 6138.5 | 8.37959 | 0.0391175 | 307.072
2 x BEAM | +2.394 | +2.750 | 5 | 7 | 313.5 | 0 | 1.1 | 8.5 | 6146.5 | mc-134 | 6146.5 | 8.39051 | 0.0391685 | 307.472
BEAM | +2.394 | +2.750 | 5 | 7 | 201.3 | 0 | 0.6 | 5.5 | 3946.1 | mc-67 | 3946.1 | 5.38677 | 0.0251464 | 197.4
BEAM | +2.394 | +2.750 | 5 | 7 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mc-63 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +12.144 | +12.500 | 5 | 7 | 303.3 | 0 | 0.9 | 8.2 | 5946.1 | mc-62 | 5946.1 | 8.11695 | 0.0378914 | 297.448
BEAM | +12.144 | +12.500 | 5 | 7 | 201.3 | 0 | 0.6 | 5.5 | 3946.1 | mc-74 | 3946.1 | 5.38677 | 0.0251464 | 197.4
BEAM | +12.144 | +12.500 | 5 | 7 | 303.3 | 0 | 0.9 | 8.2 | 5946.1 | mc-87 | 5946.1 | 8.11695 | 0.0378914 | 297.448
BEAM | +12.144 | +12.500 | 5 | 7 | 201.3 | 0 | 0.6 | 5.5 | 3946.1 | mc-98 | 3946.1 | 5.38677 | 0.0251464 | 197.4
BEAM | +12.144 | +12.500 | 5 | 7 | 221.8 | 0 | 0.6 | 5.9 | 4346.1 | mc-97 | 4346.1 | 5.93281 | 0.0276954 | 217.409
BEAM | +15.344 | +15.700 | 4 | 23 | 354 | 0 | 1.2 | 9.6 | 6940.3 | mb-54 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +15.344 | +15.700 | 5 | 23 | 221.8 | 0 | 0.6 | 5.9 | 4346.1 | mc-61 | 4346.1 | 5.93281 | 0.0276954 | 217.409
BEAM | +65.894 | +66.250 | 8 | 14 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | mf-79 | 2348.2 | 3.2055 | 0.0149639 | 117.466
BEAM | +70.294 | +70.650 | 8 | 7 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-67 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +63.094 | +63.450 | 8 | 14 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | mf-69 | 2348.2 | 3.2055 | 0.0149639 | 117.466
2 x BEAM | +57.664 | +58.020 | 8 | 7 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | mf-84 | 2348.2 | 3.2055 | 0.0149639 | 117.466
BEAM | +54.949 | +55.305 | 8 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-67 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +54.949 | +55.305 | 8 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-65 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +57.664 | +58.020 | 8 | 7 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-86 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +57.664 | +58.020 | 8 | 7 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-78 | 6946.1 | 9.48204 | 0.0442639 | 347.471
2 x BEAM | +52.684 | +53.040 | 8 | 7 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | mf-84 | 2348.2 | 3.2055 | 0.0149639 | 117.466
2 x BEAM | +52.684 | +53.040 | 8 | 7 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-77 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +44.219 | +44.575 | 7 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | me-48 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +35.914 | +36.270 | 6 | 14 | 354 | 0 | 1.2 | 9.6 | 6940.3 | md-31 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +38.682 | +39.038 | 7 | 7 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | me-48 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +38.682 | +39.038 | 7 | 7 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | me-47 | 2348.2 | 3.2055 | 0.0149639 | 117.466
2 x BEAM | +31.372 | +31.728 | 6 | 7 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | md-39 | 2328.8 | 3.17902 | 0.0148402 | 116.496
BEAM | +21.104 | +21.460 | 4 | 7 | 354 | 0 | 1.2 | 9.6 | 6940.3 | mb-52 | 6940.3 | 9.47412 | 0.0442269 | 347.181
2 x BEAM | +23.962 | +24.318 | 4 | 23 | 354 | 0 | 1.2 | 9.6 | 6940.3 | mb-53 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +17.694 | +18.050 | 4 | 14 | 354 | 0 | 1.2 | 9.6 | 6940.3 | mb-52 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +15.344 | +15.700 | 4 | 23 | 354 | 0 | 1.2 | 9.6 | 6940.3 | mb-55 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +2.394 | +2.750 | 5 | 7 | 191.8 | 0 | 0.6 | 5.2 | 3760.5 | mc-86 | 3760.5 | 5.13341 | 0.0239637 | 188.115
BEAM | +10.234 | +10.590 | 5 | 14 | 319.3 | 0 | 1.1 | 8.7 | 6260.5 | mc-66 | 6260.5 | 8.54613 | 0.0398949 | 313.175
BEAM | +10.234 | +10.590 | 5 | 14 | 319.3 | 0 | 1.1 | 8.7 | 6260.5 | mc-65 | 6260.5 | 8.54613 | 0.0398949 | 313.175
BEAM | +10.234 | +10.590 | 3 | 14 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | ma-46 | 2328.8 | 3.17902 | 0.0148402 | 116.496
BEAM | +10.234 | +10.590 | 3 | 14 | 201 | 0 | 0.6 | 5.5 | 3940.3 | ma-34 | 3940.3 | 5.37886 | 0.0251095 | 197.109
BEAM | +10.234 | +10.590 | 3 | 14 | 201 | 0 | 0.6 | 5.5 | 3940.3 | ma-36 | 3940.3 | 5.37886 | 0.0251095 | 197.109
BEAM | +10.234 | +10.590 | 3 | 14 | 201 | 0 | 0.6 | 5.5 | 3940.3 | ma-53 | 3940.3 | 5.37886 | 0.0251095 | 197.109
BEAM | +5.344 | +5.700 | 5 | 23 | 221.8 | 0 | 0.6 | 5.9 | 4346.1 | mc-96 | 4346.1 | 5.93281 | 0.0276954 | 217.409
BEAM | +5.344 | +5.700 | 5 | 23 | 221.8 | 0 | 0.6 | 5.9 | 4346.1 | mc-95 | 4346.1 | 5.93281 | 0.0276954 | 217.409
BEAM | +5.344 | +5.700 | 5 | 23 | 431.5 | 0.1 | 1.5 | 11.6 | 8460.5 | mc-68 | 8460.5 | 11.5493 | 0.0539144 | 423.228
BEAM | +5.344 | +5.700 | 5 | 23 | 212.2 | 0 | 0.6 | 5.9 | 4160.5 | mc-117 | 4160.5 | 5.67945 | 0.0265127 | 208.125
2 x BEAM | +5.344 | +5.700 | 5 | 23 | 425.8 | 0.1 | 1.5 | 11.6 | 8348.2 | mc-131 | 8348.2 | 11.396 | 0.0531987 | 417.61
BEAM | +10.234 | +10.590 | 3 | 14 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | ma-32 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +10.234 | +10.590 | 3 | 14 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | ma-31 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +10.234 | +10.590 | 3 | 14 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | ma-29 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +21.104 | +21.460 | 4 | 7 | 354 | 0 | 1.2 | 9.6 | 6940.3 | mb-36 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +21.104 | +21.460 | 4 | 7 | 354 | 0 | 1.2 | 9.6 | 6940.3 | mb-35 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +21.104 | +21.460 | 4 | 7 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | mb-34 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +15.344 | +15.700 | 4 | 23 | 201 | 0 | 0.6 | 5.5 | 3940.3 | mb-47 | 3940.3 | 5.37886 | 0.0251095 | 197.109
BEAM | +15.344 | +15.700 | 5 | 23 | 201.3 | 0 | 0.6 | 5.5 | 3946.1 | mc-116 | 3946.1 | 5.38677 | 0.0251464 | 197.4
BEAM | +35.914 | +36.270 | 6 | 14 | 354 | 0 | 1.2 | 9.6 | 6940.3 | md-26 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +35.914 | +36.270 | 6 | 14 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | md-24 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +44.219 | +44.575 | 7 | 14 | 43.6 | 0 | 0.1 | 1.3 | 854.1 | me-46 | 854.106 | 1.16593 | 0.00544277 | 42.7257
BEAM | +54.949 | +55.305 | 8 | 14 | 43.6 | 0 | 0.1 | 1.3 | 854.1 | mf-68 | 854.108 | 1.16593 | 0.00544279 | 42.7259
BEAM | +70.294 | +70.650 | 8 | 7 | 339.1 | 0 | 1.1 | 9.2 | 6648.2 | mf-63 | 6648.2 | 9.07538 | 0.0423655 | 332.569
BEAM | +44.219 | +44.575 | 7 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | me-39 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +44.219 | +44.575 | 7 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | me-38 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +44.219 | +44.575 | 7 | 14 | 339.1 | 0 | 1.1 | 9.2 | 6648.2 | me-37 | 6648.2 | 9.07538 | 0.0423655 | 332.569
BEAM | +54.949 | +55.305 | 8 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-61 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +54.949 | +55.305 | 8 | 14 | 339.1 | 0 | 1.1 | 9.2 | 6648.2 | mf-62 | 6648.2 | 9.07538 | 0.0423655 | 332.569
BEAM | +2.394 | +2.750 | 5 | 7 | 344.8 | 0 | 1.2 | 9.5 | 6760.5 | mc-124 | 6760.5 | 9.22868 | 0.0430812 | 338.187
BEAM | +65.894 | +66.250 | 8 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-67 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +65.894 | +66.250 | 8 | 14 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | mf-84 | 2348.2 | 3.2055 | 0.0149639 | 117.466
BEAM | +63.094 | +63.450 | 8 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-76 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +63.094 | +63.450 | 8 | 14 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | mf-84 | 2348.2 | 3.2055 | 0.0149639 | 117.466
BEAM | +38.682 | +39.038 | 7 | 7 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | me-36 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +38.682 | +39.038 | 7 | 7 | 119.8 | 0 | 0.3 | 3.3 | 2348.2 | me-50 | 2348.2 | 3.2055 | 0.0149639 | 117.466
BEAM | +31.372 | +31.728 | 6 | 7 | 354 | 0 | 1.2 | 9.6 | 6940.3 | md-30 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +31.372 | +31.728 | 6 | 7 | 354 | 0 | 1.2 | 9.6 | 6940.3 | md-33 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +15.344 | +15.700 | 4 | 23 | 354 | 0 | 1.2 | 9.6 | 6940.3 | mb-51 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +65.894 | +66.250 | 8 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-60 | 6946.1 | 9.48204 | 0.0442639 | 347.471
2 x BEAM | +38.682 | +39.038 | 7 | 7 | 339.1 | 0 | 1.1 | 9.2 | 6648.2 | me-49 | 6648.2 | 9.07538 | 0.0423655 | 332.569
2 x BEAM | +31.372 | +31.728 | 6 | 7 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | md-38 | 6628.8 | 9.04889 | 0.0422419 | 331.599
2 x BEAM | +23.962 | +24.318 | 4 | 23 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | mb-45 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +2.394 | +2.750 | 3 | 7 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | ma-45 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +2.394 | +2.750 | 3 | 7 | 338.5 | 0 | 1.1 | 9.2 | 6636.8 | ma-44 | 6636.8 | 9.05982 | 0.0422929 | 331.999
BEAM | +2.394 | +2.750 | 5 | 7 | 313.5 | 0 | 1.1 | 8.5 | 6146.5 | mc-115 | 6146.5 | 8.39051 | 0.0391685 | 307.472
BEAM | +63.094 | +63.450 | 8 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-58 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +63.094 | +63.450 | 8 | 14 | 339.1 | 0 | 1.1 | 9.2 | 6648.2 | mf-56 | 6648.2 | 9.07538 | 0.0423655 | 332.569
2 x BEAM | +57.664 | +58.020 | 8 | 7 | 339.1 | 0 | 1.1 | 9.2 | 6648.2 | mf-83 | 6648.2 | 9.07538 | 0.0423655 | 332.569
BEAM | +63.094 | +63.450 | 8 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-57 | 6946.1 | 9.48204 | 0.0442639 | 347.471
2 x BEAM | +5.344 | +5.700 | 5 | 23 | 303.3 | 0 | 0.9 | 8.2 | 5946.1 | mc-133 | 5946.1 | 8.11695 | 0.0378914 | 297.448
BEAM | +12.144 | +12.500 | 5 | 7 | 303.3 | 0 | 0.9 | 8.2 | 5946.1 | mc-57 | 5946.1 | 8.11695 | 0.0378914 | 297.448
BEAM | +12.144 | +12.500 | 5 | 7 | 303.3 | 0 | 0.9 | 8.2 | 5946.1 | mc-85 | 5946.1 | 8.11695 | 0.0378914 | 297.448
BEAM | +70.294 | +70.650 | 8 | 7 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-64 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +35.914 | +36.270 | 6 | 14 | 43.1 | 0 | 0.1 | 1.3 | 844.4 | md-36 | 844.404 | 1.15269 | 0.00538095 | 42.2404
BEAM | +70.294 | +70.650 | 8 | 7 | 89.5 | 0 | 0.3 | 2.5 | 1754.1 | mf-75 | 1754.12 | 2.39453 | 0.0111781 | 87.7482
BEAM | +63.094 | +63.450 | 8 | 14 | 43.6 | 0 | 0.1 | 1.3 | 854.1 | mf-55 | 854.11 | 1.16594 | 0.0054428 | 42.726
BEAM | +48.344 | +48.700 | 7 | 14 | 164.4 | 0 | 0.6 | 4.5 | 3224.9 | me-35 | 3224.85 | 4.4022 | 0.0205503 | 161.32
BEAM | +48.344 | +48.700 | 7 | 14 | 339.1 | 0 | 1.1 | 9.2 | 6648.2 | me-34 | 6648.2 | 9.07538 | 0.0423655 | 332.569
BEAM | +48.344 | +48.700 | 7 | 14 | 164.4 | 0 | 0.6 | 4.5 | 3224.9 | me-33 | 3224.85 | 4.4022 | 0.0205503 | 161.32
BEAM | +48.344 | +48.700 | 7 | 14 | 43.6 | 0 | 0.1 | 1.3 | 854.1 | me-46 | 854.106 | 1.16593 | 0.00544278 | 42.7258
BEAM | +17.694 | +18.050 | 4 | 14 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | mb-33 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +17.694 | +18.050 | 4 | 14 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | mb-42 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +10.234 | +10.590 | 3 | 14 | 354 | 0 | 1.2 | 9.6 | 6940.3 | ma-28 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +5.344 | +5.700 | 5 | 23 | 313.1 | 0 | 1.1 | 8.5 | 6138.5 | mc-56 | 6138.5 | 8.37959 | 0.0391175 | 307.072
BEAM | +5.344 | +5.700 | 3 | 23 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | ma-27 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +5.344 | +5.700 | 3 | 23 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | ma-40 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +5.344 | +5.700 | 3 | 23 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | ma-30 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +5.344 | +5.700 | 5 | 23 | 284.9 | 0 | 0.9 | 7.7 | 5585.5 | mc-54 | 5585.5 | 7.6247 | 0.0355935 | 279.409
BEAM | +5.344 | +5.700 | 5 | 23 | 425.8 | 0.1 | 1.5 | 11.6 | 8348.2 | mc-78 | 8348.2 | 11.396 | 0.0531987 | 417.61
BEAM | +5.344 | +5.700 | 5 | 23 | 425.8 | 0.1 | 1.5 | 11.6 | 8348.2 | mc-60 | 8348.2 | 11.396 | 0.0531987 | 417.61
BEAM | +5.344 | +5.700 | 5 | 23 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mc-53 | 6946.1 | 9.48204 | 0.0442639 | 347.471
2 x BEAM | +17.694 | +18.050 | 4 | 14 | 104.7 | 0 | 0.3 | 2.8 | 2050.2 | mb-49 | 2050.15 | 2.79864 | 0.0130645 | 102.557
BEAM | +38.682 | +39.038 | 7 | 7 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | me-32 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +15.344 | +15.700 | 4 | 23 | 118.8 | 0 | 0.3 | 3.2 | 2328.8 | mb-32 | 2328.8 | 3.17902 | 0.0148402 | 116.496
BEAM | +5.344 | +5.700 | 5 | 23 | 425.8 | 0.1 | 1.5 | 11.6 | 8348.2 | mc-71 | 8348.2 | 11.396 | 0.0531987 | 417.61
BEAM | +5.344 | +5.700 | 3 | 23 | 354 | 0 | 1.2 | 9.6 | 6940.3 | ma-24 | 6940.3 | 9.47412 | 0.0442269 | 347.181
2 x BEAM | +15.344 | +15.700 | 4 | 23 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | mb-45 | 6628.8 | 9.04889 | 0.0422419 | 331.599
2 x BEAM | +15.344 | +15.700 | 4 | 23 | 221.4 | 0 | 0.6 | 5.9 | 4340.3 | mb-44 | 4340.3 | 5.92489 | 0.0276585 | 217.119
BEAM | +2.394 | +2.750 | 5 | 7 | 212.2 | 0 | 0.6 | 5.9 | 4160.5 | mc-123 | 4160.5 | 5.67945 | 0.0265127 | 208.125
BEAM | +10.844 | +11.200 | 5 | 5 | 342.7 | 0 | 1.2 | 9.2 | 6718.8 | mc-114 | 6718.8 | 9.17175 | 0.0428154 | 336.101
BEAM | +8.844 | +9.200 | 5 | 5 | 342.7 | 0 | 1.2 | 9.2 | 6718.8 | mc-114 | 6718.8 | 9.17175 | 0.0428154 | 336.101
2 x BEAM | +10.844 | +11.200 | 5 | 5 | 357.1 | 0 | 1.2 | 9.6 | 7001.1 | mc-64 | 7001.1 | 9.55712 | 0.0446144 | 350.223
BEAM | +8.844 | +9.200 | 5 | 5 | 357.1 | 0 | 1.2 | 9.6 | 7001.1 | mc-84 | 7001.1 | 9.55712 | 0.0446144 | 350.223
BEAM | +8.844 | +9.200 | 5 | 5 | 357.1 | 0 | 1.2 | 9.6 | 7001.1 | mc-94 | 7001.1 | 9.55712 | 0.0446144 | 350.223
BEAM | +10.234 | +10.590 | 5 | 14 | 313.1 | 0 | 1.1 | 8.5 | 6138.5 | mc-93 | 6138.5 | 8.37959 | 0.0391175 | 307.072
BEAM | +10.844 | +11.200 | 5 | 5 | 357.1 | 0 | 1.2 | 9.6 | 7001.1 | mc-52 | 7001.1 | 9.55712 | 0.0446144 | 350.223
BEAM | +8.844 | +9.200 | 5 | 5 | 357.1 | 0 | 1.2 | 9.6 | 7001.1 | mc-122 | 7001.1 | 9.55712 | 0.0446144 | 350.223
BEAM | +10.844 | +11.200 | 5 | 5 | 357.1 | 0 | 1.2 | 9.6 | 7001.1 | mc-81 | 7001.1 | 9.55712 | 0.0446144 | 350.223
BEAM | +8.844 | +9.200 | 5 | 5 | 357.1 | 0 | 1.2 | 9.6 | 7001.1 | mc-55 | 7001.1 | 9.55712 | 0.0446144 | 350.223
BEAM | +9.844 | +10.200 | 5 | 12 | 296.4 | 0 | 0.9 | 8.1 | 5811.6 | mc-132 | 5811.6 | 7.93335 | 0.0370343 | 290.719
2 x BEAM | +52.684 | +53.040 | 8 | 7 | 339.1 | 0 | 1.1 | 9.2 | 6648.2 | mf-83 | 6648.2 | 9.07538 | 0.0423655 | 332.569
BEAM | +52.684 | +53.040 | 8 | 7 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-66 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +48.344 | +48.700 | 7 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | me-40 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +10.234 | +10.590 | 3 | 14 | 221.4 | 0 | 0.6 | 5.9 | 4340.3 | ma-23 | 4340.3 | 5.92489 | 0.0276585 | 217.119
BEAM | +10.234 | +10.590 | 3 | 14 | 221.4 | 0 | 0.6 | 5.9 | 4340.3 | ma-33 | 4340.3 | 5.92489 | 0.0276585 | 217.119
BEAM | +5.344 | +5.700 | 3 | 23 | 221.4 | 0 | 0.6 | 5.9 | 4340.3 | ma-22 | 4340.3 | 5.92489 | 0.0276585 | 217.119
BEAM | +5.344 | +5.700 | 3 | 23 | 104.8 | 0 | 0.3 | 3 | 2055.2 | ma-43 | 2055.15 | 2.80546 | 0.0130964 | 102.807
BEAM | +5.344 | +5.700 | 3 | 23 | 104.8 | 0 | 0.3 | 3 | 2055.2 | ma-35 | 2055.15 | 2.80546 | 0.0130964 | 102.807
2 x BEAM | +21.104 | +21.460 | 4 | 7 | 66.6 | 0 | 0.2 | 1.7 | 1305.9 | mb-31 | 1305.9 | 1.78267 | 0.00832182 | 65.3263
BEAM | +21.104 | +21.460 | 4 | 7 | 354.8 | 0 | 1.2 | 9.5 | 6956.7 | mb-30 | 6956.7 | 9.49651 | 0.0437001 | 343.046
BEAM | +48.344 | +48.700 | 7 | 14 | 354.8 | 0 | 1.2 | 9.5 | 6956.7 | me-31 | 6956.7 | 9.49651 | 0.0437001 | 343.046
BEAM | +48.344 | +48.700 | 7 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | me-29 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +57.664 | +58.020 | 8 | 7 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-73 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +31.372 | +31.728 | 6 | 7 | 354 | 0 | 1.2 | 9.6 | 6940.3 | md-23 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +23.962 | +24.318 | 4 | 23 | 354 | 0 | 1.2 | 9.6 | 6940.3 | mb-40 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +47.005 | +47.361 | 7 | 7 | 339.1 | 0 | 1.1 | 9.2 | 6648.2 | me-49 | 6648.2 | 9.07538 | 0.0423655 | 332.569
BEAM | +17.694 | +18.050 | 4 | 14 | 221.4 | 0 | 0.6 | 5.9 | 4340.3 | mb-44 | 4340.3 | 5.92489 | 0.0276585 | 217.119
BEAM | +15.344 | +15.700 | 4 | 23 | 221.4 | 0 | 0.6 | 5.9 | 4340.3 | mb-48 | 4340.3 | 5.92489 | 0.0276585 | 217.119
BEAM | +28.724 | +29.080 | 6 | 14 | 354 | 0 | 1.2 | 9.6 | 6940.3 | md-35 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +5.344 | +5.700 | 3 | 23 | 354 | 0 | 1.2 | 9.6 | 6940.3 | ma-26 | 6940.3 | 9.47412 | 0.0442269 | 347.181
BEAM | +2.394 | +2.750 | 5 | 7 | 221.8 | 0 | 0.6 | 5.9 | 4346.1 | mc-59 | 4346.1 | 5.93281 | 0.0276954 | 217.409
2 x BEAM | +5.344 | +5.700 | 3 | 23 | 191.8 | 0 | 0.6 | 5.2 | 3760.5 | ma-50 | 3760.5 | 5.13341 | 0.0239637 | 188.115
BEAM | +5.344 | +5.700 | 3 | 23 | 64.3 | 0 | 0.2 | 1.7 | 1260.5 | ma-49 | 1260.5 | 1.72069 | 0.00803251 | 63.0552
BEAM | +5.344 | +5.700 | 3 | 23 | 64.3 | 0 | 0.2 | 1.7 | 1260.5 | ma-52 | 1260.5 | 1.72069 | 0.00803251 | 63.0552
BEAM | +10.234 | +10.590 | 3 | 14 | 338.1 | 0 | 1.1 | 9.2 | 6628.8 | ma-25 | 6628.8 | 9.04889 | 0.0422419 | 331.599
BEAM | +65.894 | +66.250 | 8 | 14 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-59 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +65.894 | +66.250 | 8 | 14 | 97.4 | 0 | 0.3 | 2.7 | 1909.9 | mf-54 | 1909.85 | 2.60711 | 0.0121705 | 95.5383
BEAM | +65.894 | +66.250 | 8 | 14 | 339.1 | 0 | 1.1 | 9.2 | 6648.2 | mf-52 | 6648.2 | 9.07538 | 0.0423655 | 332.569
BEAM | +65.894 | +66.250 | 8 | 14 | 98.5 | 0 | 0.3 | 2.7 | 1931.1 | mf-53 | 1931.1 | 2.63612 | 0.0123059 | 96.6013
BEAM | +65.894 | +66.250 | 8 | 14 | 89.5 | 0 | 0.3 | 2.5 | 1754.1 | mf-72 | 1754.12 | 2.39453 | 0.0111781 | 87.7481
BEAM | +65.894 | +66.250 | 8 | 14 | 354.8 | 0 | 1.2 | 9.5 | 6956.7 | mf-51 | 6956.7 | 9.49651 | 0.0437001 | 343.046
BEAM | +15.344 | +15.700 | 5 | 23 | 313.1 | 0 | 1.1 | 8.5 | 6138.5 | mc-58 | 6138.5 | 8.37959 | 0.0391175 | 307.072
BEAM | +15.344 | +15.700 | 5 | 23 | 313.1 | 0 | 1.1 | 8.5 | 6138.5 | mc-51 | 6138.5 | 8.37959 | 0.0391175 | 307.072
BEAM | +12.144 | +12.500 | 5 | 7 | 430.3 | 0.1 | 1.5 | 11.6 | 8436.5 | mc-50 | 8436.5 | 11.5166 | 0.0537614 | 422.027
BEAM | +12.144 | +12.500 | 5 | 7 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mc-92 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +12.144 | +12.500 | 5 | 7 | 430.3 | 0.1 | 1.5 | 11.6 | 8436.5 | mc-47 | 8436.5 | 11.5166 | 0.0537614 | 422.027
BEAM | +12.144 | +12.500 | 5 | 7 | 425.8 | 0.1 | 1.5 | 11.6 | 8348.2 | mc-131 | 8348.2 | 11.396 | 0.0531987 | 417.61
BEAM | +12.144 | +12.500 | 5 | 7 | 427.7 | 0.1 | 1.5 | 11.6 | 8387.2 | mc-49 | 8387.25 | 11.4493 | 0.0534476 | 419.563
2 x BEAM | +12.144 | +12.500 | 5 | 7 | 427.2 | 0.1 | 1.5 | 11.6 | 8377.2 | mc-46 | 8377.25 | 11.4357 | 0.0533839 | 419.063
BEAM | +12.144 | +12.500 | 5 | 7 | 77.7 | 0 | 0.3 | 2.1 | 1524.1 | mc-113 | 1524.1 | 2.08053 | 0.0097123 | 76.2416
2 x BEAM | +12.144 | +12.500 | 5 | 7 | 121.8 | 0 | 0.3 | 3.3 | 2387.5 | mc-111 | 2387.5 | 3.25915 | 0.0152143 | 119.432
2 x BEAM | +12.144 | +12.500 | 5 | 7 | 207.8 | 0 | 0.6 | 5.6 | 4074 | mc-83 | 4074 | 5.56137 | 0.0259615 | 203.798
2 x BEAM | +12.144 | +12.500 | 5 | 7 | 100.1 | 0 | 0.3 | 2.7 | 1962.2 | mc-112 | 1962.25 | 2.67864 | 0.0125044 | 98.1595
2 x BEAM | +12.144 | +12.500 | 5 | 7 | 22.6 | 0 | 0.1 | 0.6 | 442.2 | mc-130 | 442.25 | 0.60371 | 0.00281823 | 22.1231
2 x BEAM | +12.144 | +12.500 | 5 | 7 | 425.8 | 0.1 | 1.5 | 11.6 | 8348.2 | mc-77 | 8348.2 | 11.396 | 0.0531987 | 417.61
BEAM | +12.144 | +12.500 | 5 | 7 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mc-45 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +12.144 | +12.500 | 5 | 7 | 100.9 | 0 | 0.3 | 2.7 | 1977.5 | mc-110 | 1977.5 | 2.69946 | 0.0126016 | 98.9224
BEAM | +12.144 | +12.500 | 5 | 7 | 431.5 | 0.1 | 1.5 | 11.6 | 8460.5 | mc-48 | 8460.5 | 11.5493 | 0.0539144 | 423.228
2 x BEAM | +12.144 | +12.500 | 5 | 7 | 173.9 | 0 | 0.6 | 4.7 | 3412.2 | mc-91 | 3412.25 | 4.65802 | 0.0217445 | 170.694
BEAM | +70.294 | +70.650 | 8 | 7 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mf-50 | 6946.1 | 9.48204 | 0.0442639 | 347.471
BEAM | +15.344 | +15.700 | 5 | 23 | 319.3 | 0 | 1.1 | 8.7 | 6260.5 | mc-44 | 6260.5 | 8.54613 | 0.0398949 | 313.175
BEAM | +15.344 | +15.700 | 5 | 23 | 354.3 | 0 | 1.2 | 9.6 | 6946.1 | mc-90 | 6946.1 | 9.48204 | 0.0442639 | 347.471
2 x BEAM | +5.344 | +5.700 | 5 | 23 | 84.7 | 0 | 0.3 | 2.3 | 1660.5 | mc-106 | 1660.5 | 2.26673 | 0.0105815 | 83.0648
BEAM | +5.344 | +5.700 | 5 | 23 | 344.1 | 0 | 1.2 | 9.2 | 6747.6 | mc-89 | 6747.65 | 9.21114 | 0.0429993 | 337.544
BEAM | +5.344 | +5.700 | 5 | 23 | 344.1 | 0 | 1.2 | 9.2 | 6747.6 | mc-109 | 6747.65 | 9.21114 | 0.0429993 | 337.544
2 x BEAM | +5.344 | +5.700 | 5 | 23 | 191.3 | 0 | 0.6 | 5.2 | 3751.3 | mc-108 | 3751.3 | 5.12085 | 0.0239051 | 187.655
BEAM | +5.344 | +5.700 | 5 | 23 | 212 | 0 | 0.6 | 5.9 | 4156.8 | mc-128 | 4156.85 | 5.67447 | 0.0264894 | 207.942
BEAM | +5.344 | +5.700 | 5 | 23 | 212 | 0 | 0.6 | 5.9 | 4156.8 | mc-107 | 4156.85 | 5.67447 | 0.0264894 | 207.942
BEAM | +12.144 | +12.500 | 5 | 7 | 221.8 | 0 | 0.6 | 5.9 | 4346.1 | mc-127 | 4346.1 | 5.93281 | 0.0276954 | 217.409
BEAM | +17.694 | +18.050 | 4 | 14 | 338.5 | 0 | 1.1 | 9.2 | 6636.8 | mb-39 | 6636.8 | 9.05982 | 0.0422929 | 331.999
BEAM | +5.344 | +5.700 | 5 | 23 | 162.7 | 0 | 0.5 | 4.5 | 3189.5 | mc-80 | 3189.5 | 4.35395 | 0.020325 | 159.551
BEAM | +5.344 | +5.700 | 5 | 23 | 313.1 | 0 | 1.1 | 8.5 | 6138.5 | mc-121 | 6138.5 | 8.37959 | 0.0391175 | 307.072
BEAM | +2.394 | +2.750 | 5 | 7 | 313.1 | 0 | 1.1 | 8.5 | 6138.5 | mc-105 | 6138.5 | 8.37959 | 0.0391175 | 307.072

# IfcBeam: UB406*178*67, BEAM
In: Undefined
Description: UB406*178*67; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +5.291; Top elevation: +5.700; Phase: 5; Class: 23
Tekla Quantity - Weight: 411.9 kg; Volume: 0.1 m3; Gross footprint area: 1.1 m2; Area per tons: 22.2 m2; Net surface area: 9.2 m2; Height: 409.4 mm; Width: 178.8 mm; Length: 6138.5 mm
Pset_BeamCommon - LoadBearing: yes; Reference: mc-465
BaseQuantities - Length: 6138.5 mm; OuterSurfaceArea: 9.20092 m2; NetVolume: 0.0519607 m3; NetWeight: 407.891 kg

# IfcBeam: UB457*191*67, BEAM
In: Undefined
Description: UB457*191*67; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +5.246; Top elevation: +5.700; Phase: 5; Class: 23
Tekla Quantity - Weight: 411.9 kg; Volume: 0.1 m3; Gross footprint area: 1.2 m2; Area per tons: 24.3 m2; Net surface area: 10.1 m2; Height: 453.6 mm; Width: 189.9 mm; Length: 6138.5 mm
Pset_BeamCommon - LoadBearing: yes; Reference: mc-165
BaseQuantities - Length: 6138.5 mm; OuterSurfaceArea: 10.0198 m2; NetVolume: 0.0519511 m3; NetWeight: 407.816 kg

# IfcBeam: UC152*152*23 (152)
In: Undefined
Description: UC152*152*23; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 38.7 m2; Height: 152.4 mm; Width: 152.4 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
LIGHT SUPPORT | +63.098 | +63.250 | 8 | 6 | 24.2 | 0.2 | 1 | 1050 | mf-160 | 1050 | 0.93361 | 0.00306529 | 24.0625
3 x LIGHT SUPPORT | +62.942 | +63.094 | 8 | 6 | 24.2 | 0.2 | 1 | 1056 | mf-156 | 1056 | 0.938945 | 0.0030828 | 24.2
2 x LIGHT SUPPORT | +63.098 | +63.250 | 8 | 6 | 24.2 | 0.2 | 1 | 1050.3 | mf-155 | 1050.29 | 0.933868 | 0.00306613 | 24.0691
LIGHT SUPPORT | +70.142 | +70.294 | 8 | 6 | 27.9 | 0.2 | 1.1 | 1212 | mf-159 | 1212 | 1.07765 | 0.00353822 | 27.775
LIGHT SUPPORT | +70.468 | +70.620 | 8 | 6 | 9.3 | 0.1 | 0.5 | 405.5 | mf-154 | 405.5 | 0.360551 | 0.00118378 | 9.29271
2 x LIGHT SUPPORT | +70.298 | +70.450 | 8 | 6 | 24.2 | 0.2 | 1 | 1050.3 | mf-155 | 1050.29 | 0.933868 | 0.00306613 | 24.0691
3 x LIGHT SUPPORT | +70.142 | +70.294 | 8 | 6 | 24.2 | 0.2 | 1 | 1056 | mf-156 | 1056 | 0.938945 | 0.0030828 | 24.2
LIGHT SUPPORT | +70.142 | +70.294 | 8 | 6 | 34.7 | 0.2 | 1.5 | 1509.5 | mf-152 | 1509.54 | 1.34221 | 0.00440684 | 34.5937
7 x LIGHT SUPPORT | +65.742 | +65.894 | 8 | 6 | 24.2 | 0.2 | 1 | 1056 | mf-156 | 1056 | 0.938945 | 0.0030828 | 24.2
LIGHT SUPPORT | +65.742 | +65.894 | 8 | 6 | 34.7 | 0.2 | 1.5 | 1509.5 | mf-152 | 1509.54 | 1.34221 | 0.00440684 | 34.5937
LIGHT SUPPORT | +62.942 | +63.094 | 8 | 6 | 35.2 | 0.2 | 1.5 | 1529.5 | mf-158 | 1529.54 | 1.35999 | 0.00446522 | 35.052
LIGHT SUPPORT | +68.098 | +68.250 | 8 | 6 | 28.7 | 0.2 | 1.1 | 1250 | mf-151 | 1250 | 1.11144 | 0.00364915 | 28.6458
LIGHT SUPPORT | +57.668 | +57.820 | 8 | 6 | 28.7 | 0.2 | 1.1 | 1250 | mf-151 | 1250 | 1.11144 | 0.00364915 | 28.6458
LIGHT SUPPORT | +60.331 | +60.484 | 8 | 6 | 15.6 | 0.1 | 0.6 | 679.5 | mf-157 | 679.54 | 0.604214 | 0.00198379 | 15.5728
3 x LIGHT SUPPORT | +54.797 | +54.949 | 8 | 6 | 24.2 | 0.2 | 1 | 1056 | mf-156 | 1056 | 0.938945 | 0.0030828 | 24.2
LIGHT SUPPORT | +54.953 | +55.105 | 8 | 6 | 23 | 0.2 | 0.8 | 1000 | mf-153 | 1000 | 0.889152 | 0.00291932 | 22.9167
2 x LIGHT SUPPORT | +54.953 | +55.105 | 8 | 6 | 24.2 | 0.2 | 1 | 1050.3 | mf-155 | 1050.29 | 0.933868 | 0.00306613 | 24.0691
LIGHT SUPPORT | +54.797 | +54.949 | 8 | 6 | 34.7 | 0.2 | 1.5 | 1509.5 | mf-152 | 1509.54 | 1.34221 | 0.00440684 | 34.5937
LIGHT SUPPORT | +52.688 | +52.840 | 8 | 6 | 28.7 | 0.2 | 1.1 | 1250 | mf-151 | 1250 | 1.11144 | 0.00364915 | 28.6458
8 x LIGHT SUPPORT | +48.192 | +48.344 | 7 | 6 | 24.2 | 0.2 | 1 | 1056 | me-99 | 1056 | 0.938945 | 0.0030828 | 24.2
2 x LIGHT SUPPORT | +48.192 | +48.344 | 7 | 6 | 24.2 | 0.2 | 1 | 1056 | me-99 | 1056 | 0.938944 | 0.0030828 | 24.2
LIGHT SUPPORT | +48.348 | +48.500 | 7 | 6 | 30.6 | 0.2 | 1.3 | 1330 | me-98 | 1330 | 1.18257 | 0.0038827 | 30.4792
LIGHT SUPPORT | +44.067 | +44.219 | 7 | 6 | 30.1 | 0.2 | 1.3 | 1310 | me-96 | 1310 | 1.16479 | 0.00382431 | 30.0208
4 x LIGHT SUPPORT | +44.067 | +44.219 | 7 | 6 | 24.2 | 0.2 | 1 | 1056 | me-99 | 1056 | 0.938945 | 0.0030828 | 24.2
LIGHT SUPPORT | +44.223 | +44.375 | 7 | 6 | 24.2 | 0.2 | 1 | 1050.3 | me-95 | 1050.29 | 0.933868 | 0.00306613 | 24.0691
LIGHT SUPPORT | +44.067 | +44.219 | 7 | 6 | 27.6 | 0.2 | 1.1 | 1200 | me-100 | 1200 | 1.06698 | 0.00350318 | 27.5
2 x LIGHT SUPPORT | +44.223 | +44.375 | 7 | 6 | 24.2 | 0.2 | 1 | 1050.3 | me-94 | 1050.29 | 0.933868 | 0.00306613 | 24.0691
LIGHT SUPPORT | +38.530 | +38.682 | 7 | 6 | 30.1 | 0.2 | 1.3 | 1310 | me-96 | 1310 | 1.16479 | 0.00382431 | 30.0208
LIGHT SUPPORT | +35.762 | +35.914 | 6 | 6 | 37.5 | 0.2 | 1.5 | 1629.5 | md-78 | 1629.54 | 1.44891 | 0.00475715 | 37.3436
LIGHT SUPPORT | +35.762 | +35.914 | 6 | 6 | 27.9 | 0.2 | 1.1 | 1215 | md-77 | 1215 | 1.08032 | 0.00354697 | 27.8437
LIGHT SUPPORT | +36.088 | +36.240 | 6 | 6 | 9.3 | 0.1 | 0.3 | 405.5 | md-74 | 405.5 | 0.360551 | 0.00118378 | 9.29271
2 x LIGHT SUPPORT | +35.918 | +36.070 | 6 | 6 | 24.2 | 0.2 | 1 | 1050.3 | md-72 | 1050.29 | 0.933868 | 0.00306613 | 24.0691
2 x LIGHT SUPPORT | +35.762 | +35.914 | 6 | 6 | 24.2 | 0.2 | 1 | 1056 | md-75 | 1056 | 0.938945 | 0.0030828 | 24.2
LIGHT SUPPORT | +33.647 | +33.799 | 6 | 6 | 27.5 | 0.2 | 1.1 | 1195 | md-71 | 1195 | 1.06254 | 0.00348859 | 27.3854
LIGHT SUPPORT | +31.376 | +31.528 | 6 | 6 | 28.7 | 0.2 | 1.1 | 1250 | md-70 | 1250 | 1.11144 | 0.00364915 | 28.6458
LIGHT SUPPORT | +28.728 | +28.880 | 6 | 6 | 24.2 | 0.2 | 1 | 1050.3 | md-73 | 1050.29 | 0.933868 | 0.00306613 | 24.0691
2 x LIGHT SUPPORT | +28.728 | +28.880 | 6 | 6 | 24.2 | 0.2 | 1 | 1050.3 | md-72 | 1050.29 | 0.933868 | 0.00306613 | 24.0691
5 x LIGHT SUPPORT | +28.572 | +28.724 | 6 | 6 | 24.2 | 0.2 | 1 | 1056 | md-75 | 1056 | 0.938945 | 0.0030828 | 24.2
2 x LIGHT SUPPORT | +28.572 | +28.724 | 6 | 6 | 30.6 | 0.2 | 1.3 | 1330 | md-76 | 1330 | 1.18257 | 0.0038827 | 30.4792
6 x LIGHT SUPPORT | +17.868 | +18.020 | 4 | 6 | 7.7 | 0.1 | 0.3 | 334.4 | mb-103 | 334.35 | 0.297288 | 0.000976075 | 7.66219
BEAM | +17.868 | +18.020 | 4 | 6 | 12.1 | 0.1 | 0.5 | 524.7 | mb-102 | 524.7 | 0.466538 | 0.00153177 | 12.0244
LIGHT SUPPORT | +15.192 | +15.344 | 5 | 6 | 23.8 | 0.2 | 0.8 | 1029 | mc-271 | 1029 | 0.914938 | 0.00300398 | 23.5812
LIGHT SUPPORT | +50.801 | +50.953 | 8 | 6 | 28.7 | 0.2 | 1.1 | 1250 | mf-151 | 1250 | 1.11144 | 0.00364915 | 28.6458
LIGHT SUPPORT | +46.661 | +46.813 | 7 | 6 | 28.7 | 0.2 | 1.1 | 1250 | me-97 | 1250 | 1.11144 | 0.00364915 | 28.6458
LIGHT SUPPORT | +41.454 | +41.606 | 7 | 6 | 28.7 | 0.2 | 1.1 | 1250 | me-97 | 1250 | 1.11144 | 0.00364915 | 28.6458
LIGHT SUPPORT | +15.192 | +15.344 | 5 | 6 | 39.8 | 0.3 | 1.6 | 1730 | mc-270 | 1730 | 1.53823 | 0.00505042 | 39.6458
LIGHT SUPPORT | +15.192 | +15.344 | 5 | 6 | 26.4 | 0.2 | 1 | 1154 | mc-269 | 1154 | 1.02608 | 0.0033689 | 26.4458
4 x LIGHT SUPPORT | +5.192 | +5.344 | 5 | 6 | 24.2 | 0.2 | 1 | 1056 | mc-264 | 1056 | 0.938945 | 0.0030828 | 24.2
2 x LIGHT SUPPORT | +5.192 | +5.344 | 5 | 6 | 30.2 | 0.2 | 1.3 | 1316 | mc-266 | 1316 | 1.17012 | 0.00384183 | 30.1583
LIGHT SUPPORT | +15.192 | +15.344 | 5 | 6 | 19.7 | 0.1 | 0.8 | 856 | mc-268 | 856 | 0.761114 | 0.00249894 | 19.6167
3 x LIGHT SUPPORT | +15.192 | +15.344 | 5 | 6 | 24.2 | 0.2 | 1 | 1056 | mc-264 | 1056 | 0.938945 | 0.0030828 | 24.2
LIGHT SUPPORT | +15.192 | +15.344 | 5 | 6 | 21.2 | 0.1 | 0.8 | 921 | mc-267 | 921 | 0.818909 | 0.00268869 | 21.1062
LIGHT SUPPORT | +5.192 | +5.344 | 5 | 6 | 23.1 | 0.2 | 0.8 | 1006 | mc-265 | 1006 | 0.894487 | 0.00293684 | 23.0542
LIGHT SUPPORT | +26.063 | +26.215 | 6 | 6 | 28.7 | 0.2 | 1.1 | 1250 | md-70 | 1250 | 1.11144 | 0.00364915 | 28.6458
LIGHT SUPPORT | +19.403 | +19.555 | 4 | 6 | 28.7 | 0.2 | 1.1 | 1250 | mb-101 | 1250 | 1.11144 | 0.00364915 | 28.6458
LIGHT SUPPORT | +23.966 | +24.118 | 4 | 6 | 28.7 | 0.2 | 1.1 | 1250 | mb-101 | 1250 | 1.11144 | 0.00364915 | 28.6458
LIGHT SUPPORT | +21.108 | +21.260 | 4 | 6 | 24.8 | 0.2 | 1 | 1080 | mb-100 | 1080 | 0.960281 | 0.00315286 | 24.7499
LIGHT SUPPORT | +20.952 | +21.104 | 4 | 6 | 36.5 | 0.2 | 1.5 | 1585.8 | mb-99 | 1585.75 | 1.40997 | 0.00462931 | 36.3401
LIGHT SUPPORT | +20.952 | +21.104 | 4 | 6 | 30.6 | 0.2 | 1.3 | 1330 | mb-98 | 1330 | 1.18257 | 0.0038827 | 30.4792
5 x LIGHT SUPPORT | +20.952 | +21.104 | 4 | 6 | 24.2 | 0.2 | 1 | 1056 | mb-97 | 1056 | 0.938945 | 0.0030828 | 24.2
LIGHT SUPPORT | +21.108 | +21.260 | 4 | 6 | 28.7 | 0.2 | 1.1 | 1250 | mb-101 | 1250 | 1.11144 | 0.00364915 | 28.6458
LIGHT SUPPORT | +17.542 | +17.694 | 4 | 6 | 30.6 | 0.2 | 1.3 | 1330 | mb-98 | 1330 | 1.18257 | 0.00388269 | 30.4791
2 x LIGHT SUPPORT | +17.542 | +17.694 | 4 | 6 | 24.2 | 0.2 | 1 | 1056 | mb-97 | 1056 | 0.938945 | 0.0030828 | 24.2
2 x LIGHT SUPPORT | +17.698 | +17.850 | 4 | 6 | 24.1 | 0.2 | 1 | 1050 | mb-95 | 1050 | 0.93361 | 0.00306529 | 24.0625
LIGHT SUPPORT | +17.698 | +17.850 | 4 | 6 | 28.7 | 0.2 | 1.1 | 1250 | mb-101 | 1250 | 1.11144 | 0.00364915 | 28.6458
LIGHT SUPPORT | +15.192 | +15.344 | 4 | 6 | 34 | 0.2 | 1.3 | 1480 | mb-96 | 1480 | 1.31595 | 0.00432059 | 33.9167
2 x LIGHT SUPPORT | +10.082 | +10.234 | 3 | 6 | 24.2 | 0.2 | 1 | 1056 | ma-102 | 1056 | 0.938945 | 0.0030828 | 24.2
2 x LIGHT SUPPORT | +10.082 | +10.234 | 3 | 6 | 21.4 | 0.1 | 0.8 | 936 | ma-109 | 936 | 0.832246 | 0.00273248 | 21.45
2 x LIGHT SUPPORT | +10.082 | +10.234 | 3 | 6 | 32.9 | 0.2 | 1.3 | 1430 | ma-107 | 1430 | 1.27149 | 0.00417463 | 32.7708
6 x LIGHT SUPPORT | +10.082 | +10.234 | 3 | 6 | 30.6 | 0.2 | 1.3 | 1330 | ma-108 | 1330 | 1.18258 | 0.00388271 | 30.4792
LIGHT SUPPORT | +10.082 | +10.234 | 3 | 6 | 14.7 | 0.1 | 0.6 | 636 | ma-106 | 636 | 0.565501 | 0.00185669 | 14.575
LIGHT SUPPORT | +5.344 | +5.497 | 3 | 6 | 24.2 | 0.2 | 1 | 1056 | ma-101 | 1056 | 0.938945 | 0.0030828 | 24.2
LIGHT SUPPORT | +5.348 | +5.500 | 3 | 6 | 24.2 | 0.2 | 1 | 1056 | ma-101 | 1056 | 0.938945 | 0.0030828 | 24.2
2 x LIGHT SUPPORT | +5.192 | +5.344 | 3 | 6 | 72.1 | 0.5 | 2.8 | 3135.8 | ma-105 | 3135.75 | 2.78816 | 0.00915426 | 71.8609
LIGHT SUPPORT | +5.192 | +5.344 | 3 | 6 | 24.2 | 0.2 | 1 | 1056 | ma-104 | 1056 | 0.938944 | 0.0030828 | 24.2
LIGHT SUPPORT | +5.192 | +5.344 | 3 | 6 | 35.2 | 0.2 | 1.5 | 1530 | ma-103 | 1530 | 1.3604 | 0.00446656 | 35.0625
LIGHT SUPPORT | +5.192 | +5.344 | 3 | 6 | 24.2 | 0.2 | 1 | 1056 | ma-102 | 1056 | 0.938945 | 0.0030828 | 24.2
POST | +8.217 | +8.827 | 5 | 3 | 14 | 0 | 0.6 | 610.4 | mc-263 | 610.4 | 0.542739 | 0.00178195 | 13.9883
2 x POST | +11.217 | +12.200 | 5 | 12 | 22.6 | 0 | 0.8 | 983 | mc-260 | 983 | 0.874037 | 0.00286969 | 22.5271
3 x POST | +10.607 | +10.827 | 5 | 3 | 5.1 | 0 | 0.2 | 220.4 | mc-262 | 220.4 | 0.195969 | 0.000643418 | 5.05083
STUB COLUMN | +10.607 | +10.827 | 3 | 3 | 5.1 | 0 | 0.2 | 220.4 | ma-100 | 220.4 | 0.195969 | 0.000643418 | 5.05083
HANGER | +9.217 | +10.217 | 3 | 3 | 23 | 0 | 0.8 | 1000.4 | ma-99 | 1000.4 | 0.889508 | 0.00292049 | 22.9258
3 x POST | +9.217 | +10.217 | 5 | 3 | 23 | 0 | 0.8 | 1000.4 | mc-261 | 1000.4 | 0.889508 | 0.00292049 | 22.9258
2 x POST | +9.217 | +10.827 | 5 | 12 | 37 | 0 | 1.5 | 1610.4 | mc-259 | 1610.4 | 1.43189 | 0.00470127 | 36.905
POST | +18.062 | +19.490 | 4 | 3 | 32.9 | 0 | 1.3 | 1427.4 | mb-93 | 1427.5 | 1.26926 | 0.00416733 | 32.7135

# IfcBeam: UC203*203*46 (69)
In: Undefined
Description: UC203*203*46; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 25.8 m2; Height: 203.2 mm; Width: 203.2 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BEAM | +63.247 | +63.450 | 8 | 14 | 65.1 | 0.3 | 1.7 | 1413 | mf-256 | 1413 | 1.67735 | 0.00797229 | 62.5825
BEAM | +70.447 | +70.650 | 8 | 7 | 50.7 | 0.2 | 1.3 | 1099.4 | mf-255 | 1099.4 | 1.30508 | 0.00594699 | 46.6839
BEAM | +44.372 | +44.575 | 7 | 14 | 50.7 | 0.2 | 1.3 | 1099.4 | me-165 | 1099.4 | 1.30508 | 0.00594699 | 46.6839
BEAM | +36.067 | +36.270 | 6 | 14 | 50.7 | 0.2 | 1.3 | 1099.4 | md-133 | 1099.4 | 1.30508 | 0.00594699 | 46.6839
PIPE SUPPORT | +28.877 | +29.080 | 6 | 14 | 39.9 | 0.2 | 1 | 865.6 | md-132 | 865.56 | 1.0275 | 0.0045262 | 35.5306
3 x PIPE SUPPORT | +28.877 | +29.080 | 6 | 14 | 39.9 | 0.2 | 1 | 865.5 | md-131 | 865.55 | 1.02748 | 0.00461356 | 36.2165
BEAM | +15.497 | +15.700 | 5 | 6 | 42.2 | 0.2 | 1 | 914.4 | mc-344 | 914.4 | 1.08547 | 0.00487526 | 38.2708
PIPE SUPPORT | +5.497 | +5.700 | 5 | 6 | 35.4 | 0.1 | 0.8 | 764.7 | mc-343 | 764.7 | 0.907766 | 0.0040331 | 31.6598
BEAM | +15.497 | +15.700 | 5 | 23 | 58.3 | 0.2 | 1.5 | 1265.6 | mc-342 | 1265.55 | 1.50232 | 0.00693083 | 54.407
PIPE SUPPORT | +5.497 | +5.700 | 5 | 6 | 51.1 | 0.2 | 1.3 | 1109.4 | mc-341 | 1109.4 | 1.31696 | 0.00600493 | 47.1387
PIPE SUPPORT | +5.497 | +5.700 | 5 | 6 | 51.1 | 0.2 | 1.3 | 1108.6 | mc-337 | 1108.55 | 1.31595 | 0.00602131 | 47.2673
PIPE SUPPORT | +5.497 | +5.700 | 5 | 6 | 35.4 | 0.1 | 0.8 | 765.6 | mc-338 | 765.55 | 0.908775 | 0.00403425 | 31.6688
PIPE SUPPORT | +5.497 | +5.700 | 5 | 6 | 51.1 | 0.2 | 1.3 | 1108.6 | mc-337 | 1108.55 | 1.31595 | 0.0060213 | 47.2672
3 x PIPE SUPPORT | +5.497 | +5.700 | 5 | 6 | 53.7 | 0.2 | 1.3 | 1165.6 | mc-336 | 1165.55 | 1.38361 | 0.00635151 | 49.8594
PIPE SUPPORT | +5.497 | +5.700 | 5 | 6 | 39.9 | 0.2 | 1 | 865.6 | mc-335 | 865.55 | 1.02748 | 0.00461356 | 36.2165
2 x PIPE SUPPORT | +5.497 | +5.700 | 5 | 6 | 58.3 | 0.2 | 1.5 | 1265.6 | mc-334 | 1265.55 | 1.50232 | 0.00693083 | 54.407
PIPE SUPPORT | +5.497 | +5.700 | 5 | 6 | 35.4 | 0.1 | 0.8 | 765.6 | mc-340 | 765.55 | 0.908775 | 0.0039496 | 31.0044
PIPE SUPPORT | +5.497 | +5.700 | 5 | 6 | 23.3 | 0.1 | 0.5 | 504.7 | mc-333 | 504.7 | 0.599123 | 0.00228819 | 17.9623
PIPE SUPPORT | +5.497 | +5.700 | 5 | 6 | 49.1 | 0.2 | 1.3 | 1065.6 | mc-331 | 1065.55 | 1.2649 | 0.00577219 | 45.3117
PIPE SUPPORT | +21.257 | +21.460 | 4 | 6 | 31.3 | 0.1 | 0.6 | 679.7 | mb-183 | 679.724 | 0.806892 | 0.00330213 | 25.9217
PIPE SUPPORT | +21.257 | +21.460 | 4 | 6 | 39.9 | 0.2 | 1 | 866.4 | mb-182 | 866.4 | 1.02849 | 0.00459719 | 36.0879
PIPE SUPPORT | +21.257 | +21.460 | 4 | 6 | 50.7 | 0.2 | 1.3 | 1099.4 | mb-180 | 1099.4 | 1.30508 | 0.00594699 | 46.6839
PIPE SUPPORT | +17.847 | +18.050 | 4 | 6 | 39.9 | 0.2 | 1 | 866.4 | mb-181 | 866.4 | 1.02849 | 0.00459719 | 36.0879
PIPE SUPPORT | +21.257 | +21.460 | 4 | 6 | 44.5 | 0.2 | 1 | 964.7 | mb-179 | 964.7 | 1.14518 | 0.00469684 | 36.8702
2 x PIPE SUPPORT | +21.257 | +21.460 | 4 | 6 | 39.9 | 0.2 | 1 | 865.5 | mb-172 | 865.549 | 1.02748 | 0.00461356 | 36.2164
PIPE SUPPORT | +21.257 | +21.460 | 4 | 6 | 39.9 | 0.2 | 0.8 | 865.5 | mb-171 | 865.549 | 1.02748 | 0.00442713 | 34.753
PIPE SUPPORT | +21.257 | +21.460 | 4 | 6 | 27.5 | 0.1 | 0.6 | 595.6 | mb-178 | 595.55 | 0.70697 | 0.0027932 | 21.9266
PIPE SUPPORT | +21.257 | +21.460 | 4 | 6 | 38.5 | 0.1 | 0.8 | 835.6 | mb-177 | 835.55 | 0.991871 | 0.00418356 | 32.841
PIPE SUPPORT | +21.257 | +21.460 | 4 | 6 | 39.9 | 0.2 | 1 | 866.4 | mb-173 | 866.4 | 1.02849 | 0.00459719 | 36.0879
PIPE SUPPORT | +17.847 | +18.050 | 4 | 6 | 58.3 | 0.2 | 1.5 | 1265.5 | mb-176 | 1265.55 | 1.50232 | 0.00667462 | 52.3958
PIPE SUPPORT | +17.847 | +18.050 | 4 | 6 | 21.4 | 0.1 | 0.3 | 465.6 | mb-175 | 465.55 | 0.552649 | 0.00204009 | 16.0147
PIPE SUPPORT | +17.847 | +18.050 | 4 | 6 | 81.5 | 0.3 | 2.1 | 1766.4 | mb-174 | 1766.4 | 2.09687 | 0.00981103 | 77.0166
PIPE SUPPORT | +17.847 | +18.050 | 4 | 6 | 39.9 | 0.2 | 1 | 866.4 | mb-173 | 866.4 | 1.02849 | 0.00459719 | 36.0879
2 x PIPE SUPPORT | +10.387 | +10.590 | 3 | 6 | 44.5 | 0.2 | 1.1 | 965.6 | ma-169 | 965.55 | 1.14619 | 0.00519288 | 40.7641
4 x PIPE SUPPORT | +10.387 | +10.590 | 3 | 6 | 39.9 | 0.2 | 1 | 866.4 | ma-162 | 866.4 | 1.02849 | 0.00459719 | 36.0879
2 x PIPE SUPPORT | +10.387 | +10.590 | 3 | 6 | 39.9 | 0.2 | 1 | 865.5 | ma-167 | 865.55 | 1.02748 | 0.00461356 | 36.2165
PIPE SUPPORT | +10.387 | +10.590 | 3 | 6 | 39.9 | 0.2 | 1 | 865.5 | ma-167 | 865.549 | 1.02748 | 0.00461356 | 36.2164
2 x PIPE SUPPORT | +10.387 | +10.590 | 3 | 6 | 50.7 | 0.2 | 1.3 | 1099.4 | ma-165 | 1099.4 | 1.30508 | 0.00594699 | 46.6839
PIPE SUPPORT | +10.387 | +10.590 | 3 | 6 | 39.9 | 0.2 | 1 | 865.6 | ma-167 | 865.55 | 1.02748 | 0.00461356 | 36.2165
PIPE SUPPORT | +10.387 | +10.590 | 3 | 6 | 22.2 | 0.1 | 0.5 | 484.7 | ma-168 | 484.7 | 0.575382 | 0.00217233 | 17.0528
PIPE SUPPORT | +10.387 | +10.590 | 3 | 6 | 54.2 | 0.2 | 1.3 | 1176.4 | ma-160 | 1176.4 | 1.39649 | 0.00639307 | 50.1856
2 x PIPE SUPPORT | +10.387 | +10.590 | 3 | 6 | 44.1 | 0.2 | 1.1 | 956.4 | ma-163 | 956.4 | 1.13533 | 0.00511857 | 40.1808
PIPE SUPPORT | +5.497 | +5.700 | 5 | 6 | 42.2 | 0.2 | 1 | 915.6 | mc-332 | 915.551 | 1.08684 | 0.00490323 | 38.4903
PIPE SUPPORT | +5.497 | +5.700 | 5 | 6 | 42.2 | 0.2 | 1 | 915.6 | mc-339 | 915.551 | 1.08684 | 0.00482504 | 37.8766
PIPE SUPPORT | +5.497 | +5.700 | 3 | 6 | 39.9 | 0.1 | 1 | 865.5 | ma-164 | 865.549 | 1.02748 | 0.00453538 | 35.6027
PIPE SUPPORT | +10.387 | +10.590 | 3 | 6 | 49.1 | 0.2 | 1.3 | 1065.6 | ma-166 | 1065.55 | 1.2649 | 0.00577219 | 45.3117
2 x PIPE SUPPORT | +5.497 | +5.700 | 3 | 6 | 39.9 | 0.2 | 1 | 865.5 | ma-167 | 865.549 | 1.02748 | 0.00461356 | 36.2164
PIPE SUPPORT | +5.497 | +5.700 | 3 | 6 | 39.9 | 0.2 | 1 | 866.4 | ma-162 | 866.4 | 1.02849 | 0.00459719 | 36.0879
PIPE SUPPORT | +5.497 | +5.700 | 3 | 6 | 49.2 | 0.2 | 1.3 | 1066.4 | ma-161 | 1066.4 | 1.26591 | 0.00575582 | 45.1832
PIPE SUPPORT | +5.497 | +5.700 | 3 | 6 | 49.1 | 0.2 | 1.3 | 1065.6 | ma-166 | 1065.55 | 1.2649 | 0.00577219 | 45.3117
BEAM | +17.847 | +18.050 | 4 | 14 | 39.9 | 0.2 | 1 | 865.5 | mb-170 | 865.55 | 1.02748 | 0.00461356 | 36.2165
BEAM | +0.012 | +3.250 | 5 | 3 | 149.3 | 0 | 4 | 3238 | mc-330 | 3238 | 3.84379 | 0.0187583 | 147.252
BEAM | +0.012 | +2.750 | 5 | 3 | 126.2 | 0 | 3.3 | 2738 | mc-329 | 2738 | 3.25025 | 0.0158617 | 124.514
BEAM | +0.012 | +3.250 | 5 | 3 | 149.3 | 0 | 4 | 3238 | mc-328 | 3238 | 3.84379 | 0.0187583 | 147.252
STUB COLUMN | +2.766 | +3.250 | 5 | 3 | 22.2 | 0 | 0.6 | 484 | mc-327 | 484 | 0.57455 | 0.00280389 | 22.0105

# IfcBeam: UC254*254*73 (12)
In: Undefined
Description: UC254*254*73; Material: STEEL/S355JR
Tekla Common - Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 20.3 m2; Height: 254.2 mm; Width: 254 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x POST | +36.287 | +38.665 | 7 | 173.9 | 3.6 | 2378.4 | me-206 | 3.53287 | 0.0217754 | 170.937
POST | +55.322 | +57.647 | 8 | 170 | 3.5 | 2325.4 | mf-329 | 3.45415 | 0.0212902 | 167.128
POST | +29.097 | +31.355 | 6 | 165.1 | 3.5 | 2258.4 | md-168 | 3.35462 | 0.0206768 | 162.313
2 x POST | +63.467 | +65.877 | 8 | 176.3 | 3.7 | 2410.4 | mf-330 | 3.5804 | 0.0220684 | 173.237
2 x POST | +15.718 | +17.676 | 4 | 143.2 | 3 | 1958.4 | mb-234 | 2.909 | 0.0179301 | 140.751
POST | +18.068 | +21.086 | 4 | 220.6 | 4.7 | 3018.4 | mb-235 | 4.48352 | 0.0276349 | 216.934
POST | +55.322 | +57.648 | 8 | 170 | 3.5 | 2325.9 | mf-329 | 3.45488 | 0.0212947 | 167.163
POST | +29.097 | +31.355 | 6 | 165.1 | 3.5 | 2258.4 | md-168 | 3.35462 | 0.0206767 | 162.312
POST | +21.478 | +23.944 | 4 | 180.3 | 3.7 | 2466.4 | mb-233 | 3.66358 | 0.0225811 | 177.261

# IfcBeam: UC305*305*158 (28)
In: Undefined
Description: UC305*305*158; Material: STEEL/S355JR
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 11.6 m2; Height: 327.2 mm; Width: 310.6 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Volume (m3) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
COLUMN | +0.040 | +10.590 | 3 | 3 | 1666.9 | 0.2 | 19.7 | 10550 | ma-189 | 19.4047 | 0.209756 | 1646.58
COLUMN | +0.040 | +10.590 | 3 | 3 | 1666.9 | 0.2 | 19.7 | 10550 | ma-188 | 19.4047 | 0.209756 | 1646.58
COLUMN | +0.040 | +12.000 | 3 | 3 | 1889.7 | 0.2 | 22.3 | 11960 | ma-187 | 21.9981 | 0.237789 | 1866.65
COLUMN | +0.040 | +12.000 | 3 | 3 | 1889.7 | 0.2 | 22.3 | 11960 | ma-186 | 21.9981 | 0.237789 | 1866.65
