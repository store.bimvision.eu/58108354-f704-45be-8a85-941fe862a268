Properties of the parts of a building model (IFC2X3), part 3 of 22

# IfcBeam: L80*80*8 (469)
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 14.4 | 0.1 | 0.5 | 1483.8 | 471-G-F258 | 1483.84 | 0.462092 | 0.00180435 | 14.1642
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 19.4 | 0.2 | 0.6 | 2029.3 | 471-G-F257 | 2029.28 | 0.63195 | 0.00246761 | 19.3707
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1693.7 | 471-G-F248 | 1693.74 | 0.527457 | 0.00205959 | 16.1678
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 14.7 | 0.1 | 0.5 | 1541 | 471-G-F253 | 1541.04 | 0.479906 | 0.00187391 | 14.7102
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 17.5 | 0.1 | 0.6 | 1816.4 | 471-G-F256 | 1816.42 | 0.565663 | 0.00220877 | 17.3389
2 x FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 17.6 | 0.1 | 0.6 | 1830.6 | 471-G-F255 | 1830.55 | 0.570063 | 0.00222595 | 17.4737
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 15.8 | 0.1 | 0.5 | 1649.2 | 471-G-F254 | 1649.19 | 0.513585 | 0.00200542 | 15.7425
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 14.7 | 0.1 | 0.5 | 1541.5 | 471-G-F253 | 1541.54 | 0.480059 | 0.00187451 | 14.7149
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 17.5 | 0.1 | 0.6 | 1820.9 | 471-G-F252 | 1820.92 | 0.567064 | 0.00221424 | 17.3818
2 x FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 18.3 | 0.2 | 0.6 | 1904.3 | 471-G-F250 | 1904.27 | 0.593021 | 0.0023156 | 18.1774
2 x FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 20 | 0.2 | 0.6 | 2064.9 | 471-G-F251 | 2064.9 | 0.643042 | 0.00251091 | 19.7107
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 20 | 0.2 | 0.6 | 2065.6 | 471-G-F251 | 2065.58 | 0.643253 | 0.00251174 | 19.7172
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 18.5 | 0.2 | 0.6 | 1916.8 | 471-G-F249 | 1916.82 | 0.596928 | 0.00233085 | 18.2972
3 x FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 17.5 | 0.1 | 0.6 | 1812.8 | 471-G-F240 | 1812.82 | 0.56454 | 0.00220439 | 17.3044
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1693.7 | 471-G-F248 | 1693.74 | 0.527458 | 0.00205959 | 16.1678
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-G-F245 | 1695.8 | 0.5281 | 0.0020621 | 16.1875
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1696.9 | 471-G-F245 | 1696.92 | 0.528449 | 0.00206346 | 16.1982
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 17.2 | 0.1 | 0.6 | 1773.5 | 471-G-F247 | 1773.52 | 0.552302 | 0.0021566 | 16.9293
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 17.5 | 0.1 | 0.6 | 1809.6 | 471-G-F246 | 1809.63 | 0.563549 | 0.00220052 | 17.274
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-G-F245 | 1695.93 | 0.528138 | 0.00206225 | 16.1886
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 14.7 | 0.1 | 0.5 | 1518.1 | 471-G-F242 | 1518.08 | 0.472753 | 0.00184598 | 14.491
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 17 | 0.1 | 0.6 | 1767.8 | 471-G-F244 | 1767.82 | 0.550526 | 0.00214966 | 16.8749
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 17.6 | 0.1 | 0.6 | 1828.7 | 471-G-F243 | 1828.66 | 0.569473 | 0.00222365 | 17.4556
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 14.7 | 0.1 | 0.5 | 1517.7 | 471-G-F242 | 1517.72 | 0.472642 | 0.00184555 | 14.4875
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 17.6 | 0.1 | 0.6 | 1837.2 | 471-G-F241 | 1837.15 | 0.572118 | 0.00223398 | 17.5367
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 17.5 | 0.1 | 0.6 | 1813.5 | 471-G-F240 | 1813.53 | 0.564763 | 0.00220526 | 17.3113
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 11.1 | 0.1 | 0.3 | 1154.2 | 471-F-E175 | 1154.23 | 0.359447 | 0.00140355 | 11.0179
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 11.5 | 0.1 | 0.3 | 1190.4 | 471-F-E174 | 1190.36 | 0.370696 | 0.00144747 | 11.3627
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 10.9 | 0.1 | 0.3 | 1119.6 | 471-F-E173 | 1119.59 | 0.348659 | 0.00136143 | 10.6872
SUPPORT | +44.495 | +44.575 | 7 | 3 | 9.9 | 0.1 | 0.3 | 1032.3 | me-103 | 1032.25 | 0.321459 | 0.00125522 | 9.85345
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 11.9 | 0.1 | 0.3 | 1225.4 | 471-G-F239 | 1225.41 | 0.381613 | 0.0014901 | 11.6973
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 10.9 | 0.1 | 0.3 | 1128.1 | 471-G-F238 | 1128.07 | 0.351299 | 0.00137174 | 10.7681
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 10.9 | 0.1 | 0.3 | 1119.6 | 471-G-F235 | 1119.59 | 0.348659 | 0.00136143 | 10.6872
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 11.1 | 0.1 | 0.3 | 1154.2 | 471-G-F237 | 1154.23 | 0.359447 | 0.00140355 | 11.0179
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 11.5 | 0.1 | 0.3 | 1190.4 | 471-G-F236 | 1190.36 | 0.370696 | 0.00144747 | 11.3627
FLOOR BRACE | +55.118 | +55.198 | 8 | 6 | 10.9 | 0.1 | 0.3 | 1119.6 | 471-G-F235 | 1119.59 | 0.348659 | 0.00136143 | 10.6872
SUPPORT | +55.225 | +55.305 | 8 | 3 | 9.9 | 0.1 | 0.3 | 1032.3 | mf-161 | 1032.25 | 0.321459 | 0.00125522 | 9.85345
SUPPORT | +63.370 | +63.450 | 8 | 3 | 9.9 | 0.1 | 0.3 | 1032.3 | mf-161 | 1032.25 | 0.321459 | 0.00125522 | 9.85345
FLOOR BRACE | +63.263 | +63.343 | 8 | 6 | 12.1 | 0.1 | 0.3 | 1261.3 | 471-G-F234 | 1261.32 | 0.392795 | 0.00153376 | 12.04
FLOOR BRACE | +63.263 | +63.343 | 8 | 6 | 9.3 | 0.1 | 0.3 | 977.3 | 471-G-F233 | 977.275 | 0.304339 | 0.00118837 | 9.32867
FLOOR BRACE | +38.851 | +38.931 | 7 | 6 | 9.3 | 0.1 | 0.3 | 965.7 | 471-F-E172 | 965.673 | 0.300726 | 0.00117426 | 9.21793
SUPPORT | +38.958 | +39.038 | 7 | 3 | 9.9 | 0.1 | 0.3 | 1032.3 | me-103 | 1032.25 | 0.321459 | 0.00125522 | 9.85345
FLOOR BRACE | +38.851 | +38.931 | 7 | 6 | 12.1 | 0.1 | 0.3 | 1261.3 | 471-F-E171 | 1261.32 | 0.392795 | 0.00153376 | 12.04
FLOOR BRACE | +38.851 | +38.931 | 7 | 6 | 12.1 | 0.1 | 0.3 | 1262.5 | 471-F-E170 | 1262.51 | 0.393164 | 0.00153521 | 12.0514
SUPPORT | +48.620 | +48.700 | 7 | 3 | 4.1 | 0 | 0.1 | 430.2 | me-102 | 430.246 | 0.133985 | 0.000523179 | 4.10696
SUPPORT | +48.620 | +48.700 | 7 | 3 | 4.1 | 0 | 0.1 | 430.2 | me-101 | 430.246 | 0.133985 | 0.000523179 | 4.10696
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 27.7 | 0.2 | 0.8 | 2878.7 | 471-F-E168 | 2878.69 | 0.89647 | 0.00350049 | 27.4788
2 x FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 26.9 | 0.2 | 0.8 | 2798.5 | 471-F-E169 | 2798.46 | 0.871485 | 0.00340293 | 26.713
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 27.7 | 0.2 | 0.8 | 2878.7 | 471-F-E168 | 2878.69 | 0.896471 | 0.00350049 | 27.4788
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 15.8 | 0.1 | 0.5 | 1648.3 | 471-F-E164 | 1648.28 | 0.513301 | 0.00200431 | 15.7338
2 x FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 16.3 | 0.1 | 0.5 | 1693.7 | 471-F-E158 | 1693.74 | 0.527458 | 0.00205959 | 16.1678
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 17.5 | 0.1 | 0.6 | 1816.4 | 471-F-E166 | 1816.42 | 0.565663 | 0.00220877 | 17.3389
2 x FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 17.6 | 0.1 | 0.6 | 1830.6 | 471-F-E165 | 1830.55 | 0.570063 | 0.00222595 | 17.4737
2 x FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 15.8 | 0.1 | 0.5 | 1649.2 | 471-F-E164 | 1649.19 | 0.513585 | 0.00200542 | 15.7425
3 x FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 17.5 | 0.1 | 0.6 | 1812.8 | 471-F-E150 | 1812.82 | 0.56454 | 0.00220439 | 17.3044
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-F-E155 | 1695.8 | 0.5281 | 0.0020621 | 16.1875
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 16.3 | 0.1 | 0.5 | 1696.9 | 471-F-E155 | 1696.92 | 0.528449 | 0.00206346 | 16.1982
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 17.2 | 0.1 | 0.6 | 1773.5 | 471-F-E157 | 1773.52 | 0.552302 | 0.0021566 | 16.9293
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 17.5 | 0.1 | 0.6 | 1809.6 | 471-F-E156 | 1809.63 | 0.563549 | 0.00220052 | 17.274
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 16.2 | 0.1 | 0.5 | 1682.9 | 471-F-E167 | 1682.92 | 0.524088 | 0.00204643 | 16.0645
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 17.6 | 0.1 | 0.6 | 1826.5 | 471-F-E154 | 1826.45 | 0.568786 | 0.00222097 | 17.4346
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 17.2 | 0.1 | 0.6 | 1770.7 | 471-F-E153 | 1770.72 | 0.551429 | 0.00215319 | 16.9025
2 x FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 17.6 | 0.1 | 0.6 | 1828.4 | 471-F-E152 | 1828.42 | 0.5694 | 0.00222336 | 17.4534
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 17.6 | 0.1 | 0.6 | 1837.2 | 471-F-E151 | 1837.15 | 0.572118 | 0.00223398 | 17.5367
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 17.5 | 0.1 | 0.6 | 1813.5 | 471-F-E150 | 1813.53 | 0.564763 | 0.00220526 | 17.3113
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 16.3 | 0.1 | 0.5 | 1693.7 | 471-F-E158 | 1693.74 | 0.527457 | 0.00205959 | 16.1678
2 x FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 16.3 | 0.1 | 0.5 | 1693.7 | 471-F-E158 | 1693.74 | 0.527458 | 0.00205959 | 16.1678
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 17.5 | 0.1 | 0.6 | 1816.4 | 471-F-E166 | 1816.42 | 0.565663 | 0.00220877 | 17.3389
2 x FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 17.6 | 0.1 | 0.6 | 1830.6 | 471-F-E165 | 1830.55 | 0.570063 | 0.00222595 | 17.4737
2 x FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 15.8 | 0.1 | 0.5 | 1649.2 | 471-F-E164 | 1649.19 | 0.513585 | 0.00200542 | 15.7425
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 18.6 | 0.2 | 0.6 | 1934 | 471-F-E163 | 1934.04 | 0.602292 | 0.0023518 | 18.4616
2 x FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 18.3 | 0.2 | 0.6 | 1904.3 | 471-F-E161 | 1904.27 | 0.593021 | 0.0023156 | 18.1774
2 x FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 20 | 0.2 | 0.6 | 2064.9 | 471-F-E162 | 2064.9 | 0.643042 | 0.00251091 | 19.7107
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 20 | 0.2 | 0.6 | 2065.6 | 471-F-E162 | 2065.58 | 0.643253 | 0.00251174 | 19.7172
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 18.5 | 0.2 | 0.6 | 1916.8 | 471-F-E160 | 1916.82 | 0.596928 | 0.00233085 | 18.2972
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 12.4 | 0.1 | 0.3 | 1291.1 | 471-F-E159 | 1291.09 | 0.402066 | 0.00156997 | 12.3242
2 x FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 17.5 | 0.1 | 0.6 | 1812.8 | 471-F-E150 | 1812.82 | 0.56454 | 0.00220439 | 17.3044
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-F-E155 | 1695.8 | 0.5281 | 0.0020621 | 16.1875
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 16.3 | 0.1 | 0.5 | 1696.9 | 471-F-E155 | 1696.92 | 0.528449 | 0.00206346 | 16.1982
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 17.2 | 0.1 | 0.6 | 1773.5 | 471-F-E157 | 1773.52 | 0.552302 | 0.0021566 | 16.9293
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 17.5 | 0.1 | 0.6 | 1809.6 | 471-F-E156 | 1809.63 | 0.563549 | 0.00220052 | 17.274
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-F-E155 | 1695.93 | 0.528138 | 0.00206225 | 16.1886
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 17.6 | 0.1 | 0.6 | 1826.5 | 471-F-E154 | 1826.45 | 0.568786 | 0.00222097 | 17.4346
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 17.2 | 0.1 | 0.6 | 1770.7 | 471-F-E153 | 1770.72 | 0.551429 | 0.00215319 | 16.9025
2 x FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 17.6 | 0.1 | 0.6 | 1828.4 | 471-F-E152 | 1828.42 | 0.5694 | 0.00222336 | 17.4534
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 17.6 | 0.1 | 0.6 | 1837.2 | 471-F-E151 | 1837.15 | 0.572118 | 0.00223398 | 17.5367
FLOOR BRACE | +44.388 | +44.468 | 7 | 6 | 17.5 | 0.1 | 0.6 | 1813.5 | 471-F-E150 | 1813.53 | 0.564763 | 0.00220526 | 17.3113
2 x FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 16.3 | 0.1 | 0.5 | 1693.7 | 471-E-D116 | 1693.74 | 0.527458 | 0.00205959 | 16.1678
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 11.1 | 0.1 | 0.3 | 1154.2 | 471-E-D138 | 1154.23 | 0.359447 | 0.00140355 | 11.0179
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 11.5 | 0.1 | 0.3 | 1190.4 | 471-E-D137 | 1190.36 | 0.370696 | 0.00144747 | 11.3627
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 10.9 | 0.1 | 0.3 | 1119.6 | 471-E-D136 | 1119.59 | 0.348659 | 0.00136143 | 10.6872
SUPPORT | +36.190 | +36.270 | 6 | 3 | 9.9 | 0.1 | 0.3 | 1032.3 | md-79 | 1032.25 | 0.321459 | 0.00125522 | 9.85345
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 9.7 | 0.1 | 0.3 | 1021.4 | 471-E-D135 | 1021.42 | 0.318086 | 0.00124205 | 9.75006
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 9.9 | 0.1 | 0.3 | 1032.1 | 471-E-D134 | 1032.14 | 0.321426 | 0.00125509 | 9.85244
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 11.5 | 0.1 | 0.3 | 1196.3 | 471-E-D133 | 1196.28 | 0.372542 | 0.00145468 | 11.4193
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 11.5 | 0.1 | 0.3 | 1196.7 | 471-E-D133 | 1196.75 | 0.372686 | 0.00145524 | 11.4237
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 14.7 | 0.1 | 0.5 | 1517.8 | 471-E-D132 | 1517.84 | 0.472678 | 0.00184569 | 14.4887
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 14.7 | 0.1 | 0.5 | 1518.1 | 471-E-D132 | 1518.19 | 0.47279 | 0.00184612 | 14.4921
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 16.4 | 0.1 | 0.5 | 1698.3 | 471-E-D131 | 1698.26 | 0.528864 | 0.00206508 | 16.2109
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 16.4 | 0.1 | 0.5 | 1698.7 | 471-E-D131 | 1698.73 | 0.529012 | 0.00206566 | 16.2154
2 x FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 17.6 | 0.1 | 0.6 | 1830.6 | 471-E-D130 | 1830.55 | 0.570063 | 0.00222595 | 17.4737
2 x FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 15.8 | 0.1 | 0.5 | 1649.2 | 471-E-D126 | 1649.19 | 0.513585 | 0.00200542 | 15.7425
2 x FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 14.7 | 0.1 | 0.5 | 1513.2 | 471-E-D121 | 1513.23 | 0.471245 | 0.00184009 | 14.4447
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 18.6 | 0.2 | 0.6 | 1934 | 471-E-D125 | 1934.04 | 0.602292 | 0.0023518 | 18.4616
2 x FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 18.3 | 0.2 | 0.6 | 1904.3 | 471-E-D123 | 1904.27 | 0.593021 | 0.0023156 | 18.1774
2 x FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 20 | 0.2 | 0.6 | 2064.9 | 471-E-D124 | 2064.9 | 0.643042 | 0.00251091 | 19.7107
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 20 | 0.2 | 0.6 | 2065.6 | 471-E-D124 | 2065.58 | 0.643253 | 0.00251174 | 19.7172
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 18.5 | 0.2 | 0.6 | 1916.8 | 471-E-D122 | 1916.82 | 0.596928 | 0.00233085 | 18.2972
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 12.4 | 0.1 | 0.3 | 1281.2 | 471-E-D129 | 1281.19 | 0.398984 | 0.00155793 | 12.2298
2 x FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 17.5 | 0.1 | 0.6 | 1812.8 | 471-E-D111 | 1812.82 | 0.56454 | 0.00220439 | 17.3044
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-E-D120 | 1695.8 | 0.5281 | 0.0020621 | 16.1875
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 16.3 | 0.1 | 0.5 | 1696.9 | 471-E-D128 | 1696.92 | 0.528449 | 0.00206346 | 16.1982
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 17.2 | 0.1 | 0.6 | 1773.5 | 471-E-D118 | 1773.52 | 0.552302 | 0.0021566 | 16.9293
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 17.5 | 0.1 | 0.6 | 1809.6 | 471-E-D117 | 1809.63 | 0.563549 | 0.00220052 | 17.274
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 17.6 | 0.1 | 0.6 | 1837.2 | 471-E-D112 | 1837.15 | 0.572118 | 0.00223398 | 17.5367
FLOOR BRACE | +36.083 | +36.163 | 6 | 6 | 17.5 | 0.1 | 0.6 | 1813.5 | 471-E-D111 | 1813.53 | 0.564763 | 0.00220526 | 17.3113
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 15.6 | 0.1 | 0.5 | 1626.8 | 471-E-D127 | 1626.79 | 0.506609 | 0.00197818 | 15.5287
2 x FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 15.8 | 0.1 | 0.5 | 1649.2 | 471-E-D126 | 1649.19 | 0.513585 | 0.00200542 | 15.7425
2 x FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 14.7 | 0.1 | 0.5 | 1513.2 | 471-E-D121 | 1513.23 | 0.471245 | 0.00184009 | 14.4447
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 18.6 | 0.2 | 0.6 | 1934 | 471-E-D125 | 1934.04 | 0.602292 | 0.0023518 | 18.4616
2 x FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 18.3 | 0.2 | 0.6 | 1904.3 | 471-E-D123 | 1904.27 | 0.593021 | 0.0023156 | 18.1774
2 x FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 20 | 0.2 | 0.6 | 2064.9 | 471-E-D124 | 2064.9 | 0.643042 | 0.00251091 | 19.7107
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 20 | 0.2 | 0.6 | 2065.6 | 471-E-D124 | 2065.58 | 0.643253 | 0.00251174 | 19.7172
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 18.5 | 0.2 | 0.6 | 1916.8 | 471-E-D122 | 1916.82 | 0.596928 | 0.00233085 | 18.2972
2 x FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 16.3 | 0.1 | 0.5 | 1693.7 | 471-E-D116 | 1693.74 | 0.527458 | 0.00205959 | 16.1678
3 x FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 17.5 | 0.1 | 0.6 | 1812.8 | 471-E-D111 | 1812.82 | 0.56454 | 0.00220439 | 17.3044
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 16.3 | 0.1 | 0.5 | 1693.7 | 471-E-D116 | 1693.74 | 0.527457 | 0.00205959 | 16.1678
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-E-D120 | 1695.8 | 0.5281 | 0.0020621 | 16.1875
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 12.6 | 0.1 | 0.3 | 1313.3 | 471-E-D119 | 1313.27 | 0.408973 | 0.00159694 | 12.536
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 17.2 | 0.1 | 0.6 | 1773.5 | 471-E-D118 | 1773.52 | 0.552302 | 0.0021566 | 16.9293
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 17.5 | 0.1 | 0.6 | 1809.6 | 471-E-D117 | 1809.63 | 0.563549 | 0.00220052 | 17.274
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 16.3 | 0.1 | 0.5 | 1694.2 | 471-E-D116 | 1694.21 | 0.527605 | 0.00206016 | 16.1723
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 17.6 | 0.1 | 0.6 | 1826.5 | 471-E-D115 | 1826.45 | 0.568786 | 0.00222097 | 17.4346
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 17.2 | 0.1 | 0.6 | 1770.7 | 471-E-D114 | 1770.72 | 0.551429 | 0.00215319 | 16.9025
2 x FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 17.6 | 0.1 | 0.6 | 1828.4 | 471-E-D113 | 1828.42 | 0.5694 | 0.00222336 | 17.4534
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 17.6 | 0.1 | 0.6 | 1837.2 | 471-E-D112 | 1837.15 | 0.572118 | 0.00223398 | 17.5367
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 17.5 | 0.1 | 0.6 | 1813.5 | 471-E-D111 | 1813.53 | 0.564763 | 0.00220526 | 17.3113
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 9.3 | 0.1 | 0.3 | 965.7 | 471-E-D110 | 965.673 | 0.300726 | 0.00117426 | 9.21793
SUPPORT | +29.000 | +29.080 | 6 | 3 | 9.9 | 0.1 | 0.3 | 1032.3 | md-79 | 1032.25 | 0.321459 | 0.00125522 | 9.85345
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 12.1 | 0.1 | 0.3 | 1261.3 | 471-E-D109 | 1261.32 | 0.392795 | 0.00153376 | 12.04
FLOOR BRACE | +28.893 | +28.973 | 6 | 6 | 12.1 | 0.1 | 0.3 | 1262.5 | 471-E-D108 | 1262.51 | 0.393164 | 0.00153521 | 12.0514
2 x FLOOR BRACE | +11.013 | +11.093 | 5 | 6 | 15.6 | 0.1 | 0.5 | 1623 | 471-D-C315 | 1623.04 | 0.50544 | 0.00197361 | 15.4929
SUPPORT | +5.420 | +5.500 | 5 | 3 | 8.5 | 0.1 | 0.3 | 870.3 | mc-275 | 870.25 | 0.27101 | 0.00105822 | 8.30706
SUPPORT | +5.420 | +5.500 | 5 | 3 | 8.5 | 0.1 | 0.3 | 870.3 | mc-274 | 870.25 | 0.27101 | 0.00105822 | 8.30706
FLOOR BRACE | +5.313 | +5.393 | 5 | 6 | 16.4 | 0.1 | 0.6 | 1718.2 | 471-D-C314 | 1718.18 | 0.535068 | 0.00208931 | 16.401
FLOOR BRACE | +5.313 | +5.393 | 5 | 6 | 24.8 | 0.2 | 0.8 | 2572.7 | 471-D-C313 | 2572.71 | 0.801183 | 0.00312841 | 24.5581
FLOOR BRACE | +5.313 | +5.393 | 5 | 6 | 25.1 | 0.2 | 0.8 | 2603.3 | 471-D-C312 | 2603.26 | 0.810697 | 0.00316556 | 24.8497
FLOOR BRACE | +5.313 | +5.393 | 5 | 6 | 14.4 | 0.1 | 0.5 | 1502.7 | 471-D-C311 | 1502.7 | 0.467966 | 0.00182729 | 14.3442
FLOOR BRACE | +5.313 | +5.393 | 5 | 6 | 18.1 | 0.2 | 0.6 | 1881 | 471-D-C310 | 1881.03 | 0.585783 | 0.00228734 | 17.9556
FLOOR BRACE | +10.403 | +10.483 | 5 | 6 | 15.3 | 0.1 | 0.5 | 1598.9 | 471-D-C309 | 1598.93 | 0.497932 | 0.0019443 | 15.2627
FLOOR BRACE | +10.403 | +10.483 | 5 | 6 | 14.1 | 0.1 | 0.5 | 1477.9 | 471-D-C308 | 1477.79 | 0.460206 | 0.00179699 | 14.1064
FLOOR BRACE | +10.403 | +10.483 | 5 | 6 | 13.1 | 0.1 | 0.3 | 1374.6 | 471-D-C307 | 1374.58 | 0.428067 | 0.00167149 | 13.1212
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 6.8 | 0.1 | 0.2 | 712.6 | 471-C-B189 | 712.637 | 0.221926 | 0.000866566 | 6.80255
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 8.8 | 0.1 | 0.3 | 904.3 | 471-C-B188 | 904.259 | 0.281601 | 0.00109958 | 8.6317
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 11.6 | 0.1 | 0.3 | 1213.7 | 471-C-B187 | 1213.68 | 0.377959 | 0.00147583 | 11.5853
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 11.1 | 0.1 | 0.3 | 1154.2 | 471-C-B159 | 1154.23 | 0.359447 | 0.00140355 | 11.0179
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 11.5 | 0.1 | 0.3 | 1190.4 | 471-C-B186 | 1190.36 | 0.370696 | 0.00144747 | 11.3627
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 10.9 | 0.1 | 0.3 | 1119.6 | 471-C-B150 | 1119.59 | 0.348659 | 0.00136143 | 10.6872
SUPPORT | +21.380 | +21.460 | 4 | 3 | 9.9 | 0.1 | 0.3 | 1032.3 | mb-104 | 1032.25 | 0.321459 | 0.00125522 | 9.85345
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 8.1 | 0.1 | 0.3 | 828.9 | 471-B-A164 | 828.857 | 0.258119 | 0.00100789 | 7.91193
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 8.8 | 0.1 | 0.3 | 902.8 | 471-B-A163 | 902.758 | 0.281133 | 0.00109775 | 8.61737
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 10.2 | 0.1 | 0.3 | 1065.4 | 471-B-A162 | 1065.37 | 0.331773 | 0.00129549 | 10.1696
FRAME | +6.020 | +6.100 | 3 | 6 | 9.5 | 0.1 | 0.3 | 984 | ma-115 | 984 | 0.306433 | 0.00115507 | 9.06732
SUPPORT | +15.620 | +15.700 | 5 | 3 | 5.9 | 0 | 0.2 | 620.3 | mc-273 | 620.251 | 0.193156 | 0.000754225 | 5.92066
SUPPORT | +15.620 | +15.700 | 5 | 3 | 5.9 | 0 | 0.2 | 620.3 | mc-272 | 620.251 | 0.193156 | 0.000754225 | 5.92066
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 10.2 | 0.1 | 0.3 | 1053.2 | 471-C-B185 | 1053.17 | 0.327975 | 0.00128066 | 10.0532
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 16.4 | 0.1 | 0.5 | 1698.7 | 471-C-B161 | 1698.65 | 0.528987 | 0.00206556 | 16.2146
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 15.8 | 0.1 | 0.5 | 1646.2 | 471-C-B184 | 1646.21 | 0.512655 | 0.00200179 | 15.714
2 x FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 17.5 | 0.1 | 0.6 | 1812.8 | 471-C-B165 | 1812.82 | 0.56454 | 0.00220439 | 17.3044
2 x FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 17.5 | 0.1 | 0.6 | 1813.5 | 471-C-B165 | 1813.53 | 0.564763 | 0.00220526 | 17.3113
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 15.1 | 0.1 | 0.5 | 1573.2 | 471-C-B183 | 1573.2 | 0.489919 | 0.00191301 | 15.0171
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 11.1 | 0.1 | 0.3 | 1161.4 | 471-C-B182 | 1161.41 | 0.361682 | 0.00141228 | 11.0864
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 15.8 | 0.1 | 0.5 | 1654.2 | 471-C-B181 | 1654.22 | 0.51515 | 0.00201153 | 15.7905
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-C-B170 | 1695.8 | 0.5281 | 0.0020621 | 16.1875
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 16.3 | 0.1 | 0.5 | 1696.9 | 471-C-B170 | 1696.92 | 0.528449 | 0.00206346 | 16.1982
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 9.7 | 0.1 | 0.3 | 1007.9 | 471-C-B180 | 1007.92 | 0.313881 | 0.00122563 | 9.62117
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 17.5 | 0.1 | 0.6 | 1809.6 | 471-C-B172 | 1809.63 | 0.563549 | 0.00220052 | 17.274
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 17.3 | 0.1 | 0.6 | 1795.5 | 471-C-B179 | 1795.51 | 0.55915 | 0.00218334 | 17.1392
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 17.6 | 0.1 | 0.6 | 1826.5 | 471-C-B169 | 1826.45 | 0.568786 | 0.00222097 | 17.4346
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 17.2 | 0.1 | 0.6 | 1770.7 | 471-C-B168 | 1770.72 | 0.551429 | 0.00215319 | 16.9025
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 17.6 | 0.1 | 0.6 | 1828.4 | 471-C-B167 | 1828.42 | 0.5694 | 0.00222336 | 17.4534
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 9.7 | 0.1 | 0.3 | 992 | 471-C-B178 | 992.03 | 0.308934 | 0.00120631 | 9.46952
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 17.6 | 0.1 | 0.6 | 1837.2 | 471-C-B166 | 1837.15 | 0.572118 | 0.00223398 | 17.5367
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 15.1 | 0.1 | 0.5 | 1578.6 | 471-C-B177 | 1578.57 | 0.491591 | 0.00191954 | 15.0684
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 12.4 | 0.1 | 0.3 | 1276.5 | 471-C-B176 | 1276.53 | 0.39753 | 0.00155225 | 12.1852
3 x FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 17.5 | 0.1 | 0.6 | 1812.8 | 471-C-B165 | 1812.82 | 0.56454 | 0.00220439 | 17.3044
2 x FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 17.5 | 0.1 | 0.6 | 1813.5 | 471-C-B165 | 1813.53 | 0.564763 | 0.00220526 | 17.3113
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 14 | 0.1 | 0.5 | 1446.4 | 471-C-B175 | 1446.37 | 0.450422 | 0.00175878 | 13.8064
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 15.8 | 0.1 | 0.5 | 1640 | 471-C-B174 | 1639.97 | 0.510713 | 0.0019942 | 15.6545
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 16.3 | 0.1 | 0.5 | 1696.9 | 471-C-B170 | 1696.9 | 0.528442 | 0.00206343 | 16.1979
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-C-B170 | 1695.8 | 0.5281 | 0.0020621 | 16.1875
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 16.3 | 0.1 | 0.5 | 1696.9 | 471-C-B170 | 1696.92 | 0.528449 | 0.00206346 | 16.1982
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 17.2 | 0.1 | 0.6 | 1773.5 | 471-C-B173 | 1773.52 | 0.552302 | 0.0021566 | 16.9293
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 17.5 | 0.1 | 0.6 | 1809.6 | 471-C-B172 | 1809.63 | 0.563549 | 0.00220052 | 17.274
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 15.6 | 0.1 | 0.5 | 1635.2 | 471-C-B171 | 1635.2 | 0.509229 | 0.00198841 | 15.609
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-C-B170 | 1695.93 | 0.528138 | 0.00206225 | 16.1886
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 17.6 | 0.1 | 0.6 | 1826.5 | 471-C-B169 | 1826.45 | 0.568786 | 0.00222097 | 17.4346
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 17.2 | 0.1 | 0.6 | 1770.7 | 471-C-B168 | 1770.72 | 0.551429 | 0.00215319 | 16.9025
2 x FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 17.6 | 0.1 | 0.6 | 1828.4 | 471-C-B167 | 1828.42 | 0.5694 | 0.00222336 | 17.4534
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 17.6 | 0.1 | 0.6 | 1837.2 | 471-C-B166 | 1837.15 | 0.572118 | 0.00223398 | 17.5367
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 5.9 | 0 | 0.2 | 623 | 471-C-B164 | 623.043 | 0.194026 | 0.000757621 | 5.94732
2 x FLOOR BRACE | +11.013 | +11.093 | 5 | 6 | 29.4 | 0.2 | 1 | 3055.6 | 471-D-C305 | 3055.58 | 0.951558 | 0.00371559 | 29.1674
FLOOR BRACE | +11.013 | +11.093 | 5 | 6 | 30.1 | 0.2 | 1 | 3123.5 | 471-D-C306 | 3123.54 | 0.97272 | 0.00379823 | 29.8161
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 12.9 | 0.1 | 0.3 | 1353.2 | 471-C-B163 | 1353.22 | 0.421414 | 0.00164551 | 12.9173
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 17.6 | 0.1 | 0.6 | 1832 | 471-C-B162 | 1832.02 | 0.57052 | 0.00222774 | 17.4877
2 x FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 14.7 | 0.1 | 0.5 | 1525.8 | 471-B-A161 | 1525.79 | 0.475155 | 0.00185536 | 14.5646
2 x FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 15.8 | 0.1 | 0.5 | 1646.2 | 471-B-A148 | 1646.21 | 0.512655 | 0.00200179 | 15.714
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 15.1 | 0.1 | 0.5 | 1578.6 | 471-B-A160 | 1578.57 | 0.491591 | 0.00191954 | 15.0684
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 15.8 | 0.1 | 0.5 | 1640 | 471-B-A159 | 1639.97 | 0.510713 | 0.0019942 | 15.6545
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 11.9 | 0.1 | 0.3 | 1251.2 | 471-B-A158 | 1251.25 | 0.389659 | 0.00152152 | 11.9439
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-B-A151 | 1695.8 | 0.5281 | 0.0020621 | 16.1875
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 16.3 | 0.1 | 0.5 | 1696.9 | 471-B-A151 | 1696.92 | 0.528449 | 0.00206346 | 16.1982
3 x FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 17.5 | 0.1 | 0.6 | 1812.8 | 471-B-A144 | 1812.82 | 0.56454 | 0.00220439 | 17.3044
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 17.2 | 0.1 | 0.6 | 1773.5 | 471-B-A153 | 1773.52 | 0.552302 | 0.0021566 | 16.9293
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 17.5 | 0.1 | 0.6 | 1809.6 | 471-B-A152 | 1809.63 | 0.563549 | 0.00220052 | 17.274
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 11.9 | 0.1 | 0.3 | 1241.4 | 471-B-A157 | 1241.42 | 0.386599 | 0.00150957 | 11.8501
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-B-A151 | 1695.93 | 0.528138 | 0.00206225 | 16.1886
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 17.6 | 0.1 | 0.6 | 1826.5 | 471-B-A150 | 1826.45 | 0.568786 | 0.00222097 | 17.4346
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 17.2 | 0.1 | 0.6 | 1770.7 | 471-B-A149 | 1770.72 | 0.551429 | 0.00215319 | 16.9025
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 14.7 | 0.1 | 0.5 | 1530 | 471-B-A156 | 1530.02 | 0.476473 | 0.00186051 | 14.605
2 x FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 17.6 | 0.1 | 0.6 | 1828.4 | 471-B-A146 | 1828.42 | 0.5694 | 0.00222336 | 17.4534
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 17.6 | 0.1 | 0.6 | 1837.2 | 471-B-A145 | 1837.15 | 0.572118 | 0.00223398 | 17.5367
FLOOR BRACE | +10.403 | +10.483 | 3 | 6 | 17.5 | 0.1 | 0.6 | 1813.5 | 471-B-A144 | 1813.53 | 0.564763 | 0.00220526 | 17.3113
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 15.1 | 0.1 | 0.5 | 1578.6 | 471-B-A155 | 1578.57 | 0.491591 | 0.00191954 | 15.0684
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 15.8 | 0.1 | 0.5 | 1640 | 471-B-A154 | 1639.98 | 0.510716 | 0.00199422 | 15.6546
BEAM | +5.620 | +5.700 | 3 | 23 | 7.3 | 0.1 | 0.2 | 756 | ma-113 | 756 | 0.23543 | 0.000919296 | 7.21647
BEAM | +5.620 | +5.700 | 3 | 23 | 7.3 | 0.1 | 0.2 | 756 | ma-112 | 756 | 0.23543 | 0.000919296 | 7.21647
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 16.4 | 0.1 | 0.5 | 1698.1 | 471-C-B161 | 1698.08 | 0.528808 | 0.00206486 | 16.2092
FLOOR BRACE | +21.273 | +21.353 | 4 | 6 | 17.6 | 0.1 | 0.6 | 1830.9 | 471-C-B160 | 1830.93 | 0.570181 | 0.00222641 | 17.4773
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 11.1 | 0.1 | 0.3 | 1154.2 | 471-C-B159 | 1154.17 | 0.359426 | 0.00140347 | 11.0172
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 16.3 | 0.1 | 0.5 | 1696.9 | 471-B-A151 | 1696.9 | 0.528442 | 0.00206343 | 16.1979
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-B-A151 | 1695.8 | 0.5281 | 0.0020621 | 16.1875
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 16.3 | 0.1 | 0.5 | 1696.9 | 471-B-A151 | 1696.92 | 0.528449 | 0.00206346 | 16.1982
2 x FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 15.8 | 0.1 | 0.5 | 1646.2 | 471-B-A148 | 1646.21 | 0.512655 | 0.00200179 | 15.714
3 x FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 17.5 | 0.1 | 0.6 | 1812.8 | 471-B-A144 | 1812.82 | 0.56454 | 0.00220439 | 17.3044
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 17.2 | 0.1 | 0.6 | 1773.5 | 471-B-A153 | 1773.52 | 0.552302 | 0.0021566 | 16.9293
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 17.5 | 0.1 | 0.6 | 1809.6 | 471-B-A152 | 1809.63 | 0.563549 | 0.00220052 | 17.274
3 x FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 17.6 | 0.1 | 0.6 | 1828.4 | 471-B-A146 | 1828.42 | 0.5694 | 0.00222336 | 17.4534
2 x FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 17.5 | 0.1 | 0.6 | 1813.5 | 471-B-A144 | 1813.53 | 0.564763 | 0.00220526 | 17.3113
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-B-A151 | 1695.93 | 0.528138 | 0.00206225 | 16.1886
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 17.6 | 0.1 | 0.6 | 1826.5 | 471-B-A150 | 1826.45 | 0.568786 | 0.00222097 | 17.4346
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 17.2 | 0.1 | 0.6 | 1770.7 | 471-B-A149 | 1770.72 | 0.551429 | 0.00215319 | 16.9025
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 10.9 | 0.1 | 0.3 | 1147.2 | 471-B-A147 | 1147.23 | 0.357265 | 0.00139503 | 10.951
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 17.6 | 0.1 | 0.6 | 1837.2 | 471-B-A145 | 1837.15 | 0.572118 | 0.00223398 | 17.5367
2 x FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 18.3 | 0.2 | 0.6 | 1904.3 | 471-C-B157 | 1904.27 | 0.593021 | 0.0023156 | 18.1774
2 x FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 20 | 0.2 | 0.6 | 2064.9 | 471-C-B158 | 2064.9 | 0.643042 | 0.00251091 | 19.7107
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 20 | 0.2 | 0.6 | 2065.6 | 471-C-B158 | 2065.58 | 0.643253 | 0.00251174 | 19.7172
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 18.5 | 0.2 | 0.6 | 1916.8 | 471-C-B156 | 1916.82 | 0.596928 | 0.00233085 | 18.2972
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 18.3 | 0.2 | 0.6 | 1904.3 | 471-B-A143 | 1904.27 | 0.593021 | 0.0023156 | 18.1774
2 x FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 20 | 0.2 | 0.6 | 2064.9 | 471-B-A142 | 2064.9 | 0.643042 | 0.00251091 | 19.7107
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 20 | 0.2 | 0.6 | 2065.6 | 471-B-A142 | 2065.58 | 0.643253 | 0.00251174 | 19.7172
FLOOR BRACE | +5.513 | +5.593 | 3 | 6 | 18.8 | 0.2 | 0.6 | 1948.2 | 471-B-A141 | 1948.16 | 0.606689 | 0.00236897 | 18.5964
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 18 | 0.1 | 0.6 | 1873 | 471-G-F232 | 1873.01 | 0.583285 | 0.00227758 | 17.879
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 10.5 | 0.1 | 0.3 | 1095.1 | 471-G-F231 | 1095.13 | 0.341041 | 0.00133168 | 10.4537
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 17.2 | 0.1 | 0.6 | 1790.1 | 471-G-F230 | 1790.14 | 0.557477 | 0.0021768 | 17.0879
2 x FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 16.4 | 0.1 | 0.5 | 1710.5 | 471-G-F228 | 1710.47 | 0.532668 | 0.00207993 | 16.3275
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1691.4 | 471-G-F229 | 1691.5 | 0.526759 | 0.00205686 | 16.1464
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 17.3 | 0.1 | 0.6 | 1795 | 471-G-F227 | 1795.03 | 0.559001 | 0.00218276 | 17.1347
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 13.1 | 0.1 | 0.3 | 1360.9 | 471-C-B155 | 1360.91 | 0.423808 | 0.00165486 | 12.9907
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 11.1 | 0.1 | 0.3 | 1150.6 | 471-C-B154 | 1150.6 | 0.358315 | 0.00139913 | 10.9832
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 10.9 | 0.1 | 0.3 | 1139 | 471-C-B153 | 1138.99 | 0.3547 | 0.00138501 | 10.8723
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 10.9 | 0.1 | 0.3 | 1128.3 | 471-C-B152 | 1128.26 | 0.351357 | 0.00137196 | 10.7699
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 11.9 | 0.1 | 0.3 | 1233.3 | 471-C-B151 | 1233.35 | 0.384084 | 0.00149975 | 11.773
FLOOR BRACE | +17.863 | +17.943 | 4 | 6 | 10.9 | 0.1 | 0.3 | 1119.6 | 471-C-B150 | 1119.59 | 0.348659 | 0.00136143 | 10.6872
2 x FLOOR BRACE | +15.513 | +15.593 | 5 | 6 | 16.4 | 0.1 | 0.6 | 1712.4 | 471-D-C301 | 1712.44 | 0.533281 | 0.00208233 | 16.3463
FLOOR BRACE | +15.513 | +15.593 | 5 | 6 | 18.1 | 0.2 | 0.6 | 1876.3 | 471-D-C304 | 1876.29 | 0.584305 | 0.00228156 | 17.9103
2 x FLOOR BRACE | +15.513 | +15.593 | 5 | 6 | 21.2 | 0.2 | 0.6 | 2198.1 | 471-D-C303 | 2198.1 | 0.684523 | 0.00267289 | 20.9822
2 x FLOOR BRACE | +15.513 | +15.593 | 5 | 6 | 23.8 | 0.2 | 0.8 | 2465.6 | 471-D-C302 | 2465.6 | 0.767828 | 0.00299817 | 23.5357
FLOOR BRACE | +15.513 | +15.593 | 4 | 6 | 17 | 0.1 | 0.6 | 1756.9 | 471-C-B149 | 1756.86 | 0.547114 | 0.00213634 | 16.7703
5 x FLOOR BRACE | +15.513 | +15.593 | 4 | 6 | 16.8 | 0.1 | 0.6 | 1746.4 | 471-C-B148 | 1746.37 | 0.543848 | 0.00212359 | 16.6702
FLOOR BRACE | +15.513 | +15.593 | 4 | 6 | 15.8 | 0.1 | 0.5 | 1647.9 | 471-C-B147 | 1647.91 | 0.513185 | 0.00200386 | 15.7303
FLOOR BRACE | +12.313 | +12.393 | 5 | 6 | 14.4 | 0.1 | 0.5 | 1497.1 | 471-D-C300 | 1497.13 | 0.466229 | 0.00182051 | 14.291
BEAM | +5.620 | +5.700 | 3 | 23 | 6.8 | 0.1 | 0.2 | 720.2 | ma-111 | 720.25 | 0.224297 | 0.000875824 | 6.87522
BEAM | +5.620 | +5.700 | 3 | 23 | 6.8 | 0.1 | 0.2 | 720.2 | ma-110 | 720.25 | 0.224297 | 0.000875824 | 6.87522

# IfcBeam: PC180*70, BEAM
In: Undefined
Description: PC180*70; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +2.570; Top elevation: +2.750; Phase: 5; Class: 7
Tekla Quantity - Weight: 32 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 29.2 m2; Net surface area: 0.8 m2; Height: 180 mm; Width: 70 mm; Length: 1516.4 mm
Pset_BeamCommon - LoadBearing: yes; Reference: mc-349
BaseQuantities - Length: 1516.4 mm; OuterSurfaceArea: 0.935078 m2; NetVolume: 0.00391621 m3; NetWeight: 30.7423 kg

# IfcBeam: PC200*75 (74)
In: Undefined
Description: PC200*75; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 27.8 m2; Height: 200 mm; Width: 75 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x BEAM | +66.050 | +66.250 | 8 | 7 | 41.1 | 0.1 | 1.1 | 1691.4 | mf-285 | 1691.4 | 1.14206 | 0.00500194 | 39.2653
4 x BEAM | +55.105 | +55.305 | 8 | 7 | 41.1 | 0.1 | 1.1 | 1691.4 | mf-285 | 1691.4 | 1.14206 | 0.00500194 | 39.2653
4 x BEAM | +70.450 | +70.650 | 8 | 7 | 41.1 | 0.1 | 1.1 | 1691.4 | mf-285 | 1691.4 | 1.14206 | 0.00500194 | 39.2653
BEAM | +70.450 | +70.650 | 8 | 7 | 17.6 | 0.1 | 0.5 | 724.5 | mf-286 | 724.5 | 0.489193 | 0.00220176 | 17.2838
2 x BEAM | +63.250 | +63.450 | 8 | 7 | 21.2 | 0.1 | 0.6 | 872.3 | mf-287 | 872.25 | 0.588956 | 0.00265077 | 20.8085
BEAM | +63.250 | +63.450 | 8 | 7 | 17.6 | 0.1 | 0.5 | 724.5 | mf-286 | 724.5 | 0.489193 | 0.00220176 | 17.2838
2 x BEAM | +55.105 | +55.305 | 8 | 7 | 21.2 | 0.1 | 0.6 | 872.3 | mf-287 | 872.25 | 0.588956 | 0.00265077 | 20.8085
BEAM | +55.105 | +55.305 | 8 | 7 | 17.6 | 0.1 | 0.5 | 724.5 | mf-286 | 724.5 | 0.489193 | 0.00220176 | 17.2838
BEAM | +44.375 | +44.575 | 7 | 7 | 22.1 | 0.1 | 0.6 | 910 | me-181 | 910 | 0.614445 | 0.00276549 | 21.7091
BEAM | +44.375 | +44.575 | 7 | 7 | 17.5 | 0.1 | 0.5 | 720.3 | me-179 | 720.25 | 0.486323 | 0.00218884 | 17.1824
BEAM | +36.070 | +36.270 | 6 | 7 | 22.7 | 0.1 | 0.6 | 935 | md-139 | 935 | 0.631325 | 0.00284147 | 22.3055
BEAM | +36.070 | +36.270 | 6 | 7 | 24.2 | 0.1 | 0.6 | 995.3 | md-136 | 995.25 | 0.672007 | 0.00302456 | 23.7428
BEAM | +36.070 | +36.270 | 6 | 7 | 24.2 | 0.1 | 0.6 | 995.3 | md-138 | 995.25 | 0.672007 | 0.00302456 | 23.7428
BEAM | +28.880 | +29.080 | 6 | 7 | 22.7 | 0.1 | 0.6 | 935 | md-139 | 935 | 0.631325 | 0.00284147 | 22.3055
BEAM | +28.880 | +29.080 | 6 | 7 | 24.2 | 0.1 | 0.6 | 995.3 | md-136 | 995.25 | 0.672007 | 0.00302456 | 23.7428
BEAM | +28.880 | +29.080 | 6 | 7 | 24.2 | 0.1 | 0.6 | 995.3 | md-138 | 995.25 | 0.672007 | 0.00302456 | 23.7428
3 x POST | +55.317 | +56.588 | 8 | 13 | 30.9 | 0 | 0.8 | 1271 | mf-284 | 1271 | 0.858197 | 0.00386257 | 30.3212
3 x POST | +55.319 | +56.588 | 8 | 13 | 30.8 | 0 | 0.8 | 1269 | mf-283 | 1269 | 0.856847 | 0.00385649 | 30.2735
PLATFORM ASS. | +56.600 | +56.800 | 8 | 13 | 83.4 | 0.3 | 2.5 | 3434 | mf-279 | 3434 | 2.31869 | 0.0104359 | 81.922
4 x POST | +36.284 | +37.888 | 7 | 13 | 39 | 0 | 1.1 | 1604 | me-178 | 1604 | 1.08304 | 0.00487456 | 38.2653
PLATFORM ASS. | +37.900 | +38.100 | 7 | 13 | 59.6 | 0.2 | 1.7 | 2454 | me-173 | 2454 | 1.65698 | 0.00745771 | 58.543
4 x BEAM | +48.500 | +48.700 | 7 | 14 | 33.7 | 0.1 | 0.8 | 1387.3 | me-180 | 1387.34 | 0.936754 | 0.00407792 | 32.0117
4 x BEAM | +44.375 | +44.575 | 7 | 14 | 33.7 | 0.1 | 0.8 | 1387.3 | me-180 | 1387.34 | 0.936754 | 0.00407792 | 32.0117
4 x BEAM | +36.070 | +36.270 | 6 | 14 | 33.7 | 0.1 | 0.8 | 1387.3 | md-137 | 1387.34 | 0.936754 | 0.00407792 | 32.0117
4 x BEAM | +28.880 | +29.080 | 6 | 14 | 33.7 | 0.1 | 0.8 | 1387.3 | md-137 | 1387.34 | 0.936754 | 0.00407792 | 32.0117
BEAM | +21.260 | +21.460 | 4 | 7 | 22.7 | 0.1 | 0.6 | 935 | mb-189 | 935 | 0.631325 | 0.00284147 | 22.3055
BEAM | +21.260 | +21.460 | 4 | 7 | 24.2 | 0.1 | 0.6 | 995.3 | mb-186 | 995.25 | 0.672007 | 0.00302456 | 23.7428
BEAM | +21.260 | +21.460 | 4 | 7 | 24.2 | 0.1 | 0.6 | 995.3 | mb-188 | 995.25 | 0.672007 | 0.00302456 | 23.7428
4 x BEAM | +21.260 | +21.460 | 4 | 7 | 33.7 | 0.1 | 0.8 | 1387.3 | mb-187 | 1387.34 | 0.936754 | 0.00407792 | 32.0117
4 x BEAM | +17.850 | +18.050 | 4 | 14 | 33.7 | 0.1 | 0.8 | 1387.3 | mb-187 | 1387.34 | 0.936754 | 0.00407792 | 32.0117
4 x BEAM | +10.390 | +10.590 | 3 | 14 | 33.7 | 0.1 | 0.8 | 1387.3 | ma-171 | 1387.34 | 0.936754 | 0.00407792 | 32.0117
4 x BEAM | +5.500 | +5.700 | 3 | 23 | 33.7 | 0.1 | 0.8 | 1387.3 | ma-171 | 1387.34 | 0.936754 | 0.00407792 | 32.0117

# IfcBeam: PC260*90, BEAM
In: Undefined
Description: PC260*90; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +10.940; Top elevation: +11.200; Phase: 5; Class: 5
Tekla Quantity - Weight: 207.2 kg; Volume: 0 m3; Gross footprint area: 0.5 m2; Area per tons: 24.4 m2; Net surface area: 5.2 m2; Height: 260 mm; Width: 90 mm; Length: 5956.7 mm
Pset_BeamCommon - LoadBearing: yes; Reference: mc-460
BaseQuantities - Length: 5956.7 mm; OuterSurfaceArea: 5.08523 m2; NetVolume: 0.0258613 m3; NetWeight: 203.011 kg

# IfcBeam: PC300*100 (29)
In: Undefined
Description: PC300*100; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 21.5 m2; Height: 300 mm; Width: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BEAM | +63.150 | +63.450 | 8 | 14 | 70 | 0.1 | 1.5 | 1544.3 | mf-277 | 1544.35 | 1.50064 | 0.00867482 | 68.0973
BEAM | +63.150 | +63.450 | 8 | 14 | 38.6 | 0.1 | 0.8 | 851.3 | mf-274 | 851.35 | 0.827256 | 0.004422 | 34.7127
2 x BEAM | +63.150 | +63.450 | 8 | 14 | 29.4 | 0.1 | 0.6 | 648 | mf-271 | 648 | 0.629661 | 0.00369554 | 29.01
BEAM | +44.275 | +44.575 | 7 | 7 | 32.6 | 0.1 | 0.6 | 720.3 | me-172 | 720.25 | 0.699866 | 0.00410759 | 32.2445
BEAM | +44.275 | +44.575 | 7 | 7 | 28.2 | 0.1 | 0.6 | 622 | me-170 | 622 | 0.604397 | 0.00354727 | 27.846
BEAM | +44.275 | +44.575 | 7 | 7 | 34 | 0.1 | 0.6 | 751.5 | me-171 | 751.5 | 0.730232 | 0.0042858 | 33.6436
BEAM | +35.970 | +36.270 | 6 | 7 | 71.9 | 0.2 | 1.6 | 1587.2 | md-135 | 1587.25 | 1.54233 | 0.00905208 | 71.0588
BEAM | +35.970 | +36.270 | 6 | 7 | 46.5 | 0.1 | 1 | 1026.5 | md-134 | 1026.5 | 0.997449 | 0.00585413 | 45.9549
BEAM | +28.780 | +29.080 | 6 | 7 | 71.9 | 0.2 | 1.6 | 1587.2 | md-135 | 1587.25 | 1.54233 | 0.00905208 | 71.0588
BEAM | +28.780 | +29.080 | 6 | 7 | 46.5 | 0.1 | 1 | 1026.5 | md-134 | 1026.5 | 0.997449 | 0.00585413 | 45.9549
BEAM | +21.160 | +21.460 | 4 | 7 | 71.9 | 0.2 | 1.6 | 1587.2 | mb-185 | 1587.25 | 1.54233 | 0.00905208 | 71.0588
2 x BEAM | +63.150 | +63.450 | 8 | 14 | 38.6 | 0.1 | 0.8 | 851.3 | mf-272 | 851.35 | 0.827256 | 0.004422 | 34.7127
BEAM | +63.150 | +63.450 | 8 | 14 | 161.4 | 0.3 | 3.5 | 3564 | mf-270 | 3564 | 3.46314 | 0.0203255 | 159.555
BEAM | +63.150 | +63.450 | 8 | 14 | 70 | 0.1 | 1.5 | 1544.3 | mf-276 | 1544.35 | 1.50064 | 0.00867825 | 68.1243
BEAM | +63.150 | +63.450 | 8 | 14 | 74.8 | 0.1 | 1.6 | 1651.4 | mf-273 | 1651.35 | 1.60462 | 0.0089844 | 70.5275
BEAM | +63.150 | +63.450 | 8 | 14 | 74.8 | 0.1 | 1.6 | 1651.4 | mf-269 | 1651.35 | 1.60462 | 0.0089844 | 70.5275
BEAM | +63.150 | +63.450 | 8 | 14 | 74.8 | 0.1 | 1.6 | 1651.4 | mf-268 | 1651.35 | 1.60461 | 0.00898439 | 70.5275
BEAM | +63.150 | +63.450 | 8 | 14 | 34.2 | 0.1 | 0.6 | 755 | mf-267 | 755 | 0.733633 | 0.00400512 | 31.4402
BEAM | +63.150 | +63.450 | 8 | 14 | 238.3 | 0.5 | 5.2 | 5260.3 | mf-266 | 5260.35 | 5.11148 | 0.0298672 | 234.457
BEAM | +63.150 | +63.450 | 8 | 14 | 238.3 | 0.5 | 5.2 | 5260.3 | mf-265 | 5260.35 | 5.11148 | 0.0298672 | 234.457
BEAM | +63.150 | +63.450 | 8 | 14 | 315.1 | 0.6 | 6.8 | 6956.7 | mf-264 | 6956.7 | 6.75982 | 0.0394123 | 309.386
BEAM | +63.150 | +63.450 | 8 | 14 | 238.3 | 0.5 | 5.2 | 5260.3 | mf-263 | 5260.35 | 5.11148 | 0.0298672 | 234.457
BEAM | +63.150 | +63.450 | 8 | 14 | 70 | 0.1 | 1.5 | 1544.3 | mf-275 | 1544.35 | 1.50064 | 0.00867482 | 68.0974
BEAM | +63.150 | +63.450 | 8 | 14 | 70 | 0.1 | 1.5 | 1544.3 | mf-262 | 1544.35 | 1.50064 | 0.00867482 | 68.0973
BEAM | +63.150 | +63.450 | 8 | 14 | 70 | 0.1 | 1.5 | 1544.3 | mf-261 | 1544.35 | 1.50064 | 0.00867482 | 68.0974
BEAM | +63.150 | +63.450 | 8 | 14 | 70 | 0.1 | 1.5 | 1544.3 | mf-261 | 1544.35 | 1.50064 | 0.00867482 | 68.0973
BEAM | +21.160 | +21.460 | 4 | 7 | 46.5 | 0.1 | 1 | 1026.5 | mb-184 | 1026.5 | 0.997449 | 0.00585413 | 45.9549

# IfcBeam: PFC100*50 (3)
In: Undefined
Description: PFC100*50; Material: STEEL/S355JR
Tekla Common - Phase: 5; Class: 99
Tekla Quantity - Weight: 11.1 kg; Volume: 0 m3; Area per tons: 37.9 m2; Net surface area: 0.3 m2; Height: 100 mm; Width: 50 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Gross footprint area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
END PLATE | +5.600 | +5.700 | 0.1 | 1103.4 | mc-464 | 1103.4 | 0.42237 | 0.00134313 | 10.5436
END PLATE | +5.600 | +5.700 | 0 | 1103.6 | mc-463 | 1103.55 | 0.422427 | 0.00132659 | 10.4138
END PLATE | +12.400 | +12.500 | 0.1 | 1103.4 | mc-462 | 1103.4 | 0.42237 | 0.00134313 | 10.5436

# IfcBeam: PFC180*70 (4)
In: Undefined
Description: PFC180*70; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +2.570; Top elevation: +2.750; Phase: 5; Class: 7
Tekla Quantity - Weight: 12.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.2 m2; Net surface area: 0.3 m2; Height: 180 mm; Width: 70 mm; Length: 586.4 mm
Pset_BeamCommon - LoadBearing: yes; Reference: mc-397
BaseQuantities - Length: 586.4 mm; OuterSurfaceArea: 0.3616 m2; NetVolume: 0.00146392 m3; NetWeight: 11.4918 kg

# IfcBeam: PFC200*75 (82)
In: Undefined
Description: PFC200*75; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 27.8 m2; Height: 200 mm; Width: 75 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x BEAM | +63.250 | +63.450 | 8 | 14 | 47.3 | 0.1 | 1.3 | 1947.4 | mf-49 | 1947.37 | 1.31489 | 0.00581418 | 45.6413
BEAM | +63.250 | +63.450 | 8 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | mf-41 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
2 x PIPE SUPPORT | +5.500 | +5.700 | 5 | 6 | 19.4 | 0.1 | 0.6 | 803.9 | mc-43 | 803.931 | 0.542825 | 0.00244315 | 19.1787
BEAM | +9.000 | +9.200 | 5 | 7 | 150.2 | 0.5 | 4.3 | 6180 | 471-D-C20 | 6180 | 4.17282 | 0.018781 | 147.431
BEAM | +48.500 | +48.700 | 7 | 3 | 64.8 | 0.2 | 1.7 | 2664.7 | me-27 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +48.500 | +48.700 | 7 | 3 | 23 | 0.1 | 0.6 | 941.7 | me-26 | 941.7 | 0.635849 | 0.00265222 | 20.8199
BEAM | +57.820 | +58.020 | 8 | 3 | 64.8 | 0.2 | 1.7 | 2664.7 | mf-39 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +57.820 | +58.020 | 8 | 3 | 21 | 0.1 | 0.6 | 861.7 | mf-38 | 861.7 | 0.581832 | 0.0024091 | 18.9114
BEAM | +57.820 | +58.020 | 8 | 3 | 21 | 0.1 | 0.6 | 861.7 | mf-37 | 861.7 | 0.581832 | 0.0024091 | 18.9114
BEAM | +50.953 | +51.153 | 8 | 3 | 51.4 | 0.1 | 1.5 | 2115.9 | mf-34 | 2115.9 | 1.42869 | 0.00629142 | 49.3876
BEAM | +46.813 | +47.013 | 7 | 3 | 51.4 | 0.1 | 1.5 | 2115.9 | me-25 | 2115.9 | 1.42869 | 0.00629142 | 49.3876
BEAM | +44.375 | +44.575 | 7 | 3 | 64.8 | 0.2 | 1.7 | 2664.7 | me-24 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +41.606 | +41.806 | 7 | 3 | 51.4 | 0.1 | 1.5 | 2115.9 | me-25 | 2115.9 | 1.42869 | 0.00629142 | 49.3876
BEAM | +38.838 | +39.038 | 7 | 3 | 64.8 | 0.2 | 1.7 | 2664.7 | me-24 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +44.375 | +44.575 | 7 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | me-23 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +44.375 | +44.575 | 7 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | me-22 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +44.375 | +44.575 | 7 | 14 | 88.8 | 0.3 | 2.5 | 3660 | me-20 | 3660 | 2.47128 | 0.0111227 | 87.3135
BEAM | +70.450 | +70.650 | 8 | 7 | 27.2 | 0.1 | 0.8 | 1120.4 | mf-40 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +70.450 | +70.650 | 8 | 7 | 88.8 | 0.3 | 2.5 | 3660 | mf-31 | 3660 | 2.47128 | 0.0111227 | 87.3135
BEAM | +55.105 | +55.305 | 8 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | mf-30 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +55.105 | +55.305 | 8 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | mf-29 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +55.105 | +55.305 | 8 | 14 | 88.8 | 0.3 | 2.5 | 3660 | mf-28 | 3660 | 2.47128 | 0.0111227 | 87.3135
BEAM | +63.250 | +63.450 | 8 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | mf-30 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +63.250 | +63.450 | 8 | 14 | 80.4 | 0.2 | 2.3 | 3310 | mf-27 | 3310 | 2.23496 | 0.0100591 | 78.9639
BEAM | +38.838 | +39.038 | 7 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | me-21 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +38.838 | +39.038 | 7 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | me-23 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +38.838 | +39.038 | 7 | 14 | 88.8 | 0.3 | 2.5 | 3660 | me-19 | 3660 | 2.47128 | 0.0111227 | 87.3135
BEAM | +36.070 | +36.270 | 6 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | md-22 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +36.070 | +36.270 | 6 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | md-21 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +36.070 | +36.270 | 6 | 14 | 88.8 | 0.3 | 2.5 | 3660 | md-19 | 3660 | 2.47128 | 0.0111227 | 87.3135
BEAM | +28.880 | +29.080 | 6 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | md-20 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +28.880 | +29.080 | 6 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | md-22 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +28.880 | +29.080 | 6 | 14 | 88.8 | 0.3 | 2.5 | 3660 | md-18 | 3660 | 2.47128 | 0.0111227 | 87.3135
BEAM | +21.260 | +21.460 | 4 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | mb-28 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +21.260 | +21.460 | 4 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | mb-27 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +17.850 | +18.050 | 4 | 14 | 27.2 | 0.1 | 0.8 | 1120.4 | mb-26 | 1120.35 | 0.756476 | 0.0033254 | 26.1044
BEAM | +21.260 | +21.460 | 4 | 14 | 64.8 | 0.2 | 1.7 | 2665.9 | mb-24 | 2665.9 | 1.80005 | 0.00794556 | 62.3727
BEAM | +15.500 | +15.700 | 4 | 23 | 64.8 | 0.2 | 1.7 | 2664.7 | mb-22 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +21.260 | +21.460 | 4 | 14 | 88.8 | 0.3 | 2.5 | 3660 | mb-20 | 3660 | 2.47128 | 0.0111227 | 87.3135
2 x PIPE SUPPORT | +10.390 | +10.590 | 3 | 6 | 26.8 | 0.1 | 0.6 | 1099.4 | ma-21 | 1099.4 | 0.74233 | 0.00316974 | 24.8825
PIPE SUPPORT | +10.390 | +10.590 | 3 | 6 | 21.1 | 0.1 | 0.6 | 866.4 | ma-20 | 866.399 | 0.585005 | 0.00246902 | 19.3818
PIPE SUPPORT | +10.390 | +10.590 | 3 | 6 | 21.1 | 0.1 | 0.6 | 866.4 | ma-19 | 866.399 | 0.585005 | 0.00246713 | 19.367
Beam | +1.000 | +1.200 | 1 | 4 | 52.5 | 0.2 | 1.5 | 2160.1 | 471-0-010008 | 2160 | 1.45846 | 0.00656424 | 51.5293
Beam | +1.000 | +1.200 | 1 | 4 | 52.7 | 0.2 | 1.5 | 2170 | 471-0-010007 | 2170 | 1.46521 | 0.00659463 | 51.7678
Beam | +1.000 | +1.200 | 1 | 4 | 105.2 | 0.3 | 3 | 4330 | 471-0-010006 | 4330 | 2.92368 | 0.0131589 | 103.297
Beam | +1.000 | +1.200 | 1 | 4 | 21.1 | 0.1 | 0.6 | 870 | 471-0-010005 | 870 | 0.587436 | 0.00264393 | 20.7549
2 x Beam | +1.000 | +1.200 | 1 | 4 | 35.7 | 0.1 | 1 | 1470 | 471-0-010004 | 1470 | 0.992565 | 0.00446733 | 35.0685
BEAM | +66.050 | +66.250 | 8 | 3 | 64.8 | 0.2 | 1.7 | 2664.7 | mf-33 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +55.105 | +55.305 | 8 | 3 | 64.8 | 0.2 | 1.7 | 2664.7 | mf-16 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +52.840 | +53.040 | 8 | 3 | 64.8 | 0.2 | 1.7 | 2664.7 | mf-39 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +36.070 | +36.270 | 6 | 3 | 64.8 | 0.2 | 1.7 | 2664.7 | md-11 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +31.528 | +31.728 | 6 | 3 | 64.8 | 0.2 | 1.7 | 2664.7 | md-10 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +28.880 | +29.080 | 6 | 3 | 64.8 | 0.2 | 1.7 | 2664.7 | md-11 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +24.118 | +24.318 | 4 | 23 | 64.8 | 0.2 | 1.7 | 2664.7 | mb-25 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +17.850 | +18.050 | 4 | 14 | 64.8 | 0.2 | 1.7 | 2665.9 | mb-24 | 2665.9 | 1.80005 | 0.00794556 | 62.3727
BEAM | +10.390 | +10.590 | 3 | 14 | 64.8 | 0.2 | 1.7 | 2664.7 | ma-8 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +5.500 | +5.700 | 3 | 23 | 64.8 | 0.2 | 1.7 | 2664.7 | ma-8 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +70.450 | +70.650 | 8 | 3 | 64.8 | 0.2 | 1.7 | 2664.7 | mf-3 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +17.850 | +18.050 | 4 | 14 | 89.6 | 0.3 | 2.5 | 3690 | mb-1 | 3690 | 2.49154 | 0.0112139 | 88.0292
BEAM | +63.250 | +63.450 | 8 | 3 | 64.8 | 0.2 | 1.7 | 2664.7 | mf-16 | 2664.7 | 1.79924 | 0.00793933 | 62.3237
BEAM | +70.450 | +70.650 | 8 | 6 | 26.9 | 0.1 | 0.6 | 1110.9 | mf-2 | 1110.85 | 0.750062 | 0.00317734 | 24.9421
BEAM | +68.250 | +68.450 | 8 | 3 | 51.4 | 0.1 | 1.5 | 2115.9 | mf-32 | 2115.9 | 1.42869 | 0.00629142 | 49.3876
BEAM | +60.535 | +60.735 | 8 | 3 | 51.4 | 0.1 | 1.5 | 2115.9 | mf-15 | 2115.9 | 1.42869 | 0.00629142 | 49.3876
BEAM | +33.799 | +33.999 | 6 | 3 | 51.4 | 0.1 | 1.5 | 2115.9 | md-9 | 2115.9 | 1.42869 | 0.00629142 | 49.3876
BEAM | +19.555 | +19.755 | 4 | 3 | 51.4 | 0.1 | 1.5 | 2115.9 | mb-23 | 2115.9 | 1.42869 | 0.00629142 | 49.3876
BEAM | +2.500 | +2.700 | 3 | 3 | 51.4 | 0.1 | 1.5 | 2115.9 | ma-7 | 2115.9 | 1.42869 | 0.00629142 | 49.3876
BEAM | +66.050 | +66.250 | 8 | 3 | 26.9 | 0.1 | 0.6 | 1110.8 | mf-1 | 1110.85 | 0.750062 | 0.00317258 | 24.9048
BEAM | +52.840 | +53.040 | 8 | 3 | 21 | 0.1 | 0.6 | 861.7 | mf-36 | 861.7 | 0.581832 | 0.0024091 | 18.9114
BEAM | +52.840 | +53.040 | 8 | 3 | 21 | 0.1 | 0.6 | 861.7 | mf-35 | 861.7 | 0.581832 | 0.0024091 | 18.9114
BEAM | +7.945 | +8.145 | 3 | 3 | 51.4 | 0.1 | 1.5 | 2115.9 | ma-7 | 2115.9 | 1.42869 | 0.00629142 | 49.3876
BEAM | +26.215 | +26.415 | 6 | 3 | 51.4 | 0.1 | 1.5 | 2115.9 | md-9 | 2115.9 | 1.42869 | 0.00629142 | 49.3876
BEAM | +12.945 | +13.145 | 4 | 3 | 51.4 | 0.1 | 1.5 | 2115.9 | mb-21 | 2115.9 | 1.42869 | 0.00629142 | 49.3876
BEAM | +12.300 | +12.500 | 5 | 7 | 31.7 | 0.1 | 0.8 | 1305.3 | mc-19 | 1305.25 | 0.881323 | 0.00396665 | 31.1382
BEAM | +9.900 | +10.100 | 5 | 4 | 25 | 0.1 | 0.6 | 1027 | mc-17 | 1027 | 0.693445 | 0.00312105 | 24.5003
BEAM | +7.700 | +7.900 | 5 | 4 | 25 | 0.1 | 0.6 | 1027 | mc-17 | 1027 | 0.693445 | 0.00312105 | 24.5003
BEAM | +5.500 | +5.700 | 5 | 4 | 31.7 | 0.1 | 0.8 | 1305.3 | mc-15 | 1305.25 | 0.881323 | 0.00396665 | 31.1382

# IfcBeam: ROD25, HANDRAIL
In: Undefined
Description: ROD25; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +22.565; Top elevation: +22.590; Phase: 1; Class: 3
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 21.5 m2; Net surface area: 0.1 m2; Height: 25 mm; Width: 25 mm; Length: 909 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 471-0-010030
BaseQuantities - Length: 909 mm; OuterSurfaceArea: 0.0715175 m2; NetVolume: 0.000426094 m3; NetWeight: 3.34484 kg

# IfcBeam: SHS200*200*10.0 (5)
In: Undefined
Description: SHS200*200*10.0; Material: STEEL/S355JR
Tekla Common - Phase: 5; Class: 4
Tekla Quantity - Area per tons: 13.3 m2; Height: 200 mm; Width: 200 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BEAM | +2.500 | +2.700 | 121.8 | 0 | 0.3 | 1.7 | 2137 | mc-459 | 1.61788 | 0.0159597 | 125.284
2 x BEAM | +2.500 | +2.700 | 340.9 | 0 | 1.2 | 4.8 | 5981 | mc-458 | 4.52809 | 0.0454556 | 356.826
BEAM | +7.700 | +7.900 | 227.3 | 0 | 0.9 | 3.2 | 3988 | mc-457 | 3.01923 | 0.0303088 | 237.924
BEAM | +9.900 | +10.100 | 398.3 | 0.1 | 1.5 | 5.6 | 6988 | mc-456 | 5.29047 | 0.0531088 | 416.904

# IfcBeam: SHS250*250*10.0 (4)
In: Undefined
Description: SHS250*250*10.0; Material: STEEL/S355JR
Tekla Common - Phase: 5; Class: 6
Tekla Quantity - Area per tons: 13.3 m2; Height: 250 mm; Width: 250 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BEAM | +14.950 | +15.200 | 287.5 | 0 | 0.9 | 4 | 3954.1 | mc-322 | 3.78439 | 0.0379594 | 297.981
2 x BEAM | +14.950 | +15.200 | 432.9 | 0.1 | 1.5 | 5.9 | 5954.1 | mc-321 | 5.69855 | 0.0571594 | 448.701
BEAM | +18.350 | +18.600 | 432.9 | 0.1 | 1.5 | 5.9 | 5954.1 | mc-321 | 5.69855 | 0.0571594 | 448.701

# IfcBeam: UB203*133*25 (10)
In: Undefined
Description: UB203*133*25; Material: STEEL/S355JR
Tekla Common - Class: 14
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 36.5 m2; Height: 203.2 mm; Width: 133.4 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x BEAM | +55.102 | +55.305 | 8 | 21.8 | 0.8 | 865.5 | mf-334 | 865.549 | 0.792455 | 0.00253062 | 19.8654
3 x BEAM | +55.102 | +55.305 | 8 | 21.8 | 0.8 | 866.4 | mf-333 | 866.4 | 0.793235 | 0.00252354 | 19.8098
BEAM | +55.102 | +55.305 | 8 | 21.8 | 0.8 | 865.5 | mf-334 | 865.549 | 0.792455 | 0.0025316 | 19.8731
BEAM | +36.067 | +36.270 | 6 | 19.4 | 0.6 | 771.4 | md-174 | 771.449 | 0.706302 | 0.00232738 | 18.2699
2 x BEAM | +36.067 | +36.270 | 6 | 21.8 | 0.8 | 866.4 | md-173 | 866.4 | 0.793235 | 0.00252354 | 19.8098
BEAM | +36.067 | +36.270 | 6 | 21.8 | 0.8 | 865.5 | md-172 | 865.549 | 0.792455 | 0.00253062 | 19.8654

# IfcBeam: UB254*146*31 (56)
In: Undefined
Description: UB254*146*31; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 34.2 m2; Height: 251.5 mm; Width: 146.1 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BEAM | +19.504 | +19.755 | 4 | 4 | 72.7 | 0.3 | 2.5 | 2336.8 | mb-169 | 2336.8 | 2.4825 | 0.00915726 | 71.8845
2 x BEAM | +26.164 | +26.415 | 6 | 4 | 72.7 | 0.3 | 2.5 | 2336.8 | md-130 | 2336.8 | 2.4825 | 0.00915726 | 71.8845
2 x BEAM | +2.449 | +2.700 | 3 | 4 | 72.7 | 0.3 | 2.5 | 2336.8 | ma-159 | 2336.8 | 2.4825 | 0.00915726 | 71.8845
2 x BEAM | +7.893 | +8.145 | 3 | 4 | 72.7 | 0.3 | 2.5 | 2336.8 | ma-159 | 2336.8 | 2.4825 | 0.00915726 | 71.8845
2 x BEAM | +12.893 | +13.145 | 4 | 4 | 72.7 | 0.3 | 2.5 | 2336.8 | mb-168 | 2336.8 | 2.4825 | 0.00915726 | 71.8845
BEAM | +60.483 | +60.735 | 8 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | mf-254 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +33.747 | +33.999 | 6 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | md-129 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +33.747 | +33.999 | 6 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | md-128 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +19.504 | +19.755 | 4 | 4 | 95.3 | 0.3 | 3.3 | 3063 | mb-167 | 3062.95 | 3.25393 | 0.0118093 | 92.703
BEAM | +12.893 | +13.145 | 4 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | mb-166 | 6965.9 | 7.40024 | 0.0269103 | 211.246
7 x BEAM | +2.498 | +2.750 | 5 | 7 | 149.7 | 0.6 | 5.2 | 4816.7 | mc-326 | 4816.7 | 5.11703 | 0.0186679 | 146.543
BEAM | +2.498 | +2.750 | 5 | 7 | 149.7 | 0.6 | 5.2 | 4816.8 | mc-326 | 4816.8 | 5.11714 | 0.0186679 | 146.543
BEAM | +68.198 | +68.450 | 8 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | mf-253 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +68.198 | +68.450 | 8 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | mf-252 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +50.901 | +51.153 | 8 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | mf-251 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +50.901 | +51.153 | 8 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | mf-250 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +26.164 | +26.415 | 6 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | md-127 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +26.164 | +26.415 | 6 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | md-126 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +19.504 | +19.755 | 4 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | mb-165 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +12.893 | +13.145 | 4 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | mb-164 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +7.893 | +8.145 | 3 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | ma-158 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +7.893 | +8.145 | 3 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | ma-157 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +2.448 | +2.700 | 3 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | ma-156 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +2.449 | +2.700 | 3 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | ma-156 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +15.448 | +15.700 | 4 | 23 | 216.6 | 0.9 | 7.4 | 6964.7 | mb-163 | 6964.7 | 7.39896 | 0.0270715 | 212.511
2 x BEAM | +8.353 | +8.604 | 5 | 3 | 181.7 | 0.9 | 6.3 | 5842.5 | mc-325 | 5842.5 | 6.20679 | 0.0228951 | 179.727
BEAM | +60.483 | +60.735 | 8 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | mf-249 | 6965.9 | 7.40024 | 0.0269103 | 211.246
BEAM | +46.761 | +47.013 | 7 | 4 | 216.6 | 0.9 | 7.4 | 6965.9 | me-164 | 6965.9 | 7.40024 | 0.0269103 | 211.246
