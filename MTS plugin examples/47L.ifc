Properties of the parts of a building model (IFC2X3), part 18 of 22

# IfcElementAssembly (4115)
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Steel Assembly | RIGID_FRAME | 16.2 | +36.090 | +36.160 | D-E/2-3 | 471-E-D141 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +33.824 | +35.104 | D-E/2-3 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +33.824 | +35.104 | D-E/2-3 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 7.8 | +33.999 | +35.104 | D/2-3 | 471-E-D150 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +33.999 | +35.104 | E/2-3 | 471-E-D149 | 70.0002
Steel Assembly | RIGID_FRAME | 120.3 | +68.475 | +70.269 | D-E/2 | 471-G-F375 | 219.1
Steel Assembly | RIGID_FRAME | 159.6 | +69.941 | +70.650 | D-E/2 | 471-G-F87 | 190
Steel Assembly | RIGID_FRAME | 118.3 | +67.846 | +68.803 | D-E/2 | 471-G-F311 | 170
Steel Assembly | RIGID_FRAME | 123.8 | +66.275 | +68.173 | D-E/2 | 471-G-F376 | 219.1
Steel Assembly | RIGID_FRAME | 140.7 | +63.475 | +65.869 | D-E/2 | 471-G-F377 | 219.1
Steel Assembly | RIGID_FRAME | 176.7 | +65.545 | +66.603 | D-E/2 | 471-G-F88 | 190
Steel Assembly | RIGID_FRAME | 137.7 | +60.760 | +63.069 | D-E/2 | 471-G-F378 | 219.1
Steel Assembly | RIGID_FRAME | 141.4 | +58.045 | +60.458 | D-E/2 | 471-G-F373 | 219.1
Steel Assembly | RIGID_FRAME | 115.2 | +60.134 | +61.085 | D-E/2 | 471-G-F312 | 170
Steel Assembly | RIGID_FRAME | 137.7 | +55.330 | +57.639 | D-E/2 | 471-G-F374 | 219.1
Steel Assembly | RIGID_FRAME | 175.5 | +57.314 | +58.369 | D-E/2 | 471-G-F90 | 190
Steel Assembly | RIGID_FRAME | 122.4 | +53.065 | +54.924 | D-E/2 | 471-G-F370 | 219.1
Steel Assembly | RIGID_FRAME | 177.1 | +54.596 | +55.655 | D-E/2 | 471-G-F92 | 190
Steel Assembly | RIGID_FRAME | 109.5 | +51.178 | +52.659 | D-E/2 | 471-G-F371 | 219.1
Steel Assembly | RIGID_FRAME | 180.2 | +52.332 | +53.393 | D-E/2 | 471-G-F91 | 190
Steel Assembly | RIGID_FRAME | 132.4 | +48.725 | +50.876 | D-E/2 | 471-G-F372 | 219.1
Steel Assembly | RIGID_FRAME | 118.8 | +50.550 | +51.505 | D-E/2 | 471-G-F313 | 170
Steel Assembly | RIGID_FRAME | 102.4 | +47.038 | +48.319 | D-E/2 | 471-F-E236 | 219.1
Steel Assembly | RIGID_FRAME | 180.2 | +47.995 | +49.051 | D-E/2 | 471-F-E49 | 190
Steel Assembly | RIGID_FRAME | 131.9 | +44.600 | +46.736 | D-E/2 | 471-F-E237 | 219.1
Steel Assembly | RIGID_FRAME | 120.1 | +46.410 | +47.363 | D-E/2 | 471-F-E205 | 170
Steel Assembly | RIGID_FRAME | 139.7 | +41.831 | +44.194 | D-E/2 | 471-F-E233 | 219.1
Steel Assembly | RIGID_FRAME | 115 | +41.206 | +42.156 | D-E/2 | 471-F-E206 | 170
Steel Assembly | RIGID_FRAME | 143.3 | +39.063 | +41.529 | D-E/2 | 471-F-E234 | 219.1
Steel Assembly | RIGID_FRAME | 139.3 | +36.295 | +38.657 | D-E/2 | 471-F-E235 | 219.1
Steel Assembly | RIGID_FRAME | 122.1 | +34.024 | +35.889 | D-E/2 | 471-E-D195 | 219.1
Steel Assembly | RIGID_FRAME | 175.9 | +35.562 | +36.620 | D-E/2 | 471-E-D35 | 190
Steel Assembly | RIGID_FRAME | 125.7 | +31.753 | +33.722 | D-E/2 | 471-E-D196 | 219.1
Steel Assembly | RIGID_FRAME | 117.1 | +33.395 | +34.352 | D-E/2 | 471-E-D159 | 170
Steel Assembly | RIGID_FRAME | 135 | +29.105 | +31.347 | D-E/2 | 471-E-D197 | 219.1
Steel Assembly | RIGID_FRAME | 175.9 | +31.022 | +32.080 | D-E/2 | 471-E-D36 | 190
Steel Assembly | RIGID_FRAME | 135.6 | +26.440 | +28.699 | D-E/2 | 471-E-D193 | 219.1
Steel Assembly | RIGID_FRAME | 116.5 | +25.811 | +26.765 | D-E/2 | 471-E-D158 | 170
2 x Steel Assembly | RIGID_FRAME | 166.5 | +63.475 | +65.869 | C-D/2 | 471-G-F361 | 219.1
2 x Steel Assembly | RIGID_FRAME | 163.9 | +55.330 | +57.639 | C-D/2 | 471-G-F360 | 219.1
Steel Assembly | RIGID_FRAME | 434.5 | +57.312 | +58.353 | C-D/2 | 471-G-F85 | 190
2 x Steel Assembly | RIGID_FRAME | 149.7 | +53.065 | +54.924 | C-D/2 | 471-G-F363 | 219.1
Steel Assembly | RIGID_FRAME | 428.5 | +52.340 | +53.390 | C-D/2 | 471-G-F86 | 190
2 x Steel Assembly | RIGID_FRAME | 208.3 | +44.615 | +48.319 | C-D/2 | 471-F-E231 | 219.1
2 x Steel Assembly | RIGID_FRAME | 215.1 | +48.725 | +52.659 | C-D/2 | 471-G-F362 | 219.1
2 x Steel Assembly | RIGID_FRAME | 253.2 | +58.045 | +63.069 | C-D/2 | 471-G-F369 | 219.1
2 x Steel Assembly | RIGID_FRAME | 217.2 | +66.275 | +70.269 | C-D/2 | 471-G-F368 | 219.1
2 x Steel Assembly | RIGID_FRAME | 165.5 | +36.295 | +38.657 | C-D/2 | 471-F-E226 | 219.1
Steel Assembly | RIGID_FRAME | 439.1 | +38.330 | +39.420 | C-D/2 | 471-F-E46 | 190
2 x Steel Assembly | RIGID_FRAME | 161.5 | +29.105 | +31.347 | C-D/2 | 471-E-D183 | 219.1
Steel Assembly | RIGID_FRAME | 439.6 | +31.020 | +32.121 | C-D/2 | 471-E-D33 | 190
Steel Assembly | RIGID_FRAME | 12.6 | +33.819 | +33.889 | D-E/2-3 | 471-E-D146 | 70
2 x Steel Assembly | RIGID_FRAME | 220.2 | +31.803 | +35.889 | C-D/2 | 471-E-D192 | 219.1
2 x Steel Assembly | RIGID_FRAME | 255.2 | +39.113 | +44.194 | C-D/2 | 471-F-E232 | 219.1
Steel Assembly | RIGID_FRAME | 15.6 | +31.548 | +31.618 | D-E/2-3 | 471-E-D145 | 70
2 x Steel Assembly | RIGID_FRAME | 215.1 | +48.725 | +52.659 | C-D/3 | 471-G-F362 | 219.1
2 x Steel Assembly | RIGID_FRAME | 124.6 | +47.386 | +48.319 | C-D/3 | 471-F-E238 | 219.1
Steel Assembly | RIGID_FRAME | 410.7 | +47.005 | +47.688 | C-D/3 | 471-F-E47 | 190
Steel Assembly | RIGID_FRAME | 135.6 | +26.440 | +28.699 | D-E/3 | 471-E-D193 | 219.1
Steel Assembly | RIGID_FRAME | 116.5 | +25.811 | +26.765 | D-E/3 | 471-E-D158 | 170
Steel Assembly | RIGID_FRAME | 174.9 | +28.374 | +29.431 | D-E/3 | 471-E-D37 | 190
Steel Assembly | RIGID_FRAME | 135 | +29.105 | +31.347 | D-E/3 | 471-E-D197 | 219.1
Steel Assembly | RIGID_FRAME | 175.9 | +31.022 | +32.080 | D-E/3 | 471-E-D36 | 190
Steel Assembly | RIGID_FRAME | 125.7 | +31.753 | +33.722 | D-E/3 | 471-E-D196 | 219.1
Steel Assembly | RIGID_FRAME | 117.1 | +33.395 | +34.352 | D-E/3 | 471-E-D159 | 170
Steel Assembly | RIGID_FRAME | 122.1 | +34.024 | +35.889 | D-E/3 | 471-E-D195 | 219.1
Steel Assembly | RIGID_FRAME | 139.3 | +36.295 | +38.657 | D-E/3 | 471-F-E235 | 219.1
Steel Assembly | RIGID_FRAME | 175.2 | +38.333 | +39.387 | D-E/3 | 471-F-E51 | 190
Steel Assembly | RIGID_FRAME | 143.3 | +39.063 | +41.529 | D-E/3 | 471-F-E234 | 219.1
Steel Assembly | RIGID_FRAME | 115 | +41.206 | +42.156 | D-E/3 | 471-F-E206 | 170
Steel Assembly | RIGID_FRAME | 139.7 | +41.831 | +44.194 | D-E/3 | 471-F-E233 | 219.1
Steel Assembly | RIGID_FRAME | 176.1 | +43.870 | +44.927 | D-E/3 | 471-F-E50 | 190
Steel Assembly | RIGID_FRAME | 131.9 | +44.600 | +46.736 | D-E/3 | 471-F-E237 | 219.1
Steel Assembly | RIGID_FRAME | 120.1 | +46.410 | +47.363 | D-E/3 | 471-F-E205 | 170
Steel Assembly | RIGID_FRAME | 102.4 | +47.038 | +48.319 | D-E/3 | 471-F-E236 | 219.1
Steel Assembly | RIGID_FRAME | 180.2 | +47.995 | +49.051 | D-E/3 | 471-F-E48 | 190
Steel Assembly | RIGID_FRAME | 132.4 | +48.725 | +50.876 | D-E/3 | 471-G-F372 | 219.1
Steel Assembly | RIGID_FRAME | 109.5 | +51.178 | +52.659 | D-E/3 | 471-G-F371 | 219.1
Steel Assembly | RIGID_FRAME | 118.8 | +50.550 | +51.505 | D-E/3 | 471-G-F313 | 170
Steel Assembly | RIGID_FRAME | 180.2 | +52.332 | +53.393 | D-E/3 | 471-G-F91 | 190
Steel Assembly | RIGID_FRAME | 122.4 | +53.065 | +54.924 | D-E/3 | 471-G-F370 | 219.1
Steel Assembly | RIGID_FRAME | 137.7 | +55.330 | +57.639 | D-E/3 | 471-G-F374 | 219.1
2 x Steel Assembly | RIGID_FRAME | 149.7 | +53.065 | +54.924 | C-D/3 | 471-G-F363 | 219.1
Steel Assembly | RIGID_FRAME | 434.5 | +52.340 | +53.390 | C-D/3 | 471-G-F83 | 190
2 x Steel Assembly | RIGID_FRAME | 253.2 | +58.045 | +63.069 | C-D/3 | 471-G-F369 | 219.1
Steel Assembly | RIGID_FRAME | 394.4 | +57.664 | +58.353 | C-D/3 | 471-G-F84 | 190
Steel Assembly | RIGID_FRAME | 141.4 | +58.045 | +60.458 | D-E/3 | 471-G-F373 | 219.1
Steel Assembly | RIGID_FRAME | 175.5 | +57.314 | +58.369 | D-E/3 | 471-G-F90 | 190
Steel Assembly | RIGID_FRAME | 137.7 | +60.760 | +63.069 | D-E/3 | 471-G-F378 | 219.1
Steel Assembly | RIGID_FRAME | 115.2 | +60.134 | +61.085 | D-E/3 | 471-G-F314 | 170
Steel Assembly | RIGID_FRAME | 175.5 | +62.744 | +63.799 | D-E/3 | 471-G-F89 | 190
Steel Assembly | RIGID_FRAME | 140.7 | +63.475 | +65.869 | D-E/3 | 471-G-F377 | 219.1
2 x Steel Assembly | RIGID_FRAME | 217.2 | +66.275 | +70.269 | C-D/3 | 471-G-F368 | 219.1
Steel Assembly | RIGID_FRAME | 123.8 | +66.275 | +68.173 | D-E/3 | 471-G-F376 | 219.1
Steel Assembly | RIGID_FRAME | 118.3 | +67.846 | +68.803 | D-E/3 | 471-G-F311 | 170
Steel Assembly | RIGID_FRAME | 120.3 | +68.475 | +70.269 | D-E/3 | 471-G-F375 | 219.1
2 x Steel Assembly | RIGID_FRAME | 255.2 | +39.113 | +44.194 | C-D/3 | 471-F-E232 | 219.1
Steel Assembly | RIGID_FRAME | 399.3 | +38.682 | +39.420 | C-D/3 | 471-F-E45 | 190
2 x Steel Assembly | RIGID_FRAME | 220.2 | +31.803 | +35.889 | C-D/3 | 471-E-D192 | 219.1
Steel Assembly | RIGID_FRAME | 399 | +31.372 | +32.121 | C-D/3 | 471-E-D34 | 190
Steel Assembly | RIGID_FRAME | 324.9 | +66.275 | +70.269 | C/2-3 | 471-G-F365 | 219.1
Steel Assembly | RIGID_FRAME | 398.6 | +65.894 | +66.600 | C/2-3 | 471-G-F50 | 315.001
Steel Assembly | RIGID_FRAME | 217 | +63.475 | +65.830 | C/2-3 | 471-G-F354 | 219.1
Steel Assembly | RIGID_FRAME | 206.7 | +63.451 | +65.893 | C/2-3 | 471-G-F394 | 254
Steel Assembly | RIGID_FRAME | 352.6 | +58.045 | +63.069 | C/2-3 | 471-G-F359 | 219.1
Steel Assembly | RIGID_FRAME | 220.7 | +55.330 | +57.613 | C/2-3 | 471-G-F353 | 219.1
Steel Assembly | RIGID_FRAME | 200 | +55.306 | +57.664 | C/2-3 | 471-G-F392 | 254
Steel Assembly | RIGID_FRAME | 265.9 | +53.065 | +54.924 | C/2-3 | 471-G-F356 | 219.1
Steel Assembly | RIGID_FRAME | 323.4 | +48.725 | +52.659 | C/2-3 | 471-G-F355 | 219.1
Steel Assembly | RIGID_FRAME | 427 | +47.995 | +49.050 | C/2-3 | 471-F-E20 | 315.056
Steel Assembly | RIGID_FRAME | 317.8 | +44.600 | +48.319 | C/2-3 | 471-F-E230 | 219.1
Steel Assembly | RIGID_FRAME | 355.6 | +39.063 | +44.194 | C/2-3 | 471-F-E228 | 219.1
Steel Assembly | RIGID_FRAME | 221.7 | +36.295 | +38.626 | C/2-3 | 471-F-E225 | 219.1
Steel Assembly | RIGID_FRAME | 204 | +36.271 | +38.681 | C/2-3 | 471-F-E248 | 254
Steel Assembly | RIGID_FRAME | 328.5 | +31.753 | +35.889 | C/2-3 | 471-E-D187 | 219.1
Steel Assembly | RIGID_FRAME | 213.7 | +29.105 | +31.320 | C/2-3 | 471-E-D184 | 219.1
Steel Assembly | RIGID_FRAME | 195 | +29.081 | +31.371 | C/2-3 | 471-E-D204 | 254
Steel Assembly | RIGID_FRAME | 334.3 | +24.343 | +28.699 | C/2-3 | 471-E-D186 | 219.1
Steel Assembly | RIGID_FRAME | 249.7 | +36.295 | +38.641 | D/2-3 | 471-F-E229 | 219.1
Steel Assembly | RIGID_FRAME | 204.1 | +36.271 | +38.681 | D/2-3 | 471-F-E247 | 254
Steel Assembly | RIGID_FRAME | 15 | +28.900 | +28.970 | D-E/2-3 | 471-E-D144 | 70
Steel Assembly | RIGID_FRAME | 249.7 | +55.330 | +57.628 | D/2-3 | 471-G-F364 | 219.1
Steel Assembly | RIGID_FRAME | 200 | +55.306 | +57.663 | D/2-3 | 471-G-F393 | 254
Steel Assembly | RIGID_FRAME | 246.1 | +29.105 | +31.331 | D/2-3 | 471-E-D189 | 219.1
Steel Assembly | RIGID_FRAME | 196.2 | +29.081 | +31.371 | D/2-3 | 471-E-D203 | 254
Steel Assembly | RIGID_FRAME | 252.5 | +63.475 | +65.862 | D/2-3 | 471-G-F366 | 219.1
Steel Assembly | RIGID_FRAME | 205.3 | +63.451 | +65.893 | D/2-3 | 471-G-F395 | 254
Steel Assembly | RIGID_FRAME | 7.8 | +26.415 | +27.520 | D/2-3 | 471-E-D150 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +26.415 | +27.520 | E/2-3 | 471-E-D149 | 70.0002
Steel Assembly | RIGID_FRAME | 57.5 | +26.215 | +26.415 | D-E/2-3 | 471-E-D46 | 280.927
Steel Assembly | RIGID_FRAME | 324.9 | +66.275 | +70.269 | D/2-3 | 471-G-F365 | 219.1
Steel Assembly | RIGID_FRAME | 352.7 | +58.045 | +63.069 | D/2-3 | 471-G-F359 | 219.1
Steel Assembly | RIGID_FRAME | 394.6 | +57.664 | +58.373 | D/2-3 | 471-G-F97 | 190
Steel Assembly | RIGID_FRAME | 265.9 | +53.065 | +54.924 | D/2-3 | 471-G-F356 | 219.1
Steel Assembly | RIGID_FRAME | 427.2 | +52.334 | +53.369 | D/2-3 | 471-G-F73 | 190
Steel Assembly | RIGID_FRAME | 323.4 | +48.725 | +52.659 | D/2-3 | 471-G-F355 | 219.1
Steel Assembly | RIGID_FRAME | 317.8 | +44.600 | +48.319 | D/2-3 | 471-F-E230 | 219.1
Steel Assembly | RIGID_FRAME | 8.2 | +26.240 | +27.520 | D-E/2-3 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +26.240 | +27.520 | D-E/2-3 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 355.6 | +39.063 | +44.194 | D/2-3 | 471-F-E228 | 219.1
Steel Assembly | RIGID_FRAME | 328.5 | +31.753 | +35.889 | D/2-3 | 471-E-D187 | 219.1
Steel Assembly | RIGID_FRAME | 12.8 | +26.235 | +26.305 | D-E/2-3 | 471-E-D143 | 70
Steel Assembly | RIGID_FRAME | 58.8 | +26.215 | +26.415 | D-E/2-3 | 471-E-D1 | 230.627
Steel Assembly | RIGID_FRAME | 324.9 | +66.275 | +70.269 | E/2-3 | 471-G-F365 | 219.1
Steel Assembly | RIGID_FRAME | 283.1 | +63.475 | +65.869 | E/2-3 | 471-G-F367 | 219.1
Steel Assembly | RIGID_FRAME | 423.4 | +65.558 | +66.600 | E/2-3 | 471-G-F59 | 190
Steel Assembly | RIGID_FRAME | 352.7 | +58.045 | +63.069 | E/2-3 | 471-G-F359 | 219.1
Steel Assembly | RIGID_FRAME | 422.1 | +57.329 | +58.373 | E/2-3 | 471-G-F74 | 190
Steel Assembly | RIGID_FRAME | 280.6 | +55.330 | +57.639 | E/2-3 | 471-G-F358 | 219.1
Steel Assembly | RIGID_FRAME | 266.5 | +53.065 | +54.924 | E/2-3 | 471-G-F357 | 219.1
Steel Assembly | RIGID_FRAME | 323.4 | +48.725 | +52.659 | E/2-3 | 471-G-F355 | 219.1
Steel Assembly | RIGID_FRAME | 427.2 | +52.334 | +53.369 | E/2-3 | 471-G-F72 | 190
Steel Assembly | RIGID_FRAME | 418.8 | +47.995 | +49.050 | E/2-3 | 471-F-E31 | 190
Steel Assembly | RIGID_FRAME | 317.8 | +44.600 | +48.319 | E/2-3 | 471-F-E230 | 219.1
Steel Assembly | RIGID_FRAME | 355.6 | +39.063 | +44.194 | E/2-3 | 471-F-E228 | 219.1
Steel Assembly | RIGID_FRAME | 282 | +36.295 | +38.657 | E/2-3 | 471-F-E227 | 219.1
Steel Assembly | RIGID_FRAME | 328.5 | +31.753 | +35.889 | E/2-3 | 471-E-D187 | 219.1
Steel Assembly | RIGID_FRAME | 278.5 | +29.105 | +31.347 | E/2-3 | 471-E-D188 | 219.1
Steel Assembly | RIGID_FRAME | 2155.9 | +25.304 | +37.770 | C/2 | 471-E-D174 | 310.6
Steel Assembly | RIGID_FRAME | 2155.9 | +25.304 | +37.770 | C/3 | 471-E-D173 | 310.6
Steel Assembly | RIGID_FRAME | 1403 | +37.271 | +50.202 | C/2 | 471-F-E63 | 304.8
Steel Assembly | RIGID_FRAME | 1393.5 | +37.271 | +50.202 | C/3 | 471-F-E64 | 304.8
Steel Assembly | RIGID_FRAME | 1121.5 | +49.703 | +59.704 | C/2 | 471-G-F117 | 304.8
Steel Assembly | RIGID_FRAME | 1121.5 | +49.703 | +59.704 | C/3 | 471-G-F118 | 304.8
Steel Assembly | RIGID_FRAME | 1121 | +59.205 | +70.650 | C/2 | 471-G-F110 | 304.8
Steel Assembly | RIGID_FRAME | 2155.9 | +25.304 | +37.770 | D/2 | 471-E-D171 | 310.6
Steel Assembly | RIGID_FRAME | 2155.9 | +25.304 | +37.770 | D/3 | 471-E-D172 | 310.6
Steel Assembly | RIGID_FRAME | 1393.5 | +37.271 | +50.202 | D/2 | 471-F-E59 | 304.8
Steel Assembly | RIGID_FRAME | 1393.5 | +37.271 | +50.202 | D/3 | 471-F-E60 | 304.8
Steel Assembly | RIGID_FRAME | 1121.5 | +49.703 | +59.704 | D/2 | 471-G-F107 | 304.8
Steel Assembly | RIGID_FRAME | 1121.5 | +49.703 | +59.704 | D/3 | 471-G-F108 | 304.8
Steel Assembly | RIGID_FRAME | 1121 | +59.205 | +70.650 | D/2 | 471-G-F114 | 304.8
Steel Assembly | RIGID_FRAME | 1121 | +59.205 | +70.650 | D/3 | 471-G-F112 | 304.8
Steel Assembly | RIGID_FRAME | 334.3 | +24.343 | +28.699 | E/2-3 | 471-E-D186 | 219.1
Steel Assembly | RIGID_FRAME | 46.8 | +70.450 | +70.650 | C-D/2-3 | 471-G-F163 | 337.894
4 x Steel Assembly | RIGID_FRAME | 16.3 | +70.463 | +70.543 | C-D/2-3 | 471-G-F248 | 80
Steel Assembly | RIGID_FRAME | 10.8 | +70.463 | +70.543 | C-D/2-3 | 471-G-F278 | 80
Steel Assembly | RIGID_FRAME | 10.8 | +70.463 | +70.543 | C-D/2-3 | 471-G-F277 | 80
Steel Assembly | RIGID_FRAME | 130.2 | +70.450 | +70.650 | C-D/2-3 | 471-G-F141 | 326.673
Steel Assembly | RIGID_FRAME | 27.9 | +70.450 | +70.650 | C-D/2-3 | 471-G-F198 | 451.115
Steel Assembly | RIGID_FRAME | 129.6 | +70.450 | +70.650 | C-D/2-3 | 471-G-F142 | 349.211
Steel Assembly | RIGID_FRAME | 28.1 | +70.450 | +70.650 | C-D/2-3 | 471-G-F201 | 433.845
Steel Assembly | RIGID_FRAME | 65.7 | +68.522 | +70.292 | D/3-4 | 471-G-F191 | 180
Steel Assembly | RIGID_FRAME | 65.7 | +68.522 | +70.292 | C/3-4 | 471-G-F191 | 180
Steel Assembly | RIGID_FRAME | 47 | +70.450 | +70.650 | C-D/2-3 | 471-G-F161 | 327.809
Steel Assembly | RIGID_FRAME | 44.3 | +70.450 | +70.650 | C-D/2-3 | 471-G-F149 | 253.347
Steel Assembly | RIGID_FRAME | 46.6 | +70.450 | +70.650 | C-D/2-3 | 471-G-F158 | 346.75
Steel Assembly | RIGID_FRAME | 28.1 | +70.450 | +70.650 | C-D/2-3 | 471-G-F170 | 455.304
Steel Assembly | RIGID_FRAME | 53.5 | +70.450 | +70.650 | C-D/3-4 | 471-G-F175 | 323.651
Steel Assembly | RIGID_FRAME | 53.7 | +70.450 | +70.650 | C-D/3-4 | 471-G-F178 | 314.192
Steel Assembly | RIGID_FRAME | 17.5 | +70.463 | +70.543 | C-D/2-3 | 471-G-F256 | 80
2 x Steel Assembly | RIGID_FRAME | 17.6 | +70.463 | +70.543 | C-D/2-3 | 471-G-F255 | 80
2 x Steel Assembly | RIGID_FRAME | 15.8 | +70.463 | +70.543 | C-D/2-3 | 471-G-F254 | 80
Steel Assembly | RIGID_FRAME | 18.6 | +70.463 | +70.543 | C-D/3-4 | 471-G-F268 | 80
2 x Steel Assembly | RIGID_FRAME | 18.3 | +70.463 | +70.543 | C-D/3-4 | 471-G-F250 | 80
3 x Steel Assembly | RIGID_FRAME | 20 | +70.463 | +70.543 | C-D/3-4 | 471-G-F251 | 80
Steel Assembly | RIGID_FRAME | 18.4 | +70.463 | +70.543 | C-D/3-4 | 471-G-F249 | 80
3 x Steel Assembly | RIGID_FRAME | 17.5 | +70.463 | +70.543 | C-D/2-3 | 471-G-F240 | 80
2 x Steel Assembly | RIGID_FRAME | 16.3 | +70.463 | +70.543 | C-D/2-3 | 471-G-F245 | 80
2 x Steel Assembly | RIGID_FRAME | 17.6 | +70.463 | +70.543 | C-D/2-3 | 471-G-F243 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +70.463 | +70.543 | C-D/2-3 | 471-G-F241 | 80
Steel Assembly | RIGID_FRAME | 17.5 | +70.463 | +70.543 | C-D/2-3 | 471-G-F246 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +70.463 | +70.543 | C-D/2-3 | 471-G-F276 | 80
Steel Assembly | RIGID_FRAME | 17.1 | +70.463 | +70.543 | C-D/2-3 | 471-G-F275 | 80
Steel Assembly | RIGID_FRAME | 46.7 | +70.450 | +70.650 | C-D/2-3 | 471-G-F157 | 346.838
Steel Assembly | RIGID_FRAME | 46.6 | +70.450 | +70.650 | C-D/2-3 | 471-G-F160 | 345.692
Steel Assembly | RIGID_FRAME | 27.9 | +70.450 | +70.650 | C-D/2-3 | 471-G-F197 | 453.536
Steel Assembly | RIGID_FRAME | 27.9 | +70.450 | +70.650 | C-D/2-3 | 471-G-F199 | 446.565
Steel Assembly | RIGID_FRAME | 30.2 | +70.350 | +70.650 | C-D/2-3 | 471-G-F169 | 455.898
3 x Steel Assembly | RIGID_FRAME | 15.8 | +48.513 | +48.593 | C-D/2-3 | 471-F-E164 | 80
Steel Assembly | RIGID_FRAME | 60.4 | +64.268 | +65.892 | B-C/2 | 471-G-F192 | 180.001
Steel Assembly | RIGID_FRAME | 145.7 | +48.344 | +48.700 | D/1-2 | 471-F-E55 | 190
Steel Assembly | RIGID_FRAME | 46.8 | +66.050 | +66.250 | C-D/2-3 | 471-G-F163 | 337.894
Steel Assembly | RIGID_FRAME | 46.8 | +66.050 | +66.250 | C-D/2-3 | 471-G-F162 | 337.894
2 x Steel Assembly | RIGID_FRAME | 16.5 | +66.063 | +66.143 | B-C/2-3 | 471-G-F228 | 80
Steel Assembly | RIGID_FRAME | 46.8 | +66.050 | +66.250 | B-C/2-3 | 471-G-F164 | 328.06
Steel Assembly | RIGID_FRAME | 16.3 | +66.063 | +66.143 | B-C/2-3 | 471-G-F229 | 80
Steel Assembly | RIGID_FRAME | 10.5 | +66.063 | +66.143 | B-C/2-3 | 471-G-F231 | 80
Steel Assembly | RIGID_FRAME | 34.6 | +66.050 | +66.250 | B-C/2-3 | 471-G-F194 | 298.584
Steel Assembly | RIGID_FRAME | 5 | +66.063 | +66.143 | B-C/2-3 | 471-G-F279 | 80
Steel Assembly | RIGID_FRAME | 53.5 | +66.050 | +66.250 | B-C/2-3 | 471-G-F122 | 327.646
Steel Assembly | RIGID_FRAME | 20.9 | +66.050 | +66.250 | B-C/2-3 | 471-G-F196 | 239.969
Steel Assembly | RIGID_FRAME | 18 | +66.063 | +66.143 | B-C/2-3 | 471-G-F232 | 80
Steel Assembly | RIGID_FRAME | 49 | +66.050 | +66.250 | B-C/2-3 | 471-G-F195 | 330.275
Steel Assembly | RIGID_FRAME | 17.3 | +66.063 | +66.143 | B-C/2-3 | 471-G-F227 | 80
Steel Assembly | RIGID_FRAME | 57.1 | +66.050 | +66.250 | B-C/2-3 | 471-G-F120 | 445.571
Steel Assembly | RIGID_FRAME | 17.1 | +66.063 | +66.143 | B-C/2-3 | 471-G-F230 | 80
Steel Assembly | RIGID_FRAME | 49 | +66.050 | +66.250 | B-C/2-3 | 471-G-F119 | 160
Steel Assembly | RIGID_FRAME | 28.1 | +66.050 | +66.250 | C-D/2-3 | 471-G-F172 | 455.898
Steel Assembly | RIGID_FRAME | 28.1 | +66.050 | +66.250 | C-D/2-3 | 471-G-F171 | 450.745
Steel Assembly | RIGID_FRAME | 145.7 | +48.344 | +48.700 | C/1-2 | 471-F-E56 | 190
4 x Steel Assembly | RIGID_FRAME | 16.3 | +66.063 | +66.143 | C-D/2-3 | 471-G-F248 | 80
Steel Assembly | RIGID_FRAME | 27.9 | +66.050 | +66.250 | C-D/2-3 | 471-G-F198 | 451.115
Steel Assembly | RIGID_FRAME | 10.8 | +66.063 | +66.143 | C-D/2-3 | 471-G-F278 | 80
Steel Assembly | RIGID_FRAME | 10.8 | +66.063 | +66.143 | C-D/2-3 | 471-G-F277 | 80
Steel Assembly | RIGID_FRAME | 28.1 | +66.050 | +66.250 | C-D/2-3 | 471-G-F201 | 433.845
Steel Assembly | RIGID_FRAME | 28.1 | +66.050 | +66.250 | C-D/2-3 | 471-G-F173 | 450.448
Steel Assembly | RIGID_FRAME | 46.6 | +66.050 | +66.250 | C-D/2-3 | 471-G-F159 | 346.75
Steel Assembly | RIGID_FRAME | 46.6 | +66.050 | +66.250 | C-D/2-3 | 471-G-F158 | 346.75
Steel Assembly | RIGID_FRAME | 17.5 | +66.063 | +66.143 | C-D/2-3 | 471-G-F256 | 80
2 x Steel Assembly | RIGID_FRAME | 17.6 | +66.063 | +66.143 | C-D/2-3 | 471-G-F255 | 80
2 x Steel Assembly | RIGID_FRAME | 15.8 | +66.063 | +66.143 | C-D/2-3 | 471-G-F254 | 80
4 x Steel Assembly | RIGID_FRAME | 17.5 | +66.063 | +66.143 | C-D/2-3 | 471-G-F240 | 80
2 x Steel Assembly | RIGID_FRAME | 16.3 | +66.063 | +66.143 | C-D/2-3 | 471-G-F245 | 80
2 x Steel Assembly | RIGID_FRAME | 17.6 | +66.063 | +66.143 | C-D/2-3 | 471-G-F243 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +66.063 | +66.143 | C-D/2-3 | 471-G-F241 | 80
Steel Assembly | RIGID_FRAME | 17.5 | +66.063 | +66.143 | C-D/2-3 | 471-G-F246 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +66.063 | +66.143 | C-D/2-3 | 471-G-F276 | 80
Steel Assembly | RIGID_FRAME | 17.1 | +66.063 | +66.143 | C-D/2-3 | 471-G-F275 | 80
Steel Assembly | RIGID_FRAME | 27.9 | +66.050 | +66.250 | C-D/2-3 | 471-G-F197 | 453.536
Steel Assembly | RIGID_FRAME | 27.9 | +66.050 | +66.250 | C-D/2-3 | 471-G-F199 | 446.565
Steel Assembly | RIGID_FRAME | 1144.8 | +59.205 | +70.650 | E/2 | 471-G-F115 | 304.8
Steel Assembly | RIGID_FRAME | 1144.8 | +59.205 | +70.650 | E/3 | 471-G-F111 | 304.8
Steel Assembly | RIGID_FRAME | 1133.5 | +49.703 | +59.704 | E/2 | 471-G-F113 | 304.8
Steel Assembly | RIGID_FRAME | 1133.5 | +49.703 | +59.704 | E/3 | 471-G-F116 | 304.8
Steel Assembly | RIGID_FRAME | 2179.8 | +25.304 | +37.770 | E/2 | 471-E-D175 | 310.6
Steel Assembly | RIGID_FRAME | 2179.8 | +25.304 | +37.770 | E/3 | 471-E-D176 | 310.6
Steel Assembly | RIGID_FRAME | 1417.4 | +37.271 | +50.202 | E/2 | 471-F-E61 | 304.8
Steel Assembly | RIGID_FRAME | 1417.4 | +37.271 | +50.202 | E/3 | 471-F-E62 | 304.8
Steel Assembly | RIGID_FRAME | 65.7 | +61.322 | +63.092 | D/3-4 | 471-G-F191 | 180
Steel Assembly | RIGID_FRAME | 65.7 | +61.322 | +63.092 | C/3-4 | 471-G-F191 | 180
2 x Steel Assembly | RIGID_FRAME | 16.3 | +55.118 | +55.198 | C-D/2-3 | 471-G-F248 | 80
2 x Steel Assembly | RIGID_FRAME | 14.8 | +55.118 | +55.198 | C-D/2-3 | 471-G-F253 | 80
Steel Assembly | RIGID_FRAME | 46.8 | +55.105 | +55.305 | C-D/2-3 | 471-G-F162 | 337.894
Steel Assembly | RIGID_FRAME | 46.7 | +55.105 | +55.305 | C-D/2-3 | 471-G-F129 | 341.29
Steel Assembly | RIGID_FRAME | 28.6 | +55.102 | +55.305 | C-D/2-3 | 471-G-F399 | 302.748
Steel Assembly | RIGID_FRAME | 28.3 | +55.102 | +55.305 | C-D/2-3 | 471-G-F396 | 302.745
2 x Steel Assembly | RIGID_FRAME | 14.6 | +55.118 | +55.198 | C-D/2-3 | 471-G-F242 | 80
Steel Assembly | RIGID_FRAME | 32.7 | +55.005 | +55.305 | C-D/2-3 | 471-G-F400 | 450.441
Steel Assembly | RIGID_FRAME | 30.4 | +55.102 | +55.305 | C-D/2-3 | 471-G-F397 | 450.517
Steel Assembly | RIGID_FRAME | 28.6 | +55.102 | +55.305 | C-D/2-3 | 471-G-F401 | 302.703
Steel Assembly | RIGID_FRAME | 28.4 | +55.102 | +55.305 | C-D/2-3 | 471-G-F398 | 302.699
Steel Assembly | RIGID_FRAME | 17.6 | +55.118 | +55.198 | C-D/2-3 | 471-G-F243 | 80
Steel Assembly | RIGID_FRAME | 17 | +55.118 | +55.198 | C-D/2-3 | 471-G-F244 | 80
Steel Assembly | RIGID_FRAME | 10.8 | +70.463 | +70.543 | B-C/2-3 | 471-G-F238 | 80
Steel Assembly | RIGID_FRAME | 34 | +70.450 | +70.650 | B-C/2 | 471-G-F125 | 353.278
Steel Assembly | RIGID_FRAME | 34.7 | +70.450 | +70.650 | B-C/2-3 | 471-G-F209 | 359.08
Steel Assembly | RIGID_FRAME | 11.9 | +70.463 | +70.543 | B-C/2-3 | 471-G-F239 | 80
Steel Assembly | RIGID_FRAME | 32.6 | +70.450 | +70.650 | B-C/2-3 | 471-G-F208 | 257.196
Steel Assembly | RIGID_FRAME | 36.2 | +70.350 | +70.650 | B-C/2-3 | 471-G-F206 | 251.849
Steel Assembly | RIGID_FRAME | 32.7 | +55.105 | +55.305 | B-C/2-3 | 471-G-F207 | 253.691
Steel Assembly | RIGID_FRAME | 36.2 | +55.005 | +55.305 | B-C/2-3 | 471-G-F206 | 251.849
Steel Assembly | RIGID_FRAME | 28.1 | +55.105 | +55.305 | C-D/2-3 | 471-G-F173 | 450.448
Steel Assembly | RIGID_FRAME | 65.7 | +53.177 | +54.947 | D/3-4 | 471-G-F191 | 180
Steel Assembly | RIGID_FRAME | 65.7 | +53.177 | +54.947 | C/3-4 | 471-G-F191 | 180
Steel Assembly | RIGID_FRAME | 46.6 | +55.105 | +55.305 | C-D/2-3 | 471-G-F158 | 346.75
Steel Assembly | RIGID_FRAME | 28.1 | +55.105 | +55.305 | C-D/2-3 | 471-G-F170 | 455.304
Steel Assembly | RIGID_FRAME | 17.5 | +55.118 | +55.198 | C-D/2-3 | 471-G-F256 | 80
2 x Steel Assembly | RIGID_FRAME | 17.6 | +55.118 | +55.198 | C-D/2-3 | 471-G-F255 | 80
Steel Assembly | RIGID_FRAME | 15.8 | +55.118 | +55.198 | C-D/2-3 | 471-G-F254 | 80
2 x Steel Assembly | RIGID_FRAME | 18.3 | +55.118 | +55.198 | C-D/3-4 | 471-G-F250 | 80
3 x Steel Assembly | RIGID_FRAME | 20 | +55.118 | +55.198 | C-D/3-4 | 471-G-F251 | 80
Steel Assembly | RIGID_FRAME | 18.4 | +55.118 | +55.198 | C-D/3-4 | 471-G-F249 | 80
4 x Steel Assembly | RIGID_FRAME | 17.5 | +55.118 | +55.198 | C-D/2-3 | 471-G-F240 | 80
3 x Steel Assembly | RIGID_FRAME | 16.3 | +55.118 | +55.198 | C-D/2-3 | 471-G-F245 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +55.118 | +55.198 | C-D/2-3 | 471-G-F241 | 80
Steel Assembly | RIGID_FRAME | 17.1 | +55.118 | +55.198 | C-D/2-3 | 471-G-F247 | 80
Steel Assembly | RIGID_FRAME | 17.5 | +55.118 | +55.198 | C-D/2-3 | 471-G-F246 | 80
Steel Assembly | RIGID_FRAME | 46.7 | +55.105 | +55.305 | C-D/2-3 | 471-G-F157 | 346.838
Steel Assembly | RIGID_FRAME | 46.6 | +55.105 | +55.305 | C-D/2-3 | 471-G-F160 | 345.692
Steel Assembly | RIGID_FRAME | 28.1 | +55.105 | +55.305 | C-D/2-3 | 471-G-F202 | 465.643
Steel Assembly | RIGID_FRAME | 27.9 | +55.105 | +55.305 | C-D/2-3 | 471-G-F199 | 446.565
Steel Assembly | RIGID_FRAME | 26 | +55.105 | +55.305 | C-D/2-3 | 471-G-F200 | 299.304
Steel Assembly | RIGID_FRAME | 130.2 | +55.105 | +55.305 | C-D/2-3 | 471-G-F143 | 326.494
Steel Assembly | RIGID_FRAME | 81.6 | +46.067 | +48.344 | C/1-2 | 471-F-E88 | 180
Steel Assembly | RIGID_FRAME | 81.6 | +46.067 | +48.344 | D/1-2 | 471-F-E88 | 180
Steel Assembly | RIGID_FRAME | 175.2 | +44.375 | +44.575 | C-D/2-3 | 471-F-E73 | 450.745
Steel Assembly | RIGID_FRAME | 36.2 | +44.275 | +44.575 | B-C/2-3 | 471-F-E78 | 251.849
Steel Assembly | RIGID_FRAME | 254.2 | +45.211 | +48.342 | B-C/2 | 471-F-E21 | 190
Steel Assembly | RIGID_FRAME | 36 | +38.738 | +39.038 | B-C/2-3 | 471-F-E79 | 259.583
Steel Assembly | RIGID_FRAME | 28.4 | +36.067 | +36.270 | C-D/2-3 | 471-E-D210 | 372.068
Steel Assembly | RIGID_FRAME | 36.2 | +35.970 | +36.270 | B-C/2-3 | 471-E-D91 | 251.849
Steel Assembly | RIGID_FRAME | 36.9 | +44.375 | +44.575 | B-C/2-3 | 471-F-E14 | 360.317
Steel Assembly | RIGID_FRAME | 35.8 | +44.375 | +44.575 | B-C/2 | 471-F-E82 | 354.726
Steel Assembly | RIGID_FRAME | 36.9 | +43.442 | +44.373 | B-C/2 | 471-F-E87 | 160
Steel Assembly | RIGID_FRAME | 34.9 | +44.375 | +44.575 | B-C/2-3 | 471-F-E12 | 256.549
Steel Assembly | RIGID_FRAME | 11.1 | +44.388 | +44.468 | B-C/2-3 | 471-F-E175 | 80
Steel Assembly | RIGID_FRAME | 11.4 | +44.388 | +44.468 | B-C/2-3 | 471-F-E174 | 80
Steel Assembly | RIGID_FRAME | 196.2 | +44.575 | +50.263 | C/2 | 471-0-010022 | 780.01
Steel Assembly | RIGID_FRAME | 10.8 | +44.388 | +44.468 | B-C/2-3 | 471-F-E173 | 80
Steel Assembly | RIGID_FRAME | 11.9 | +44.489 | +44.575 | B-C/2 | 471-F-E148 | 160
Steel Assembly | RIGID_FRAME | 32.7 | +44.375 | +44.575 | B-C/2-3 | 471-F-E81 | 253.691
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | B-C/2 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.705 | B-C/2-3 | 471-F-E190 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.705 | B-C/2-3 | 471-F-E189 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | C/2 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | B-C/2 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 36.9 | +69.517 | +70.448 | B-C/2 | 471-G-F190 | 160
Steel Assembly | RIGID_FRAME | 34.9 | +70.450 | +70.650 | B-C/2-3 | 471-G-F37 | 256.549
Steel Assembly | RIGID_FRAME | 92.1 | +70.450 | +70.650 | B-C/2-3 | 471-G-F28 | 159.994
Steel Assembly | RIGID_FRAME | 10.8 | +70.463 | +70.543 | B-C/2-3 | 471-G-F235 | 80
2 x Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.755 | B-C/2 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +70.475 | +71.780 | B-C/2-3 | 471-G-F286 | 70
Steel Assembly | RIGID_FRAME | 36.9 | +55.105 | +55.305 | B-C/2-3 | 471-G-F27 | 360.317
Steel Assembly | RIGID_FRAME | 35.1 | +55.105 | +55.305 | B-C/2 | 471-G-F124 | 319.726
Steel Assembly | RIGID_FRAME | 36.9 | +54.172 | +55.103 | B-C/2 | 471-G-F190 | 160
Steel Assembly | RIGID_FRAME | 93.6 | +55.105 | +55.305 | B-C/2-3 | 471-G-F24 | 159.994
Steel Assembly | RIGID_FRAME | 11.1 | +55.118 | +55.198 | B-C/2-3 | 471-G-F237 | 80
Steel Assembly | RIGID_FRAME | 11.4 | +55.118 | +55.198 | B-C/2-3 | 471-G-F236 | 80
Steel Assembly | RIGID_FRAME | 330.3 | +55.305 | +65.028 | C/2 | 471-0-010018 | 780.01
Steel Assembly | RIGID_FRAME | 10.8 | +55.118 | +55.198 | B-C/2-3 | 471-G-F235 | 80
Steel Assembly | RIGID_FRAME | 11.9 | +55.219 | +55.305 | B-C/2 | 471-G-F225 | 160
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | B-C/2 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.435 | B-C/2-3 | 471-G-F286 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.435 | B-C/2-3 | 471-G-F287 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | C/2 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | B-C/2 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 30.1 | +63.250 | +63.450 | B-C/2 | 471-G-F126 | 190
Steel Assembly | RIGID_FRAME | 36.9 | +62.317 | +63.248 | B-C/2 | 471-G-F190 | 160
Steel Assembly | RIGID_FRAME | 11.9 | +63.364 | +63.450 | B-C/2-3 | 471-G-F225 | 160
Steel Assembly | RIGID_FRAME | 12.2 | +63.263 | +63.343 | B-C/2-3 | 471-G-F234 | 80
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.580 | B-C/2-3 | 471-G-F286 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.580 | B-C/2-3 | 471-G-F287 | 70
Steel Assembly | RIGID_FRAME | 30.1 | +38.838 | +39.038 | B-C/2 | 471-F-E83 | 190
Steel Assembly | RIGID_FRAME | 36.9 | +37.905 | +38.836 | B-C/2 | 471-F-E87 | 160
Steel Assembly | RIGID_FRAME | 239.3 | +39.038 | +46.143 | C/2-3 | 471-0-010020 | 780.01
Steel Assembly | RIGID_FRAME | 12.2 | +38.851 | +38.931 | B-C/2-3 | 471-F-E171 | 80
Steel Assembly | RIGID_FRAME | 12.2 | +38.851 | +38.931 | B-C/2-3 | 471-F-E170 | 80
Steel Assembly | RIGID_FRAME | 11.9 | +38.952 | +39.038 | B-C/2-3 | 471-F-E148 | 160
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.168 | B-C/2-3 | 471-F-E190 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.168 | B-C/2-3 | 471-F-E189 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | C/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | B-C/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 308.3 | +63.450 | +72.273 | C/2-3 | 471-0-010014 | 780.01
Steel Assembly | RIGID_FRAME | 36 | +28.780 | +29.080 | B-C/2-3 | 471-E-D90 | 259.583
Steel Assembly | RIGID_FRAME | 6.2 | +48.614 | +48.700 | B-C/2-3 | 471-F-E147 | 160
Steel Assembly | RIGID_FRAME | 6.2 | +48.614 | +48.700 | B-C/2-3 | 471-F-E146 | 160
Steel Assembly | RIGID_FRAME | 34.9 | +48.500 | +48.700 | B-C/2-3 | 471-F-E110 | 160
Steel Assembly | RIGID_FRAME | 175.2 | +48.500 | +48.700 | C-D/2-3 | 471-F-E73 | 450.745
Steel Assembly | RIGID_FRAME | 28.1 | +48.500 | +48.700 | C-D/2-3 | 471-F-E115 | 455.898
Steel Assembly | RIGID_FRAME | 28.3 | +48.500 | +48.700 | C-D/2-3 | 471-F-E118 | 470.971
Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | C/2-3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | C/2 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.830 | B-C/2-3 | 471-F-E189 | 70
Steel Assembly | RIGID_FRAME | 28.1 | +48.500 | +48.700 | C-D/2-3 | 471-F-E117 | 450.448
Steel Assembly | RIGID_FRAME | 46.6 | +48.500 | +48.700 | C-D/2-3 | 471-F-E125 | 346.75
2 x Steel Assembly | RIGID_FRAME | 16.3 | +48.513 | +48.593 | C-D/2-3 | 471-F-E158 | 80
Steel Assembly | RIGID_FRAME | 17.5 | +48.513 | +48.593 | C-D/2-3 | 471-F-E166 | 80
2 x Steel Assembly | RIGID_FRAME | 17.6 | +48.513 | +48.593 | C-D/2-3 | 471-F-E165 | 80
4 x Steel Assembly | RIGID_FRAME | 17.5 | +48.513 | +48.593 | C-D/2-3 | 471-F-E150 | 80
2 x Steel Assembly | RIGID_FRAME | 16.3 | +48.513 | +48.593 | C-D/2-3 | 471-F-E155 | 80
2 x Steel Assembly | RIGID_FRAME | 17.6 | +48.513 | +48.593 | C-D/2-3 | 471-F-E152 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +48.513 | +48.593 | C-D/2-3 | 471-F-E151 | 80
4 x Steel Assembly | RIGID_FRAME | 40.1 | +48.500 | +48.700 | C-D/2-3 | 471-F-E222 | 135.765
Steel Assembly | RIGID_FRAME | 17.1 | +48.513 | +48.593 | C-D/2-3 | 471-F-E157 | 80
Steel Assembly | RIGID_FRAME | 17.5 | +48.513 | +48.593 | C-D/2-3 | 471-F-E156 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +48.513 | +48.593 | C-D/2-3 | 471-F-E154 | 80
Steel Assembly | RIGID_FRAME | 17.1 | +48.513 | +48.593 | C-D/2-3 | 471-F-E153 | 80
Steel Assembly | RIGID_FRAME | 46.7 | +48.500 | +48.700 | C-D/2-3 | 471-F-E127 | 346.838
Steel Assembly | RIGID_FRAME | 46.6 | +48.500 | +48.700 | C-D/2-3 | 471-F-E124 | 345.692
Steel Assembly | RIGID_FRAME | 27.9 | +48.500 | +48.700 | C-D/2-3 | 471-F-E103 | 453.536
Steel Assembly | RIGID_FRAME | 88.4 | +48.500 | +48.700 | C-D/2-3 | 471-F-E74 | 292.047
Steel Assembly | RIGID_FRAME | 28.1 | +48.500 | +48.700 | C-D/2-3 | 471-F-E104 | 465.643
Steel Assembly | RIGID_FRAME | 27.9 | +48.500 | +48.700 | C-D/2-3 | 471-F-E102 | 446.565
Steel Assembly | RIGID_FRAME | 46.8 | +48.500 | +48.700 | C-D/2-3 | 471-F-E128 | 337.894
Steel Assembly | RIGID_FRAME | 46.8 | +48.500 | +48.700 | C-D/2-3 | 471-F-E126 | 337.894
Steel Assembly | RIGID_FRAME | 130.2 | +48.500 | +48.700 | C-D/2-3 | 471-F-E96 | 326.494
3 x Steel Assembly | RIGID_FRAME | 16.3 | +44.388 | +44.468 | C-D/2-3 | 471-F-E158 | 80
Steel Assembly | RIGID_FRAME | 127.7 | +44.375 | +44.575 | C-D/2-3 | 471-F-E97 | 324.291
Steel Assembly | RIGID_FRAME | 17.5 | +44.388 | +44.468 | C-D/2-3 | 471-F-E166 | 80
Steel Assembly | RIGID_FRAME | 46.6 | +44.375 | +44.575 | C-D/2-3 | 471-F-E125 | 346.75
Steel Assembly | RIGID_FRAME | 44.3 | +44.375 | +44.575 | C-D/2-3 | 471-F-E68 | 253.347
Steel Assembly | RIGID_FRAME | 65.7 | +42.447 | +44.217 | D/3-4 | 471-F-E86 | 180
Steel Assembly | RIGID_FRAME | 65.7 | +42.447 | +44.217 | C/3-4 | 471-F-E86 | 180
Steel Assembly | RIGID_FRAME | 46.8 | +44.375 | +44.575 | C-D/2-3 | 471-F-E126 | 337.894
Steel Assembly | RIGID_FRAME | 28.1 | +44.375 | +44.575 | C-D/2-3 | 471-F-E116 | 455.304
Steel Assembly | RIGID_FRAME | 53.7 | +44.375 | +44.575 | C-D/3-4 | 471-F-E71 | 314.192
2 x Steel Assembly | RIGID_FRAME | 17.6 | +44.388 | +44.468 | C-D/2-3 | 471-F-E165 | 80
2 x Steel Assembly | RIGID_FRAME | 15.8 | +44.388 | +44.468 | C-D/2-3 | 471-F-E164 | 80
Steel Assembly | RIGID_FRAME | 18.6 | +44.388 | +44.468 | C-D/3-4 | 471-F-E163 | 80
2 x Steel Assembly | RIGID_FRAME | 18.3 | +44.388 | +44.468 | C-D/3-4 | 471-F-E161 | 80
3 x Steel Assembly | RIGID_FRAME | 20 | +44.388 | +44.468 | C-D/3-4 | 471-F-E162 | 80
Steel Assembly | RIGID_FRAME | 18.4 | +44.388 | +44.468 | C-D/3-4 | 471-F-E160 | 80
3 x Steel Assembly | RIGID_FRAME | 17.5 | +44.388 | +44.468 | C-D/2-3 | 471-F-E150 | 80
3 x Steel Assembly | RIGID_FRAME | 16.3 | +44.388 | +44.468 | C-D/2-3 | 471-F-E155 | 80
2 x Steel Assembly | RIGID_FRAME | 17.6 | +44.388 | +44.468 | C-D/2-3 | 471-F-E152 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +44.388 | +44.468 | C-D/2-3 | 471-F-E151 | 80
4 x Steel Assembly | RIGID_FRAME | 40.1 | +44.375 | +44.575 | C-D/2-3 | 471-F-E222 | 135.765
Steel Assembly | RIGID_FRAME | 17.1 | +44.388 | +44.468 | C-D/2-3 | 471-F-E157 | 80
Steel Assembly | RIGID_FRAME | 17.5 | +44.388 | +44.468 | C-D/2-3 | 471-F-E156 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +44.388 | +44.468 | C-D/2-3 | 471-F-E154 | 80
Steel Assembly | RIGID_FRAME | 17.1 | +44.388 | +44.468 | C-D/2-3 | 471-F-E153 | 80
Steel Assembly | RIGID_FRAME | 46.7 | +44.375 | +44.575 | C-D/2-3 | 471-F-E127 | 346.838
Steel Assembly | RIGID_FRAME | 46.6 | +44.375 | +44.575 | C-D/2-3 | 471-F-E124 | 345.692
Steel Assembly | RIGID_FRAME | 27.9 | +44.375 | +44.575 | C-D/2-3 | 471-F-E103 | 453.536
Steel Assembly | RIGID_FRAME | 88.4 | +44.375 | +44.575 | C-D/2-3 | 471-F-E74 | 292.047
Steel Assembly | RIGID_FRAME | 28.1 | +44.375 | +44.575 | C-D/2-3 | 471-F-E104 | 465.643
Steel Assembly | RIGID_FRAME | 27.9 | +44.375 | +44.575 | C-D/2-3 | 471-F-E102 | 446.565
Steel Assembly | RIGID_FRAME | 133.8 | +44.375 | +44.575 | C-D/2-3 | 471-F-E95 | 336.58
Steel Assembly | RIGID_FRAME | 27.9 | +44.375 | +44.575 | C-D/2-3 | 471-F-E101 | 447.622
Steel Assembly | RIGID_FRAME | 30.2 | +44.275 | +44.575 | C-D/2-3 | 471-F-E114 | 455.898
Steel Assembly | RIGID_FRAME | 129.1 | +44.375 | +44.575 | C-D/2-3 | 471-F-E94 | 160
Steel Assembly | RIGID_FRAME | 130.2 | +44.375 | +44.575 | C-D/2-3 | 471-F-E96 | 326.494
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.380 | B-C/2-3 | 471-G-F286 | 70
2 x Steel Assembly | RIGID_FRAME | 16.3 | +36.083 | +36.163 | C-D/2-3 | 471-E-D116 | 80
2 x Steel Assembly | RIGID_FRAME | 14.6 | +36.083 | +36.163 | C-D/2-3 | 471-E-D132 | 80
Steel Assembly | RIGID_FRAME | 28.6 | +36.067 | +36.270 | C-D/2-3 | 471-E-D207 | 302.703
Steel Assembly | RIGID_FRAME | 9.7 | +36.083 | +36.163 | C-D/2-3 | 471-E-D135 | 80
Steel Assembly | RIGID_FRAME | 9.9 | +36.083 | +36.163 | C-D/2-3 | 471-E-D134 | 80
Steel Assembly | RIGID_FRAME | 30.2 | +36.067 | +36.270 | C-D/2-3 | 471-E-D209 | 370.854
2 x Steel Assembly | RIGID_FRAME | 11.4 | +36.083 | +36.163 | C-D/2-3 | 471-E-D133 | 80
Steel Assembly | RIGID_FRAME | 30.2 | +35.970 | +36.270 | C-D/2-3 | 471-E-D77 | 411.249
Steel Assembly | RIGID_FRAME | 27.9 | +36.070 | +36.270 | C-D/2-3 | 471-E-D66 | 411.227
Steel Assembly | RIGID_FRAME | 28.4 | +36.067 | +36.270 | C-D/2-3 | 471-E-D208 | 302.699
Steel Assembly | RIGID_FRAME | 34.7 | +36.070 | +36.270 | B-C/2 | 471-E-D94 | 319.726
Steel Assembly | RIGID_FRAME | 36.6 | +35.147 | +36.068 | B-C/2 | 471-E-D95 | 160
Steel Assembly | RIGID_FRAME | 93.6 | +36.070 | +36.270 | B-C/2-3 | 471-E-D9 | 159.994
Steel Assembly | RIGID_FRAME | 11.1 | +36.083 | +36.163 | B-C/2-3 | 471-E-D138 | 80
Steel Assembly | RIGID_FRAME | 11.4 | +36.083 | +36.163 | B-C/2-3 | 471-E-D137 | 80
Steel Assembly | RIGID_FRAME | 150.2 | +36.270 | +40.631 | C/2 | 471-0-010021 | 780.01
Steel Assembly | RIGID_FRAME | 10.8 | +36.083 | +36.163 | B-C/2-3 | 471-E-D136 | 80
Steel Assembly | RIGID_FRAME | 11.9 | +36.184 | +36.270 | B-C/2 | 471-E-D107 | 160
Steel Assembly | RIGID_FRAME | 36.9 | +36.070 | +36.270 | B-C/2-3 | 471-E-D12 | 360.317
Steel Assembly | RIGID_FRAME | 34.9 | +36.070 | +36.270 | B-C/2-3 | 471-E-D11 | 256.549
Steel Assembly | RIGID_FRAME | 32.7 | +36.070 | +36.270 | B-C/2-3 | 471-E-D92 | 253.691
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | B-C/2 | 471-E-D153 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.400 | B-C/2-3 | 471-E-D140 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.400 | B-C/2-3 | 471-E-D139 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | C/2 | 471-E-D152 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +36.095 | +37.375 | B-C/2 | 471-E-D152 | 70
2 x Steel Assembly | RIGID_FRAME | 16.5 | +36.083 | +36.163 | C-D/2-3 | 471-E-D131 | 80
Steel Assembly | RIGID_FRAME | 26 | +36.070 | +36.270 | C-D/2-3 | 471-E-D81 | 298.796
Steel Assembly | RIGID_FRAME | 25.8 | +36.070 | +36.270 | C-D/2-3 | 471-E-D65 | 298.796
Steel Assembly | RIGID_FRAME | 28.1 | +36.070 | +36.270 | C-D/2-3 | 471-E-D80 | 450.448
Steel Assembly | RIGID_FRAME | 65.7 | +34.142 | +35.912 | D/3-4 | 471-E-D96 | 180
Steel Assembly | RIGID_FRAME | 65.7 | +34.142 | +35.912 | C/3-4 | 471-E-D96 | 180
Steel Assembly | RIGID_FRAME | 46.8 | +36.070 | +36.270 | C-D/2-3 | 471-E-D72 | 337.894
Steel Assembly | RIGID_FRAME | 45 | +36.070 | +36.270 | C-D/2-3 | 471-E-D58 | 224.624
Steel Assembly | RIGID_FRAME | 47.3 | +36.070 | +36.270 | C-D/2-3 | 471-E-D74 | 318.027
Steel Assembly | RIGID_FRAME | 28.1 | +36.070 | +36.270 | C-D/2-3 | 471-E-D79 | 455.304
Steel Assembly | RIGID_FRAME | 53.7 | +36.070 | +36.270 | C-D/3-4 | 471-E-D88 | 314.192
2 x Steel Assembly | RIGID_FRAME | 17.6 | +36.083 | +36.163 | C-D/2-3 | 471-E-D130 | 80
2 x Steel Assembly | RIGID_FRAME | 15.8 | +36.083 | +36.163 | C-D/2-3 | 471-E-D126 | 80
2 x Steel Assembly | RIGID_FRAME | 14.6 | +36.083 | +36.163 | C-D/2-3 | 471-E-D121 | 80
Steel Assembly | RIGID_FRAME | 18.6 | +36.083 | +36.163 | C-D/3-4 | 471-E-D125 | 80
2 x Steel Assembly | RIGID_FRAME | 18.3 | +36.083 | +36.163 | C-D/3-4 | 471-E-D123 | 80
3 x Steel Assembly | RIGID_FRAME | 20 | +36.083 | +36.163 | C-D/3-4 | 471-E-D124 | 80
Steel Assembly | RIGID_FRAME | 18.4 | +36.083 | +36.163 | C-D/3-4 | 471-E-D122 | 80
3 x Steel Assembly | RIGID_FRAME | 17.5 | +36.083 | +36.163 | C-D/2-3 | 471-E-D111 | 80
Steel Assembly | RIGID_FRAME | 16.3 | +36.083 | +36.163 | C-D/2-3 | 471-E-D120 | 80
Steel Assembly | RIGID_FRAME | 16.3 | +36.083 | +36.163 | C-D/2-3 | 471-E-D128 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +36.083 | +36.163 | C-D/2-3 | 471-E-D112 | 80
4 x Steel Assembly | RIGID_FRAME | 40.1 | +36.070 | +36.270 | C-D/2-3 | 471-E-D167 | 135.765
Steel Assembly | RIGID_FRAME | 17.1 | +36.083 | +36.163 | C-D/2-3 | 471-E-D118 | 80
Steel Assembly | RIGID_FRAME | 17.5 | +36.083 | +36.163 | C-D/2-3 | 471-E-D117 | 80
Steel Assembly | RIGID_FRAME | 46.7 | +36.070 | +36.270 | C-D/2-3 | 471-E-D73 | 346.838
Steel Assembly | RIGID_FRAME | 46.6 | +36.070 | +36.270 | C-D/2-3 | 471-E-D71 | 345.692
Steel Assembly | RIGID_FRAME | 88.4 | +36.070 | +36.270 | C-D/2-3 | 471-E-D60 | 292.047
Steel Assembly | RIGID_FRAME | 28.1 | +36.070 | +36.270 | C-D/2-3 | 471-E-D64 | 465.643
Steel Assembly | RIGID_FRAME | 27.9 | +36.070 | +36.270 | C-D/2-3 | 471-E-D61 | 446.565
Steel Assembly | RIGID_FRAME | 131.3 | +36.070 | +36.270 | C-D/2-3 | 471-E-D56 | 253.403
Steel Assembly | RIGID_FRAME | 129.1 | +36.070 | +36.270 | C-D/2-3 | 471-E-D52 | 160
Steel Assembly | RIGID_FRAME | 130.2 | +36.070 | +36.270 | C-D/2-3 | 471-E-D54 | 326.494
Steel Assembly | RIGID_FRAME | 309.6 | +21.460 | +30.723 | C/2 | 471-0-010016 | 780.01
Steel Assembly | RIGID_FRAME | 12.2 | +28.893 | +28.973 | B-C/2-3 | 471-E-D109 | 80
Steel Assembly | RIGID_FRAME | 12.2 | +28.893 | +28.973 | B-C/2-3 | 471-E-D108 | 80
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.210 | B-C/2-3 | 471-E-D140 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +28.905 | +30.210 | B-C/2-3 | 471-E-D139 | 70
Steel Assembly | RIGID_FRAME | 65.7 | +26.952 | +28.722 | D/3-4 | 471-E-D96 | 180
Steel Assembly | RIGID_FRAME | 65.7 | +26.952 | +28.722 | C/3-4 | 471-E-D96 | 180
4 x Steel Assembly | RIGID_FRAME | 40.1 | +28.880 | +29.080 | C-D/2-3 | 471-E-D167 | 135.765
2 x Steel Assembly | RIGID_FRAME | 15.8 | +28.893 | +28.973 | C-D/2-3 | 471-E-D126 | 80
2 x Steel Assembly | RIGID_FRAME | 14.6 | +28.893 | +28.973 | C-D/2-3 | 471-E-D121 | 80
Steel Assembly | RIGID_FRAME | 18.6 | +28.893 | +28.973 | C-D/3-4 | 471-E-D125 | 80
Steel Assembly | RIGID_FRAME | 53.7 | +28.880 | +29.080 | C-D/3-4 | 471-E-D88 | 314.192
2 x Steel Assembly | RIGID_FRAME | 18.3 | +28.893 | +28.973 | C-D/3-4 | 471-E-D123 | 80
3 x Steel Assembly | RIGID_FRAME | 20 | +28.893 | +28.973 | C-D/3-4 | 471-E-D124 | 80
Steel Assembly | RIGID_FRAME | 18.4 | +28.893 | +28.973 | C-D/3-4 | 471-E-D122 | 80
4 x Steel Assembly | RIGID_FRAME | 17.5 | +28.893 | +28.973 | C-D/2-3 | 471-E-D111 | 80
Steel Assembly | RIGID_FRAME | 16.3 | +28.893 | +28.973 | C-D/2-3 | 471-E-D120 | 80
Steel Assembly | RIGID_FRAME | 17.1 | +28.893 | +28.973 | C-D/2-3 | 471-E-D118 | 80
Steel Assembly | RIGID_FRAME | 17.5 | +28.893 | +28.973 | C-D/2-3 | 471-E-D117 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +28.893 | +28.973 | C-D/2-3 | 471-E-D115 | 80
Steel Assembly | RIGID_FRAME | 17.1 | +28.893 | +28.973 | C-D/2-3 | 471-E-D114 | 80
2 x Steel Assembly | RIGID_FRAME | 17.6 | +28.893 | +28.973 | C-D/2-3 | 471-E-D113 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +28.893 | +28.973 | C-D/2-3 | 471-E-D112 | 80
Steel Assembly | RIGID_FRAME | 46.7 | +28.880 | +29.080 | C-D/2-3 | 471-E-D73 | 346.838
Steel Assembly | RIGID_FRAME | 46.6 | +28.880 | +29.080 | C-D/2-3 | 471-E-D71 | 345.692
Steel Assembly | RIGID_FRAME | 27.9 | +28.880 | +29.080 | C-D/2-3 | 471-E-D62 | 453.536
Steel Assembly | RIGID_FRAME | 88.4 | +28.880 | +29.080 | C-D/2-3 | 471-E-D60 | 292.047
Steel Assembly | RIGID_FRAME | 28.1 | +28.880 | +29.080 | C-D/2-3 | 471-E-D64 | 465.643
Steel Assembly | RIGID_FRAME | 27.9 | +28.880 | +29.080 | C-D/2-3 | 471-E-D61 | 446.565
Steel Assembly | RIGID_FRAME | 47.3 | +28.880 | +29.080 | C-D/2-3 | 471-E-D74 | 318.027
Steel Assembly | RIGID_FRAME | 131.3 | +28.880 | +29.080 | C-D/2-3 | 471-E-D53 | 253.403
Steel Assembly | RIGID_FRAME | 24.1 | +28.880 | +29.080 | C-D/2-3 | 471-E-D78 | 160
Steel Assembly | RIGID_FRAME | 46.8 | +28.880 | +29.080 | C-D/2-3 | 471-E-D72 | 337.894
Steel Assembly | RIGID_FRAME | 30.2 | +28.780 | +29.080 | C-D/2-3 | 471-E-D76 | 455.898
Steel Assembly | RIGID_FRAME | 129.1 | +28.880 | +29.080 | C-D/2-3 | 471-E-D52 | 160
Steel Assembly | RIGID_FRAME | 11.9 | +28.994 | +29.080 | B-C/2-3 | 471-E-D107 | 160
Steel Assembly | RIGID_FRAME | 29.9 | +28.880 | +29.080 | B-C/2 | 471-E-D93 | 190
Steel Assembly | RIGID_FRAME | 36.6 | +27.957 | +28.878 | B-C/2 | 471-E-D95 | 160
Steel Assembly | RIGID_FRAME | 248.1 | +48.700 | +56.858 | C/2-3 | 471-0-010019 | 780.01
Steel Assembly | RIGID_FRAME | 299.5 | +29.080 | +37.828 | C/2-3 | 471-0-010017 | 780.01
2 x Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | B/1-2 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | B/2 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | B/3-4 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | B/4 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | B/3 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | B/3 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 342 | +15.344 | +15.700 | B-C/1 | 471-D-C45 | 265
3 x Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | B-C/1 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | B/1 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | C/1 | 471-D-C342 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | B-C/4 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | B/4 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | C/4 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 42.7 | +15.192 | +15.344 | B-C/1-2 | 471-D-C293 | 152.4
Steel Assembly | RIGID_FRAME | 29.5 | +15.192 | +15.344 | B-C/2-3 | 471-D-C292 | 152.4
Steel Assembly | RIGID_FRAME | 27.2 | +15.192 | +15.344 | B-C/3-4 | 471-D-C287 | 152.4
Steel Assembly | RIGID_FRAME | 22.6 | +15.192 | +15.344 | B-C/3-4 | 471-D-C291 | 152.4
Steel Assembly | RIGID_FRAME | 24.1 | +15.192 | +15.344 | B-C/1-2 | 471-D-C290 | 152.4
2 x Steel Assembly | RIGID_FRAME | 27.2 | +15.192 | +15.344 | B-C/1-2 | 471-D-C287 | 152.4
2 x Steel Assembly | RIGID_FRAME | 27.2 | +5.192 | +5.344 | A-B/2-3 | 471-D-C287 | 152.4
Steel Assembly | RIGID_FRAME | 77.7 | +5.346 | +5.700 | A-B/2-3 | 471-D-C181 | 160
2 x Steel Assembly | RIGID_FRAME | 33.2 | +5.192 | +5.344 | A-B/1-2 | 471-D-C289 | 152.4
Steel Assembly | RIGID_FRAME | 27.2 | +5.192 | +5.344 | A-B/1-2 | 471-D-C287 | 152.4
Steel Assembly | RIGID_FRAME | 26.1 | +5.192 | +5.344 | B-C/1-2 | 471-D-C288 | 152.4
Steel Assembly | RIGID_FRAME | 36.9 | +5.346 | +5.700 | A-B/2-3 | 471-D-C179 | 160.001
Steel Assembly | RIGID_FRAME | 50 | +15.346 | +15.700 | B-C/3-4 | 471-D-C184 | 160
Steel Assembly | RIGID_FRAME | 100.1 | +15.346 | +15.700 | B-C/3-4 | 471-D-C180 | 160
Steel Assembly | RIGID_FRAME | 69.4 | +15.346 | +15.700 | B-C/1-2 | 471-D-C185 | 212
Steel Assembly | RIGID_FRAME | 109.1 | +5.346 | +5.700 | B-C/1-2 | 471-D-C182 | 160
Steel Assembly | RIGID_FRAME | 109.1 | +5.346 | +5.700 | A-B/1-2 | 471-D-C183 | 160
Steel Assembly | RIGID_FRAME | 421.6 | +2.041 | +3.103 | B/2-3 | 471-D-C40 | 315.5
3 x Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B/2-3 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B/3 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 255 | +2.054 | +3.091 | B/3-4 | 471-D-C43 | 315.5
Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B/3 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 55.7 | +5.497 | +5.700 | A-B/1-2 | 471-D-C367 | 203.2
Steel Assembly | RIGID_FRAME | 56 | +5.497 | +5.700 | A-B/1-2 | 471-D-C363 | 203.2
Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B/2 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 39.7 | +2.550 | +2.750 | A-B/1-2 | 471-D-C190 | 215.004
Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | A-B/1-2 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | A-B/1 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 72.5 | +2.550 | +2.750 | A-B/1 | 471-D-C163 | 220.004
2 x Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | A-B/1 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B/1 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 391.3 | +2.394 | +3.103 | B-C/1 | 471-D-C83 | 322.251
2 x Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B-C/1 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B/1 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 236.3 | +2.394 | +2.750 | B-C/1-2 | 471-D-C107 | 270.5
2 x Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B-C/1-2 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 358.9 | +2.394 | +2.750 | B-C/2 | 471-D-C97 | 272.251
2 x Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B-C/2 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B-C/1 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 370.6 | +2.394 | +2.750 | B-C/2-3 | 471-D-C108 | 270.5
3 x Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B-C/2-3 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B-C/3 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 212.4 | +2.394 | +2.750 | B-C/3-4 | 471-D-C65 | 270.5
4 x Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B-C/3-4 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B-C/2 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 40.1 | +5.497 | +5.700 | B-C/1-2 | 471-D-C364 | 203.2
Steel Assembly | RIGID_FRAME | 56 | +5.497 | +5.700 | A-B/2 | 471-D-C363 | 203.2
Steel Assembly | RIGID_FRAME | 58.5 | +5.497 | +5.700 | B-C/2 | 471-D-C362 | 203.2
Steel Assembly | RIGID_FRAME | 44.7 | +5.497 | +5.700 | B-C/2-3 | 471-D-C361 | 203.2
Steel Assembly | RIGID_FRAME | 63.1 | +5.497 | +5.700 | B-C/2-3 | 471-D-C360 | 203.2
Steel Assembly | RIGID_FRAME | 63.1 | +5.497 | +5.700 | B-C/3 | 471-D-C360 | 203.2
Steel Assembly | RIGID_FRAME | 40.1 | +5.497 | +5.700 | B-C/1 | 471-D-C366 | 203.2
Steel Assembly | RIGID_FRAME | 27.9 | +5.497 | +5.700 | B-C/1-2 | 471-D-C359 | 203.2
Steel Assembly | RIGID_FRAME | 53.9 | +5.497 | +5.700 | B-C/1-2 | 471-D-C357 | 203.2
Steel Assembly | RIGID_FRAME | 901 | +0.000 | +7.201 | B/2 | 471-D-C146 | 671.659
Steel Assembly | RIGID_FRAME | 925.5 | +0.000 | +7.201 | B/1 | 471-D-C150 | 637.803
Steel Assembly | RIGID_FRAME | 139.1 | +2.775 | +5.284 | B/1-2 | 471-D-C450 | 219.1
Steel Assembly | RIGID_FRAME | 269.8 | +2.050 | +3.095 | B/1-2 | 471-D-C36 | 190
Steel Assembly | RIGID_FRAME | 126.2 | +0.100 | +2.369 | B/1-2 | 471-D-C446 | 219.1
Steel Assembly | RIGID_FRAME | 158.6 | +0.041 | +2.369 | B/2-3 | 471-D-C445 | 219.1
Steel Assembly | RIGID_FRAME | 173.4 | +2.775 | +5.319 | B/2-3 | 471-D-C451 | 219.1
Steel Assembly | RIGID_FRAME | 134.1 | +2.775 | +5.264 | B/3-4 | 471-D-C452 | 219.1
Steel Assembly | RIGID_FRAME | 121.3 | +0.124 | +2.369 | B/3-4 | 471-D-C449 | 219.1
Steel Assembly | RIGID_FRAME | 331 | +0.041 | +5.319 | B/4-5 | 471-D-C426 | 219.1
Steel Assembly | RIGID_FRAME | 331 | +0.041 | +5.319 | B/5-6 | 471-D-C426 | 219.1
Steel Assembly | RIGID_FRAME | 164.8 | +2.498 | +2.750 | B-C/3-4 | 471-D-C352 | 238.05
2 x Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B/3-4 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B-C/3-4 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 11.1 | +2.611 | +2.695 | A-B/3-4 | 471-D-C476 | 84
Steel Assembly | RIGID_FRAME | 11.1 | +2.611 | +2.695 | A-B/2-3 | 471-D-C475 | 84
Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B/2-3 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 43.3 | +8.404 | +8.604 | A-B/RACK1-1 | 471-D-C230 | 205
3 x Steel Assembly | RIGID_FRAME | 8.2 | +8.429 | +9.709 | A-B/RACK1-1 | 471-D-C342 | 70
5 x Steel Assembly | RIGID_FRAME | 8.2 | +8.429 | +9.709 | A-B/RACK1-1 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 43.3 | +8.404 | +8.604 | A-B/RACK1-1 | 471-D-C231 | 205
Steel Assembly | RIGID_FRAME | 224.5 | +8.343 | +8.842 | A-B/RACK1-1 | 471-D-C350 | 243.5
Steel Assembly | RIGID_FRAME | 224.5 | +8.343 | +8.842 | A-B/RACK1 | 471-D-C349 | 243.5
3 x Steel Assembly | RIGID_FRAME | 8.2 | +8.429 | +9.709 | A-B/RACK1 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +8.429 | +9.709 | A-B/RACK1 | 471-D-C343 | 70
2 x Steel Assembly | RIGID_FRAME | 301.7 | +5.428 | +5.648 | A-B/4-5 | 471-D-C422 | 250
Steel Assembly | RIGID_FRAME | 552.6 | +5.344 | +6.133 | A-B/5 | 471-D-C117 | 722.778
2 x Steel Assembly | RIGID_FRAME | 301.7 | +5.428 | +5.648 | A-B/5-6 | 471-D-C422 | 250
Steel Assembly | RIGID_FRAME | 530 | +5.344 | +6.133 | A-B/6 | 471-D-C119 | 482.847
Steel Assembly | RIGID_FRAME | 74.3 | +3.050 | +3.250 | A-B/1-2 | 471-D-C160 | 215
2 x Steel Assembly | RIGID_FRAME | 8.2 | +3.075 | +4.355 | A-B/1-2 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 71.2 | +3.050 | +3.250 | B/1-2 | 471-D-C161 | 205
Steel Assembly | RIGID_FRAME | 8.2 | +3.075 | +4.355 | B/1-2 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +3.075 | +4.355 | B/1-2 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 70.2 | +3.050 | +3.250 | A-B/1-2 | 471-D-C162 | 215
2 x Steel Assembly | RIGID_FRAME | 8.2 | +3.075 | +4.355 | A-B/1-2 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 70.9 | +3.050 | +3.250 | A-B/2 | 471-D-C177 | 215
Steel Assembly | RIGID_FRAME | 8.2 | +3.075 | +4.355 | A-B/2 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +3.075 | +4.355 | B/2 | 471-D-C343 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +3.075 | +4.355 | A-B/2 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 409.1 | +10.844 | +11.200 | A-B/RACK1-1 | 471-D-C467 | 323.65
Steel Assembly | RIGID_FRAME | 8.2 | +11.025 | +12.306 | A-B/RACK1-1 | 471-D-C343 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +11.025 | +12.306 | A-B/RACK1-1 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 40.1 | +10.874 | +11.200 | A-B/RACK1-1 | 471-D-C275 | 323.185
3 x Steel Assembly | RIGID_FRAME | 8.2 | +11.025 | +12.305 | A-B/RACK1-1 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 38.8 | +10.874 | +11.200 | A-B/RACK1-1 | 471-D-C274 | 323.185
3 x Steel Assembly | RIGID_FRAME | 8.2 | +11.025 | +12.305 | A-B/RACK1-1 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 81.6 | +11.000 | +11.200 | A-B/RACK1-1 | 471-D-C176 | 185
2 x Steel Assembly | RIGID_FRAME | 15.6 | +11.013 | +11.093 | A-B/RACK1-1 | 471-D-C315 | 80
Steel Assembly | RIGID_FRAME | 39.3 | +10.874 | +11.200 | A-B/RACK1-1 | 471-D-C273 | 376.369
Steel Assembly | RIGID_FRAME | 218.5 | +10.940 | +11.200 | B-D/RACK1-1 | 471-D-C483 | 200
Steel Assembly | RIGID_FRAME | 45.4 | +5.300 | +5.500 | A-B/RACK1-1 | 471-D-C240 | 393.571
3 x Steel Assembly | RIGID_FRAME | 8.2 | +5.325 | +6.605 | A-B/RACK1-1 | 471-D-C343 | 70
5 x Steel Assembly | RIGID_FRAME | 8.2 | +5.325 | +6.605 | A-B/RACK1-1 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 48.4 | +5.300 | +5.500 | A-B/RACK1-1 | 471-D-C262 | 205
Steel Assembly | RIGID_FRAME | 27.7 | +5.300 | +5.500 | A-B/RACK1-1 | 471-D-C178 | 215
Steel Assembly | RIGID_FRAME | 321.5 | +5.144 | +5.500 | A-B/RACK1-1 | 471-D-C81 | 344.266
Steel Assembly | RIGID_FRAME | 34.2 | +5.174 | +5.500 | A-B/RACK1 | 471-D-C175 | 362.328
Steel Assembly | RIGID_FRAME | 8.2 | +5.325 | +6.605 | A-B/RACK1 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 323.7 | +5.144 | +5.500 | A-B/RACK1 | 471-D-C80 | 359.394
Steel Assembly | RIGID_FRAME | 8.2 | +5.325 | +6.605 | A-B/RACK1 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 380.9 | +5.144 | +5.500 | A-B/RACK1-1 | 471-D-C79 | 307.3
Steel Assembly | RIGID_FRAME | 18.1 | +5.313 | +5.393 | A-B/RACK1-1 | 471-D-C310 | 80
Steel Assembly | RIGID_FRAME | 25.1 | +5.313 | +5.393 | A-B/RACK1-1 | 471-D-C312 | 80
Steel Assembly | RIGID_FRAME | 24.7 | +5.313 | +5.393 | A-B/RACK1-1 | 471-D-C313 | 80
Steel Assembly | RIGID_FRAME | 16.5 | +5.313 | +5.393 | A-B/RACK1-1 | 471-D-C314 | 80
Steel Assembly | RIGID_FRAME | 32.6 | +5.174 | +5.500 | A-B/RACK1-1 | 471-D-C272 | 272.328
Steel Assembly | RIGID_FRAME | 10.5 | +5.414 | +5.500 | A-B/RACK1-1 | 471-D-C298 | 160
Steel Assembly | RIGID_FRAME | 10.5 | +5.414 | +5.500 | A-B/RACK1-1 | 471-D-C297 | 160
Steel Assembly | RIGID_FRAME | 14.5 | +5.313 | +5.393 | A-B/RACK1-1 | 471-D-C311 | 80
Steel Assembly | RIGID_FRAME | 314.2 | +5.144 | +5.500 | A-B/RACK1-1 | 471-D-C82 | 171.5
Steel Assembly | RIGID_FRAME | 379.1 | +5.144 | +5.500 | A-B/RACK1-1 | 471-D-C78 | 307.3
2 x Steel Assembly | RIGID_FRAME | 29.5 | +11.013 | +11.093 | A-B/RACK1-1 | 471-D-C305 | 80
2 x Steel Assembly | RIGID_FRAME | 313.2 | +10.844 | +11.200 | A-B/RACK1-1 | 471-D-C77 | 312.2
2 x Steel Assembly | RIGID_FRAME | 67.1 | +11.000 | +11.200 | A-B/RACK1-1 | 471-D-C239 | 352.392
Steel Assembly | RIGID_FRAME | 30.1 | +11.013 | +11.093 | A-B/RACK1-1 | 471-D-C306 | 80
2 x Steel Assembly | RIGID_FRAME | 47.8 | +9.201 | +10.843 | A-B/RACK1-1 | 471-D-C282 | 170
Steel Assembly | RIGID_FRAME | 310.2 | +9.844 | +10.200 | A-B/RACK1-1 | 471-D-C120 | 171.5
2 x Steel Assembly | RIGID_FRAME | 29.8 | +11.201 | +12.200 | A-B/RACK1-1 | 471-D-C283 | 170
Steel Assembly | RIGID_FRAME | 307.2 | +11.844 | +12.200 | A-B/RACK1-1 | 471-D-C134 | 171.5
Steel Assembly | RIGID_FRAME | 409.1 | +10.844 | +11.200 | A-B/RACK1-1 | 471-D-C470 | 307.3
Steel Assembly | RIGID_FRAME | 15.3 | +10.403 | +10.483 | B-C/1-2 | 471-D-C309 | 80
Steel Assembly | RIGID_FRAME | 28.6 | +10.390 | +10.590 | B-C/1-2 | 471-D-C235 | 292.075
Steel Assembly | RIGID_FRAME | 30.4 | +10.390 | +10.590 | B-C/1-2 | 471-D-C234 | 413.005
Steel Assembly | RIGID_FRAME | 14.2 | +10.403 | +10.483 | B-C/1-2 | 471-D-C308 | 80
Steel Assembly | RIGID_FRAME | 30.6 | +10.390 | +10.590 | B-C/1-2 | 471-D-C233 | 400.199
Steel Assembly | RIGID_FRAME | 13.1 | +10.403 | +10.483 | B-C/1-2 | 471-D-C307 | 80
Steel Assembly | RIGID_FRAME | 372.6 | +10.234 | +10.590 | B-C/1-2 | 471-D-C41 | 504.028
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/1-2 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/1-2 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/2 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/1 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | <A/2 | 471-D-C343 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A/2 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 264.7 | +11.810 | +12.500 | A/1-2 | 471-D-C111 | 265.001
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A/1-2 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A/1 | 471-D-C342 | 70
