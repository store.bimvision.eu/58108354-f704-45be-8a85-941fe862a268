Properties of the parts of a building model (IFC2X3), part 14 of 22

# IfcDiscreteAccessory: PLATE (5205)
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x PLATE | PLT12*82.1 | +15.356 | +15.688 | 5 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pc-88 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
2 x PLATE | PLT12*82.1 | +15.356 | +15.688 | 4 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pb-49 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
12 x PLATE | FL16*80 | +2.406 | +2.738 | 3 | 99 | 3.3 | 0 | 19.8 | 0.1 | 80 | 16 | 331.6 | pa-197 | 0.0645086 | 0.026528 | 0.000256 | 0.000414448 | 0.000414448
2 x PLATE | PLT10*94.5 | +9.871 | +10.012 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +5.923 | +6.064 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +5.896 | +6.044 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +9.890 | +10.038 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +9.838 | +9.968 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
6 x PLATE | PLT10*94.5 | +9.843 | +9.973 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT10*94.5 | +4.972 | +5.109 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT10*94.5 | +4.972 | +5.109 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +4.948 | +5.078 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
6 x PLATE | PLT20*140 | +10.235 | +10.255 | 3 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pa-42 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
6 x PLATE | PLT20*140 | +10.570 | +10.590 | 3 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pa-42 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
8 x PLATE | PLT10*94.5 | +9.819 | +9.946 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +9.643 | +10.134 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*350.7 | +9.820 | +10.234 | 3 | 99 | 14.7 | 0 | 17.5 | 0.3 | 350.7 | 16 | 414.2 | pa-227 | 0.25444 | 0.145267 | 0.000256 | 0.00186457 | 0.00186457
PLATE | PLT16*350.7 | +9.820 | +10.234 | 3 | 99 | 14.7 | 0 | 17.5 | 0.3 | 350.7 | 16 | 414.2 | pa-227 | 0.254442 | 0.145268 | 0.000256 | 0.00186459 | 0.00186459
8 x PLATE | PLT10*94.5 | +5.913 | +6.040 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +5.725 | +6.216 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*339.2 | +5.700 | +6.039 | 3 | 99 | 25.5 | 0 | 17.2 | 0.3 | 339.2 | 16 | 701.5 | pa-147 | 0.436618 | 0.237922 | 0.000256 | 0.00325389 | 0.00325389
2 x PLATE | PLT8*85 | +10.415 | +10.578 | 3 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pa-235 | 0.031678 | 0.013855 | 0.000064 | 0.00011084 | 0.00011084
2 x PLATE | PLT8*132.2 | +7.970 | +8.136 | 3 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166 | pa-232 | 0.0483663 | 0.0219452 | 0.000064 | 0.000174662 | 0.000174662
19 x PLATE | PLT12*82.1 | +5.356 | +5.689 | 3 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pa-45 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
3 x PLATE | PLT8*166.4 | +2.525 | +2.691 | 3 | 8 | 2.3 | 0 | 34.5 | 0.1 | 166.5 | 8 | 216.9 | pa-233 | 0.0780393 | 0.0361005 | 0.000064 | 0.000287904 | 0.000287904
32 x PLATE | PLT8*163 | +10.415 | +10.578 | 3 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pa-230 | 0.0763044 | 0.0352651 | 0.000064 | 0.00028122 | 0.00028122
8 x PLATE | PLT10*81.8 | +10.251 | +10.333 | 3 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pa-133 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
10 x PLATE | PLT10*81.8 | +10.152 | +10.233 | 3 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pa-133 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
10 x PLATE | PLT16*210 | +10.234 | +10.250 | 3 | 99 | 11.1 | 0.1 | 17.7 | 0.2 | 210 | 16 | 425 | pa-148 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*415.1 | +10.218 | +10.234 | 3 | 99 | 18.1 | 0.1 | 17.3 | 0.3 | 415.1 | 16 | 544.6 | pa-150 | 0.315648 | 0.226072 | 0.000256 | 0.00232034 | 0.00232034
2 x PLATE | PLT8*155.2 | +2.525 | +2.691 | 3 | 8 | 1.6 | 0 | 35 | 0.1 | 155.2 | 8 | 166.4 | pa-234 | 0.0565168 | 0.0258329 | 0.000064 | 0.000205763 | 0.000205763
PLATE | PLT16*383.3 | +10.218 | +10.234 | 3 | 99 | 12.9 | 0.1 | 17.5 | 0.2 | 383.3 | 16 | 383.7 | pa-185 | 0.226742 | 0.147082 | 0.000256 | 0.00164966 | 0.00164966
PLATE | PLT16*383.3 | +10.218 | +10.234 | 3 | 99 | 12.9 | 0.1 | 17.5 | 0.2 | 383.3 | 16 | 383.7 | pa-185 | 0.226685 | 0.147082 | 0.000256 | 0.00164921 | 0.00164921
2 x PLATE | PLT10*81.9 | +10.251 | +10.333 | 3 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pa-133 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
PLATE | PLT16*457.5 | +10.218 | +10.234 | 3 | 99 | 18.3 | 0.1 | 17.3 | 0.3 | 457.5 | 16 | 491.9 | pa-149 | 0.316372 | 0.225048 | 0.000256 | 0.00232576 | 0.00232576
PLATE | PLT16*371.2 | +10.218 | +10.234 | 3 | 99 | 13.1 | 0.1 | 17.5 | 0.2 | 371.2 | 16 | 378.7 | pa-184 | 0.22931 | 0.140549 | 0.000256 | 0.00166915 | 0.00166915
PLATE | PLT16*365.2 | +10.218 | +10.234 | 3 | 99 | 12.4 | 0.1 | 17.5 | 0.2 | 365.2 | 16 | 378.2 | pa-183 | 0.219672 | 0.138125 | 0.000256 | 0.00159618 | 0.00159618
PLATE | PLT16*350.9 | +10.218 | +10.234 | 3 | 99 | 17.2 | 0.1 | 17.3 | 0.3 | 350.9 | 16 | 477.2 | pa-178 | 0.296011 | 0.167459 | 0.000256 | 0.00218015 | 0.00218015
PLATE | PLT16*350.9 | +10.218 | +10.234 | 3 | 99 | 12.4 | 0.1 | 17.5 | 0.2 | 350.9 | 16 | 374.3 | pa-182 | 0.216067 | 0.131315 | 0.000256 | 0.00156885 | 0.00156885
52 x PLATE | FL10*70 | +10.089 | +10.227 | 3 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pa-72 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
PLATE | FL10*110 | +10.480 | +10.490 | 3 | 8 | 0.7 | 0 | 31.4 | 0 | 110 | 10 | 140 | pa-71 | 0.023295 | 0.0154 | 0.0001 | 0.000094625 | 0.000094625
4 x PLATE | FL10*80 | +10.480 | +10.490 | 3 | 8 | 0.7 | 0 | 32.5 | 0 | 80 | 10 | 140 | pa-70 | 0.0181839 | 0.0112 | 0.0001 | 0.000071375 | 0.000071375
PLATE | PLT3*94 | +5.497 | +5.500 | 3 | 8 | 0.4 | 0 | 89.3 | 0 | 94 | 3 | 150 | pa-237 | 0.029664 | 0.0141 | 0.000009 | 0.0000423 | 0.0000423
PLATE | PLT3*94 | +5.497 | +5.500 | 3 | 8 | 0.4 | 0 | 89.1 | 0 | 94 | 3 | 170 | pa-236 | 0.033544 | 0.01598 | 0.000009 | 0.00004794 | 0.00004794
4 x PLATE | FL10*70 | +5.352 | +5.489 | 3 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pa-72 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
4 x PLATE | FL10*70 | +5.355 | +5.493 | 3 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pa-72 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
20 x PLATE | FL10*70 | +5.199 | +5.337 | 3 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pa-72 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
2 x PLATE | FL10*90 | -0.060 | +0.050 | 3 | 8 | 0.7 | 0 | 30.6 | 0 | 90 | 10 | 110 | pa-69 | 0.0238 | 0.00989999 | 0.0001 | 0.0000989999 | 0.0000989999
2 x PLATE | FL10*90 | -0.070 | -0.060 | 3 | 8 | 1.3 | 0 | 29.7 | 0 | 90 | 10 | 184.9 | pa-68 | 0.0387993 | 0.0166497 | 0.0001 | 0.000166497 | 0.000166497
2 x PLATE | FL16*250 | +9.643 | +10.134 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*350.7 | +9.820 | +10.234 | 3 | 99 | 14.7 | 0 | 17.5 | 0.3 | 350.7 | 16 | 414.2 | pa-174 | 0.25444 | 0.145267 | 0.000256 | 0.00186457 | 0.00186457
4 x PLATE | FL10*80 | +5.700 | +5.710 | 3 | 8 | 0.4 | 0 | 31.8 | 0 | 80 | 10 | 80 | pa-67 | 0.016 | 0.0064 | 0.0001 | 0.000064 | 0.000064
2 x PLATE | FL16*250 | +5.725 | +6.216 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*339.2 | +5.700 | +6.039 | 3 | 99 | 25.5 | 0 | 17.2 | 0.3 | 339.2 | 16 | 701.5 | pa-189 | 0.436618 | 0.237922 | 0.000256 | 0.00325389 | 0.00325389
5 x PLATE | PLT20*140 | +15.345 | +15.365 | 4 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pb-38 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
5 x PLATE | PLT20*140 | +15.680 | +15.700 | 4 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pb-38 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
2 x PLATE | PLT20*129.1 | +23.963 | +23.983 | 4 | 99 | 2.8 | 0 | 16.5 | 0 | 129.1 | 20 | 140 | pb-22 | 0.0459944 | 0.0180741 | 0.0004 | 0.000355233 | 0.000355233
2 x PLATE | PLT20*129.1 | +24.298 | +24.318 | 4 | 99 | 2.8 | 0 | 16.5 | 0 | 129.1 | 20 | 140 | pb-22 | 0.0459944 | 0.0180741 | 0.0004 | 0.000355233 | 0.000355233
2 x PLATE | PLT20*129.1 | +21.105 | +21.125 | 4 | 99 | 2.8 | 0 | 16.5 | 0 | 129.1 | 20 | 140 | pb-22 | 0.0459943 | 0.0180741 | 0.0004 | 0.000355232 | 0.000355232
2 x PLATE | PLT20*129.1 | +21.440 | +21.460 | 4 | 99 | 2.8 | 0 | 16.5 | 0 | 129.1 | 20 | 140 | pb-22 | 0.0459943 | 0.0180741 | 0.0004 | 0.000355232 | 0.000355232
8 x PLATE | PLT10*81.8 | +5.361 | +5.443 | 3 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pa-133 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
8 x PLATE | PLT10*81.8 | +5.262 | +5.343 | 3 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pa-133 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
8 x PLATE | PLT16*210 | +5.344 | +5.360 | 3 | 99 | 11.1 | 0.1 | 17.7 | 0.2 | 210 | 16 | 425 | pa-148 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
2 x PLATE | PLT16*498.9 | +5.328 | +5.344 | 3 | 99 | 25.2 | 0.2 | 17.2 | 0.3 | 498.9 | 16 | 533.7 | pa-181 | 0.431128 | 0.266256 | 0.000256 | 0.00321945 | 0.00321945
PLATE | PLT16*388.7 | +5.328 | +5.344 | 3 | 99 | 18.6 | 0.1 | 17.2 | 0.3 | 388.7 | 16 | 487.8 | pa-180 | 0.32155 | 0.189588 | 0.000256 | 0.00237676 | 0.00237676
PLATE | PLT16*388.7 | +5.328 | +5.344 | 3 | 99 | 18.6 | 0.1 | 17.2 | 0.3 | 388.7 | 16 | 487.8 | pa-180 | 0.321549 | 0.189588 | 0.000256 | 0.00237676 | 0.00237676
PLATE | PLT10*81.8 | +5.547 | +5.629 | 3 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pa-133 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
2 x PLATE | PLT10*81.8 | +5.447 | +5.529 | 3 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pa-133 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
2 x PLATE | PLT16*210 | +5.530 | +5.546 | 3 | 99 | 11.1 | 0.1 | 17.7 | 0.2 | 210 | 16 | 425 | pa-148 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
2 x PLATE | PLT16*300.7 | +5.514 | +5.530 | 3 | 99 | 9.1 | 0.1 | 17.8 | 0.2 | 300.7 | 16 | 316.5 | pa-179 | 0.161267 | 0.0951307 | 0.000256 | 0.00115353 | 0.00115353
PLATE | PLT10*81.9 | +5.547 | +5.629 | 3 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pa-133 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
PLATE | PLT16*350.9 | +5.328 | +5.344 | 3 | 99 | 17.2 | 0.1 | 17.3 | 0.3 | 350.9 | 16 | 477.2 | pa-178 | 0.296011 | 0.167459 | 0.000256 | 0.00218015 | 0.00218015
PLATE | PLT16*350.9 | +5.328 | +5.344 | 3 | 99 | 12.4 | 0.1 | 17.5 | 0.2 | 350.9 | 16 | 374.3 | pa-177 | 0.217114 | 0.131315 | 0.000256 | 0.00157678 | 0.00157678
PLATE | PLT16*353.7 | +5.328 | +5.344 | 5 | 99 | 17.2 | 0.1 | 17.3 | 0.3 | 353.7 | 16 | 478 | pc-355 | 0.297941 | 0.169087 | 0.000256 | 0.00219502 | 0.00219502
PLATE | PLT16*492 | +5.328 | +5.344 | 5 | 99 | 28.9 | 0.2 | 16.9 | 0.5 | 492 | 16 | 629.5 | pc-356 | 0.491687 | 0.309692 | 0.000256 | 0.00368211 | 0.00368211
PLATE | PLT16*322.9 | +5.328 | +5.344 | 5 | 99 | 15.8 | 0.1 | 17.5 | 0.3 | 322.9 | 16 | 465.8 | pc-357 | 0.276256 | 0.150396 | 0.000256 | 0.00202788 | 0.00202788
PLATE | PLT16*493.8 | +5.328 | +5.344 | 5 | 99 | 27.9 | 0.2 | 16.9 | 0.5 | 493.8 | 16 | 605.7 | pc-358 | 0.475619 | 0.299079 | 0.000256 | 0.00355921 | 0.00355921
PLATE | PLT16*683.7 | +5.328 | +5.344 | 5 | 99 | 46.8 | 0.3 | 16.8 | 0.8 | 683.7 | 16 | 821 | pc-397 | 0.784753 | 0.561313 | 0.000256 | 0.00596653 | 0.00596653
4 x PLATE | PLT10*94.5 | +10.947 | +11.036 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +10.740 | +11.229 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*338.8 | +10.590 | +11.026 | 3 | 99 | 15.8 | 0 | 17.3 | 0.3 | 338.8 | 16 | 436.5 | pa-220 | 0.274705 | 0.14788 | 0.000256 | 0.00201895 | 0.00201895
4 x PLATE | PLT10*94.5 | +14.980 | +15.069 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +14.787 | +15.276 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*355 | +14.989 | +15.344 | 4 | 99 | 26 | 0 | 17.2 | 0.3 | 355 | 16 | 657.5 | pb-192 | 0.443548 | 0.233392 | 0.000256 | 0.00331088 | 0.00331088
2 x PLATE | FL12*110 | +5.136 | +5.246 | 5 | 8 | 0.7 | 0 | 27.5 | 0 | 110 | 12 | 110 | pc-84 | 0.0207474 | 0.0121 | 0.000144 | 0.0000966 | 0.0000966
PLATE | PLT16*405.5 | +5.328 | +5.344 | 5 | 99 | 19.6 | 0.2 | 17.2 | 0.3 | 405.5 | 16 | 497.1 | pc-352 | 0.337633 | 0.201594 | 0.000256 | 0.00250057 | 0.00250057
PLATE | PLT16*501.4 | +5.328 | +5.344 | 5 | 99 | 25.5 | 0.2 | 17.2 | 0.3 | 501.4 | 16 | 553.9 | pc-353 | 0.433314 | 0.277723 | 0.000256 | 0.00323419 | 0.00323419
2 x PLATE | PLT16*410.3 | +5.328 | +5.344 | 5 | 99 | 19.7 | 0.2 | 17.2 | 0.3 | 410.3 | 16 | 497.3 | pc-354 | 0.341054 | 0.204056 | 0.000256 | 0.00252695 | 0.00252695
PLATE | PLT16*530.2 | +5.328 | +5.344 | 5 | 99 | 29.4 | 0.2 | 16.9 | 0.5 | 530.2 | 16 | 650.4 | pc-242 | 0.500977 | 0.344839 | 0.000256 | 0.0037602 | 0.0037602
PLATE | PLT16*497.5 | +5.328 | +5.344 | 5 | 99 | 27.7 | 0.2 | 16.9 | 0.5 | 497.5 | 16 | 614.5 | pc-359 | 0.47131 | 0.305682 | 0.000256 | 0.00352433 | 0.00352433
PLATE | PLT16*368.6 | +5.328 | +5.344 | 5 | 99 | 26.8 | 0.2 | 16.9 | 0.5 | 368.6 | 16 | 780.3 | pc-241 | 0.456853 | 0.287592 | 0.000256 | 0.0034147 | 0.0034147
PLATE | PLT16*586.7 | +5.328 | +5.344 | 5 | 99 | 37.2 | 0.3 | 16.9 | 0.6 | 586.7 | 16 | 701.1 | pc-396 | 0.627256 | 0.411304 | 0.000256 | 0.00474125 | 0.00474125
PLATE | PLT16*301.7 | +5.328 | +5.344 | 5 | 99 | 9.1 | 0.1 | 17.8 | 0.2 | 301.7 | 16 | 319.5 | pc-360 | 0.162457 | 0.0963695 | 0.000256 | 0.00116244 | 0.00116244
PLATE | PLT16*523.6 | +5.328 | +5.344 | 5 | 99 | 30.4 | 0.2 | 16.9 | 0.5 | 523.6 | 16 | 666.4 | pc-240 | 0.516415 | 0.348985 | 0.000256 | 0.00387991 | 0.00387991
PLATE | PLT16*291.7 | +5.328 | +5.344 | 5 | 99 | 9.3 | 0.1 | 17.8 | 0.2 | 291.7 | 16 | 308.5 | pc-361 | 0.16329 | 0.089996 | 0.000256 | 0.00116974 | 0.00116974
PLATE | PLT16*326.9 | +5.328 | +5.344 | 5 | 99 | 16.3 | 0.1 | 17.3 | 0.3 | 326.9 | 16 | 474.2 | pc-349 | 0.283289 | 0.155047 | 0.000256 | 0.00208187 | 0.00208187
PLATE | PLT16*673.2 | +5.328 | +5.344 | 5 | 99 | 39.3 | 0.3 | 16.8 | 0.6 | 673.2 | 16 | 681.9 | pc-239 | 0.661041 | 0.459086 | 0.000256 | 0.00500865 | 0.00500865
PLATE | PLT16*364.3 | +5.328 | +5.344 | 5 | 99 | 17.6 | 0.1 | 17.3 | 0.3 | 364.3 | 16 | 482.3 | pc-350 | 0.305115 | 0.175681 | 0.000256 | 0.00225023 | 0.00225023
PLATE | PLT16*673.7 | +5.328 | +5.344 | 5 | 99 | 43.6 | 0.3 | 16.8 | 0.6 | 673.7 | 16 | 770.8 | pc-395 | 0.732331 | 0.51925 | 0.000256 | 0.00555993 | 0.00555993
PLATE | PLT16*294.7 | +5.328 | +5.344 | 5 | 99 | 9.3 | 0.1 | 17.8 | 0.2 | 294.7 | 16 | 309.9 | pc-351 | 0.164747 | 0.0913233 | 0.000256 | 0.00118078 | 0.00118078
4 x PLATE | PLT12*85 | +5.305 | +5.685 | 5 | 8 | 2.9 | 0 | 24.9 | 0.1 | 85 | 12 | 379.8 | pc-92 | 0.07464 | 0.032283 | 0.000144 | 0.000382596 | 0.000382596
3 x PLATE | PLT12*82.1 | +5.356 | +5.688 | 5 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pc-88 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
4 x PLATE | PLT12*90.7 | +5.259 | +5.687 | 5 | 8 | 3.6 | 0 | 24.6 | 0.1 | 90.7 | 12 | 428.2 | pc-89 | 0.0890479 | 0.0388377 | 0.000144 | 0.000461253 | 0.000461253
2 x PLATE | PLT8*74.5 | +15.614 | +15.688 | 4 | 8 | 0.4 | 0 | 38.3 | 0 | 74.5 | 8 | 82.1 | pb-238 | 0.0144432 | 0.00611645 | 0.000064 | 0.0000480316 | 0.0000480316
2 x PLATE | PLT8*47.2 | +15.614 | +15.692 | 5 | 8 | 0.2 | 0 | 40.5 | 0 | 47.2 | 8 | 77.5 | pc-418 | 0.00901591 | 0.003658 | 0.000064 | 0.000028364 | 0.000028364
PLATE | FL10*80 | +15.614 | +15.694 | 4 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pb-73 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
3 x PLATE | FL10*80 | +15.614 | +15.694 | 5 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pc-150 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
PLATE | FL10*80 | +15.614 | +15.694 | 4 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pb-72 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
3 x PLATE | FL10*80 | +15.614 | +15.694 | 5 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pc-149 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
2 x PLATE | FL10*80 | +3.145 | +3.225 | 5 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | pc-206 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
4 x PLATE | FL10*80 | +2.615 | +2.695 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
4 x PLATE | FL6*40 | +3.847 | +3.897 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
2 x PLATE | FL6*40 | +3.831 | +3.837 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
2 x PLATE | PLT6*52 | +3.867 | +3.920 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
PLATE | PLT16*138.1 | +4.988 | +5.004 | 3 | 99 | 2.5 | 0 | 19.5 | 0 | 138.1 | 16 | 146.4 | pa-195 | 0.0486958 | 0.0202247 | 0.000256 | 0.000318596 | 0.000318596
PLATE | PLT16*138.1 | +6.894 | +6.910 | 3 | 99 | 2.5 | 0 | 19.5 | 0 | 138.1 | 16 | 146.4 | pa-195 | 0.0486958 | 0.0202247 | 0.000256 | 0.000318596 | 0.000318596
PLATE | PLT16*138.1 | +7.234 | +7.250 | 3 | 99 | 2.5 | 0 | 19.5 | 0 | 138.1 | 16 | 146.4 | pa-195 | 0.0486958 | 0.0202247 | 0.000256 | 0.000318596 | 0.000318596
PLATE | PLT16*138.1 | +8.844 | +8.860 | 3 | 99 | 2.5 | 0 | 19.5 | 0 | 138.1 | 16 | 146.4 | pa-195 | 0.0486958 | 0.0202247 | 0.000256 | 0.000318596 | 0.000318596
PLATE | PLT16*138.1 | +9.184 | +9.200 | 3 | 99 | 2.5 | 0 | 19.5 | 0 | 138.1 | 16 | 146.4 | pa-195 | 0.0486958 | 0.0202247 | 0.000256 | 0.000318596 | 0.000318596
PLATE | PLT16*138.1 | +10.844 | +10.860 | 3 | 99 | 2.5 | 0 | 19.5 | 0 | 138.1 | 16 | 146.4 | pa-195 | 0.0486958 | 0.0202247 | 0.000256 | 0.000318596 | 0.000318596
PLATE | PLT16*138.1 | +11.184 | +11.200 | 3 | 99 | 2.5 | 0 | 19.5 | 0 | 138.1 | 16 | 146.4 | pa-195 | 0.0486958 | 0.0202247 | 0.000256 | 0.000318596 | 0.000318596
2 x PLATE | PLT8*166 | +5.525 | +5.691 | 5 | 8 | 2.2 | 0 | 34.5 | 0.1 | 166 | 8 | 216.4 | pc-425 | 0.0776331 | 0.0359058 | 0.000064 | 0.000286346 | 0.000286346
17 x PLATE | PLT8*163 | +5.525 | +5.688 | 3 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pa-230 | 0.0763044 | 0.0352651 | 0.000064 | 0.00028122 | 0.00028122
5 x PLATE | PLT8*132.2 | +5.525 | +5.691 | 3 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166 | pa-232 | 0.0483663 | 0.0219452 | 0.000064 | 0.000174662 | 0.000174662
7 x PLATE | PLT8*163 | +5.525 | +5.688 | 3 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.4 | pa-231 | 0.0592044 | 0.0271151 | 0.000064 | 0.00021602 | 0.00021602
13 x PLATE | FL12*80 | +5.356 | +5.688 | 3 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pa-46 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
10 x PLATE | PLT8*163 | +10.415 | +10.578 | 3 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.4 | pa-231 | 0.0592044 | 0.0271151 | 0.000064 | 0.00021602 | 0.00021602
PLATE | FL12*130 | +12.170 | +12.300 | 5 | 8 | 1.3 | 0 | 25.9 | 0 | 130 | 12 | 150 | pc-83 | 0.0329549 | 0.0195003 | 0.000144 | 0.000162002 | 0.000162002
8 x PLATE | FL12*80 | +17.706 | +18.038 | 4 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pb-48 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
6 x PLATE | FL12*80 | +12.156 | +12.488 | 5 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pc-90 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
4 x PLATE | FL12*80 | +15.356 | +15.688 | 4 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pb-48 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
4 x PLATE | FL12*80 | +10.246 | +10.578 | 3 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pa-46 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
2 x PLATE | PLT12*104 | +2.594 | +2.606 | 5 | 8 | 1.5 | 0 | 25.9 | 0 | 104 | 12 | 210 | pc-82 | 0.0371834 | 0.02184 | 0.000144 | 0.00018216 | 0.00018216
2 x PLATE | PLT12*210 | +2.400 | +2.800 | 5 | 8 | 6.3 | 0 | 23.3 | 0.1 | 210 | 12 | 400 | pc-91 | 0.14859 | 0.084 | 0.000144 | 0.0008136 | 0.0008136
2 x PLATE | PLT12*220 | +2.400 | +2.800 | 5 | 8 | 8.2 | 0 | 23 | 0.2 | 220 | 12 | 400 | pc-63 | 0.19088 | 0.088 | 0.000144 | 0.001056 | 0.001056
2 x PLATE | PLT12*206 | +2.400 | +2.800 | 5 | 8 | 7.8 | 0 | 23.1 | 0.2 | 206 | 12 | 400 | pc-62 | 0.179344 | 0.0824 | 0.000144 | 0.0009888 | 0.0009888
2 x PLATE | PLT12*143 | +2.400 | +2.800 | 5 | 8 | 5.4 | 0 | 23.8 | 0.1 | 143.1 | 12 | 400 | pc-64 | 0.127432 | 0.0572 | 0.000144 | 0.0006864 | 0.0006864
2 x PLATE | PLT12*104 | +7.794 | +7.806 | 5 | 8 | 1.5 | 0 | 25.9 | 0 | 104 | 12 | 210 | pc-82 | 0.0371834 | 0.02184 | 0.000144 | 0.00018216 | 0.00018216
2 x PLATE | PLT12*210 | +7.600 | +8.000 | 5 | 8 | 6.3 | 0 | 23.3 | 0.1 | 210 | 12 | 400 | pc-91 | 0.14859 | 0.084 | 0.000144 | 0.0008136 | 0.0008136
2 x PLATE | PLT12*220 | +7.600 | +8.000 | 5 | 8 | 8.2 | 0 | 23 | 0.2 | 220 | 12 | 400 | pc-63 | 0.19088 | 0.088 | 0.000144 | 0.001056 | 0.001056
2 x PLATE | PLT12*104 | +9.994 | +10.006 | 5 | 8 | 1.5 | 0 | 25.9 | 0 | 104 | 12 | 210 | pc-82 | 0.0371834 | 0.02184 | 0.000144 | 0.00018216 | 0.00018216
2 x PLATE | PLT12*210 | +9.800 | +10.200 | 5 | 8 | 6.3 | 0 | 23.3 | 0.1 | 210 | 12 | 400 | pc-91 | 0.14859 | 0.084 | 0.000144 | 0.0008136 | 0.0008136
2 x PLATE | PLT12*220 | +9.800 | +10.200 | 5 | 8 | 8.2 | 0 | 23 | 0.2 | 220 | 12 | 400 | pc-63 | 0.19088 | 0.088 | 0.000144 | 0.001056 | 0.001056
5 x PLATE | FL12*80 | +5.356 | +5.688 | 5 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pc-90 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
10 x PLATE | FL12*80 | +10.246 | +10.578 | 5 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pc-90 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
2 x PLATE | FL12*80 | +7.500 | +7.832 | 3 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pa-46 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
2 x PLATE | FL12*80 | +7.856 | +8.188 | 5 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pc-90 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
8 x PLATE | FL12*80 | +8.856 | +9.188 | 5 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pc-90 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
8 x PLATE | FL12*80 | +10.856 | +11.188 | 5 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pc-90 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
PLATE | PLT12*171.5 | +5.150 | +5.328 | 5 | 8 | 1.9 | 0 | 25.1 | 0 | 171.4 | 12 | 178 | pc-81 | 0.0474831 | 0.030527 | 0.000144 | 0.000240672 | 0.000240672
4 x PLATE | PLT12*82.1 | +5.356 | +5.688 | 5 | 8 | 2.5 | 0 | 25.1 | 0.1 | 82.1 | 12 | 331.6 | pc-88 | 0.0637166 | 0.0272244 | 0.000144 | 0.000323992 | 0.000323992
PLATE | PLT12*171.5 | +5.150 | +5.344 | 5 | 8 | 1.9 | 0 | 24.9 | 0.1 | 171.4 | 12 | 194 | pc-80 | 0.0510413 | 0.033271 | 0.000144 | 0.000260016 | 0.000260016
PLATE | PLT20*140 | +18.380 | +18.400 | 4 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pb-38 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
2 x PLATE | PLT12*82.1 | +10.246 | +10.579 | 5 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pc-88 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
2 x PLATE | PLT12*82.1 | +10.246 | +10.578 | 5 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pc-88 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
2 x PLATE | PLT12*82.1 | +10.246 | +10.579 | 3 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pa-45 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
2 x PLATE | PLT12*82.1 | +10.246 | +10.578 | 3 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pa-45 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
PLATE | FL12*80 | +10.247 | +10.354 | 5 | 99 | 0.7 | 0 | 26.8 | 0 | 80 | 12 | 107 | pc-79 | 0.0212777 | 0.00856008 | 0.000144 | 0.000101371 | 0.000101371
PLATE | FL12*80 | +10.370 | +10.577 | 5 | 99 | 1.5 | 0 | 25.6 | 0 | 80 | 12 | 206.9 | pc-78 | 0.0396774 | 0.0165599 | 0.000144 | 0.000197369 | 0.000197369
3 x PLATE | PLT10*81.8 | +10.387 | +10.469 | 5 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pc-203 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
4 x PLATE | PLT10*81.8 | +10.287 | +10.369 | 5 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pc-203 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
4 x PLATE | PLT16*210 | +10.370 | +10.386 | 5 | 99 | 11.1 | 0.1 | 17.7 | 0.2 | 210 | 16 | 425 | pc-384 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*305.5 | +10.354 | +10.370 | 5 | 99 | 12.6 | 0.1 | 17.7 | 0.2 | 305.5 | 16 | 471.6 | pc-316 | 0.222294 | 0.144068 | 0.000256 | 0.00160703 | 0.00160703
PLATE | PLT16*305.6 | +10.354 | +10.370 | 5 | 99 | 12.6 | 0.1 | 17.7 | 0.2 | 305.6 | 16 | 470.8 | pc-317 | 0.221982 | 0.143867 | 0.000256 | 0.00160473 | 0.00160473
PLATE | PLT10*81.9 | +10.387 | +10.469 | 5 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pc-203 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
PLATE | PLT16*319.3 | +10.354 | +10.370 | 5 | 99 | 21.4 | 0.2 | 17.2 | 0.3 | 319.3 | 16 | 598.2 | pc-394 | 0.367036 | 0.190993 | 0.000256 | 0.00272132 | 0.00272132
8 x PLATE | FL12*200 | +12.132 | +12.144 | 5 | 13 | 17.6 | 0.2 | 22.8 | 0.3 | 200 | 12 | 935 | 471-D-C490 | 0.40124 | 0.40124 | 0.0024 | 0.002244 | 0.002244
8 x PLATE | FL12*200 | +12.132 | +12.144 | 5 | 13 | 20.3 | 0.2 | 22.8 | 0.5 | 200 | 12 | 1075 | 471-D-C489 | 0.4606 | 0.4606 | 0.0024 | 0.00258 | 0.00258
4 x PLATE | PLT10*94.5 | +9.878 | +10.049 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +9.742 | +10.193 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.1 | +9.865 | +10.217 | 3 | 99 | 14.7 | 0 | 17.5 | 0.3 | 352.1 | 16 | 414 | pa-226 | 0.256305 | 0.145767 | 0.000256 | 0.00187903 | 0.00187903
4 x PLATE | PLT10*94.5 | +8.013 | +8.184 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +7.869 | +8.320 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.8 | +7.844 | +8.197 | 3 | 99 | 14 | 0 | 17.5 | 0.2 | 352.8 | 16 | 418 | pa-225 | 0.241803 | 0.147499 | 0.000256 | 0.00176499 | 0.00176499
2 x PLATE | PLT10*94.5 | +7.157 | +7.341 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +7.157 | +7.341 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +7.042 | +7.463 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*348.8 | +7.140 | +7.488 | 3 | 99 | 39.1 | 0 | 16.9 | 0.6 | 348.8 | 16 | 980.6 | pa-146 | 0.662622 | 0.342039 | 0.000256 | 0.00498517 | 0.00498517
3 x PLATE | PLT10*94.5 | +5.848 | +6.031 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +5.725 | +6.147 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*348.8 | +5.700 | +6.049 | 3 | 99 | 16.2 | 0 | 17.5 | 0.3 | 348.8 | 16 | 490.3 | pa-199 | 0.281103 | 0.171019 | 0.000256 | 0.00206156 | 0.00206156
PLATE | PLT20*140 | +15.980 | +16.000 | 4 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pb-38 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
30 x PLATE | PLT12*82.1 | +12.156 | +12.488 | 5 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pc-88 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
2 x PLATE | PLT10*94.5 | +0.329 | +0.459 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +0.143 | +0.633 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353 | +0.040 | +0.459 | 3 | 99 | 15.1 | 0 | 17.5 | 0.3 | 353 | 16 | 418.6 | pa-224 | 0.261668 | 0.147767 | 0.000256 | 0.00191839 | 0.00191839
2 x PLATE | PLT10*94.5 | +4.928 | +5.058 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +4.754 | +5.244 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*358.8 | +4.928 | +5.344 | 3 | 99 | 15.1 | 0 | 17.3 | 0.3 | 358.8 | 16 | 415.9 | pa-223 | 0.264407 | 0.149242 | 0.000256 | 0.00194156 | 0.00194156
2 x PLATE | PLT10*94.5 | +5.953 | +6.094 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +5.775 | +6.260 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*369.5 | +5.700 | +6.097 | 3 | 99 | 14.7 | 0 | 17.5 | 0.3 | 369.5 | 16 | 396.5 | pa-222 | 0.255649 | 0.146512 | 0.000256 | 0.00187449 | 0.00187449
2 x PLATE | PLT10*94.5 | +9.841 | +9.982 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +9.675 | +10.159 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*369.5 | +9.838 | +10.234 | 3 | 99 | 14.7 | 0 | 17.5 | 0.3 | 369.5 | 16 | 396.5 | pa-222 | 0.255649 | 0.146512 | 0.000256 | 0.00187449 | 0.00187449
2 x PLATE | PLT10*94.5 | +10.845 | +10.983 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +10.665 | +11.152 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*360.9 | +10.590 | +10.985 | 3 | 99 | 14.4 | 0 | 17.5 | 0.2 | 360.9 | 16 | 394.9 | pa-221 | 0.249672 | 0.142522 | 0.000256 | 0.00182873 | 0.00182873
2 x PLATE | PLT10*94.5 | +14.951 | +15.089 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +14.783 | +15.269 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*359.8 | +14.950 | +15.344 | 4 | 99 | 14.4 | 0 | 17.5 | 0.2 | 359.8 | 16 | 394.9 | pb-180 | 0.248886 | 0.142068 | 0.000256 | 0.0018227 | 0.0018227
2 x PLATE | PLT10*94.5 | +17.370 | +17.559 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +17.266 | +17.669 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*344.6 | +17.350 | +17.694 | 4 | 99 | 17.8 | 0 | 17.3 | 0.3 | 344.6 | 16 | 542 | pb-179 | 0.308834 | 0.186741 | 0.000256 | 0.00227043 | 0.00227043
PLATE | PLT10*94.5 | +15.835 | +16.025 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | PLT10*94.5 | +15.835 | +16.025 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +15.725 | +16.129 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*344.6 | +15.700 | +16.045 | 4 | 99 | 16.8 | 0 | 17.5 | 0.3 | 344.6 | 16 | 512.1 | pb-178 | 0.29165 | 0.176455 | 0.000256 | 0.00214038 | 0.00214038
2 x PLATE | PLT10*94.5 | +9.885 | +10.033 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +9.725 | +10.204 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*347.3 | +9.880 | +10.234 | 3 | 99 | 12.1 | 0 | 17.5 | 0.2 | 347.3 | 16 | 354.2 | pa-219 | 0.213273 | 0.123025 | 0.000256 | 0.00155011 | 0.00155011
2 x PLATE | PLT10*94.5 | +5.901 | +6.049 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +5.730 | +6.210 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*347.3 | +5.700 | +6.054 | 3 | 99 | 12.1 | 0 | 17.5 | 0.2 | 347.3 | 16 | 354.2 | pa-219 | 0.213273 | 0.123025 | 0.000256 | 0.00155011 | 0.00155011
2 x PLATE | PLT10*94.5 | +4.952 | +5.089 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +4.782 | +5.269 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*358.6 | +4.950 | +5.344 | 3 | 99 | 14.4 | 0 | 17.5 | 0.2 | 358.6 | 16 | 394.7 | pa-218 | 0.248101 | 0.14155 | 0.000256 | 0.00181669 | 0.00181669
2 x PLATE | PLT10*94.5 | +0.298 | +0.435 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +0.117 | +0.604 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.8 | +0.040 | +0.437 | 3 | 99 | 14.1 | 0 | 17.5 | 0.2 | 352.8 | 16 | 397.2 | pa-217 | 0.247479 | 0.140139 | 0.000256 | 0.00181046 | 0.00181046
8 x PLATE | FL12*200 | +12.132 | +12.144 | 5 | 13 | 17.5 | 0.2 | 22.8 | 0.3 | 200 | 12 | 925 | 471-D-C488 | 0.397 | 0.397 | 0.0024 | 0.00222 | 0.00222
4 x PLATE | UC152*152*30 | +8.343 | +8.826 | 5 | 3 | 14.4 | 0 | 30 | 0.3 | 157.5 | 152.9 | 483.5 | mc-461 | 0.435321 | 0.435321 | 0.00382166 | 0.00183244 | 0.00184777
2 x PLATE | FL10*80 | +5.365 | +5.445 | 1 | 3 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | p010019 | 0.0304 | 0.0304 | 0.0008 | 0.000128 | 0.000128
6 x PLATE | PLT10*94.5 | +21.633 | +21.802 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +21.485 | +21.941 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353 | +21.460 | +21.813 | 4 | 99 | 31.6 | 0 | 16.9 | 0.5 | 353 | 16 | 812.4 | pb-190 | 0.537297 | 0.286789 | 0.000256 | 0.00402772 | 0.00402772
2 x PLATE | FL10*80 | +11.060 | +11.140 | 1 | 3 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | p010019 | 0.0304 | 0.0304 | 0.0008 | 0.000128 | 0.000128
2 x PLATE | FL10*80 | +9.065 | +9.145 | 1 | 3 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | p010019 | 0.0304 | 0.0304 | 0.0008 | 0.000128 | 0.000128
2 x PLATE | FL6*40 | +9.702 | +9.752 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +9.686 | +9.692 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
PLATE | PLT6*52 | +9.722 | +9.774 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
2 x PLATE | FL6*40 | +12.297 | +12.347 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +12.281 | +12.287 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
PLATE | PLT6*52 | +12.317 | +12.370 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
PLATE | PLT6*52 | +6.617 | +6.670 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
2 x PLATE | FL10*80 | +5.360 | +5.440 | 1 | 3 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | p010019 | 0.0304 | 0.0304 | 0.0008 | 0.000128 | 0.000128
2 x PLATE | FL6*40 | +6.598 | +6.648 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +6.582 | +6.588 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
6 x PLATE | PLT12*82.1 | +12.156 | +12.489 | 5 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pc-88 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
PLATE | PLT16*140 | +10.209 | +10.225 | 3 | 99 | 4.9 | 0 | 18.6 | 0.1 | 140 | 16 | 276.2 | pa-196 | 0.0889358 | 0.038668 | 0.000256 | 0.000608688 | 0.000608688
3 x PLATE | FL12*80 | +5.356 | +5.514 | 5 | 99 | 1.3 | 0 | 25.9 | 0 | 80 | 12 | 158.1 | pc-77 | 0.03068 | 0.012648 | 0.000144 | 0.000150426 | 0.000150426
3 x PLATE | FL12*80 | +5.530 | +5.688 | 5 | 99 | 1.3 | 0 | 25.9 | 0 | 80 | 12 | 158 | pc-77 | 0.0306616 | 0.01264 | 0.000144 | 0.00015033 | 0.00015033
PLATE | PLT16*140 | +5.319 | +5.335 | 3 | 99 | 4.9 | 0 | 18.6 | 0.1 | 140 | 16 | 276.2 | pa-196 | 0.0889358 | 0.038668 | 0.000256 | 0.000608688 | 0.000608688
PLATE | PLT16*140 | +5.319 | +5.335 | 5 | 99 | 4.9 | 0 | 18.6 | 0.1 | 140 | 16 | 276 | pc-218 | 0.0888734 | 0.03864 | 0.000256 | 0.00060824 | 0.00060824
PLATE | PLT16*140 | +5.317 | +5.333 | 3 | 99 | 4.9 | 0 | 18.6 | 0.1 | 140 | 16 | 276 | pa-196 | 0.0888734 | 0.03864 | 0.000256 | 0.00060824 | 0.00060824
2 x PLATE | FL10*80 | +24.178 | +24.258 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
2 x PLATE | FL10*80 | +17.910 | +17.990 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
2 x PLATE | FL10*80 | +21.200 | +21.280 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
6 x PLATE | PLT12*82.1 | +2.406 | +2.739 | 5 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pc-88 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
4 x PLATE | PLT12*82.1 | +2.406 | +2.738 | 5 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pc-88 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
2 x PLATE | FL6*40 | +30.177 | +30.227 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +30.161 | +30.167 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
PLATE | PLT6*52 | +30.197 | +30.250 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
PLATE | PLT6*52 | +19.167 | +19.220 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
2 x PLATE | FL6*40 | +22.558 | +22.608 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +22.541 | +22.547 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
2 x PLATE | FL6*40 | +19.148 | +19.198 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +19.131 | +19.137 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
2 x PLATE | PLT16*494.7 | +10.218 | +10.234 | 3 | 99 | 24.4 | 0.2 | 17.2 | 0.3 | 494.8 | 16 | 521.3 | pa-176 | 0.417233 | 0.257883 | 0.000256 | 0.00311241 | 0.00311241
4 x PLATE | PLT10*121.5 | +4.888 | +5.036 | 3 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pa-132 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
2 x PLATE | FL16*300 | +4.709 | +5.313 | 3 | 99 | 19.7 | 0 | 17.3 | 0.3 | 300 | 16 | 525 | pa-186 | 0.3414 | 0.3414 | 0.0048 | 0.00252 | 0.00252
PLATE | PLT16*452.1 | +4.892 | +5.344 | 3 | 99 | 43.6 | 0 | 16.8 | 0.6 | 452.1 | 16 | 870.2 | pa-137 | 0.73188 | 0.393428 | 0.000256 | 0.00554788 | 0.00554788
4 x PLATE | PLT10*121.5 | +5.909 | +6.072 | 3 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pa-132 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
2 x PLATE | FL16*300 | +5.725 | +6.245 | 3 | 99 | 16 | 0 | 17.5 | 0.3 | 300 | 16 | 425 | pa-153 | 0.2782 | 0.2782 | 0.0048 | 0.00204 | 0.00204
PLATE | PLT16*371.3 | +5.700 | +6.071 | 3 | 99 | 29.9 | 0 | 16.9 | 0.5 | 371.2 | 16 | 775.6 | pa-145 | 0.510101 | 0.287969 | 0.000256 | 0.00382002 | 0.00382002
4 x PLATE | PLT10*121.5 | +9.797 | +9.960 | 3 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pa-132 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
2 x PLATE | FL16*300 | +9.624 | +10.144 | 3 | 99 | 16 | 0 | 17.5 | 0.3 | 300 | 16 | 425 | pa-153 | 0.2782 | 0.2782 | 0.0048 | 0.00204 | 0.00204
2 x PLATE | PLT16*384 | +9.798 | +10.234 | 3 | 99 | 16.7 | 0 | 17.3 | 0.3 | 384 | 16 | 436.3 | pa-216 | 0.287357 | 0.167547 | 0.000256 | 0.00211609 | 0.00211609
4 x PLATE | PLT10*121.5 | +0.470 | +0.619 | 3 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pa-132 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
2 x PLATE | FL16*300 | +0.194 | +0.798 | 3 | 99 | 19.7 | 0 | 17.3 | 0.3 | 300 | 16 | 525 | pa-186 | 0.3414 | 0.3414 | 0.0048 | 0.00252 | 0.00252
2 x PLATE | PLT16*448.2 | +0.040 | +0.614 | 3 | 99 | 25 | 0 | 17.2 | 0.3 | 448.2 | 16 | 574.5 | pa-134 | 0.426282 | 0.257492 | 0.000256 | 0.00318192 | 0.00318192
3 x PLATE | FL16*250 | +10.615 | +11.061 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.5 | +10.590 | +10.943 | 3 | 99 | 14.1 | 0 | 17.5 | 0.2 | 352.5 | 16 | 428.2 | pa-212 | 0.247436 | 0.150995 | 0.000256 | 0.00180756 | 0.00180756
3 x PLATE | FL16*250 | +14.873 | +15.319 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.5 | +14.992 | +15.344 | 4 | 99 | 14.1 | 0 | 17.5 | 0.2 | 352.5 | 16 | 428.2 | pb-173 | 0.247436 | 0.150995 | 0.000256 | 0.00180756 | 0.00180756
2 x PLATE | PLT10*94.5 | +21.602 | +21.788 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +21.485 | +21.899 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*347 | +21.460 | +21.807 | 4 | 99 | 16.2 | 0 | 17.5 | 0.3 | 347 | 16 | 512.9 | pb-230 | 0.281219 | 0.177987 | 0.000256 | 0.00205919 | 0.00205919
2 x PLATE | PLT10*94.5 | +23.624 | +23.811 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +23.514 | +23.927 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*338.9 | +23.606 | +23.944 | 4 | 99 | 12.9 | 0 | 17.5 | 0.2 | 339 | 16 | 369.6 | pb-229 | 0.223376 | 0.125268 | 0.000256 | 0.00162681 | 0.00162681
3 x PLATE | FL16*250 | +24.343 | +24.782 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
3 x PLATE | PLT16*351.7 | +24.318 | +24.670 | 4 | 99 | 14.7 | 0 | 17.5 | 0.3 | 351.8 | 16 | 446.8 | pb-228 | 0.257516 | 0.157135 | 0.000256 | 0.00188367 | 0.00188367
4 x PLATE | PLT10*94.5 | +9.885 | +10.030 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +9.722 | +10.204 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-211 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353.5 | +9.881 | +10.234 | 5 | 99 | 25.8 | 0 | 17.2 | 0.3 | 353.5 | 16 | 680.7 | pc-214 | 0.438048 | 0.240591 | 0.000256 | 0.0032682 | 0.0032682
2 x PLATE | FL16*250 | +23.558 | +23.937 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*337.4 | +23.625 | +23.962 | 4 | 99 | 20.6 | 0 | 17.3 | 0.3 | 337.4 | 16 | 629.5 | pb-227 | 0.355387 | 0.212375 | 0.000256 | 0.00262064 | 0.00262064
2 x PLATE | FL16*250 | +21.485 | +21.864 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*337.4 | +21.460 | +21.797 | 4 | 99 | 20.6 | 0 | 17.3 | 0.3 | 337.4 | 16 | 629.5 | pb-227 | 0.355387 | 0.212375 | 0.000256 | 0.00262064 | 0.00262064
2 x PLATE | FL16*250 | +20.679 | +21.079 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*343.5 | +20.761 | +21.104 | 4 | 99 | 18.1 | 0 | 17.3 | 0.3 | 343.5 | 16 | 554.2 | pb-226 | 0.315384 | 0.190391 | 0.000256 | 0.00231973 | 0.00231973
2 x PLATE | FL16*250 | +18.075 | +18.475 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*343.5 | +18.050 | +18.394 | 4 | 99 | 18.1 | 0 | 17.3 | 0.3 | 343.5 | 16 | 554.2 | pb-226 | 0.315384 | 0.190391 | 0.000256 | 0.00231973 | 0.00231973
3 x PLATE | FL16*250 | +9.669 | +10.159 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
3 x PLATE | PLT16*340.2 | +9.843 | +10.234 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 340.3 | 16 | 390.9 | pa-213 | 0.231404 | 0.132994 | 0.000256 | 0.00168835 | 0.00168835
8 x PLATE | PLT10*94.5 | +0.369 | +0.487 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +0.175 | +0.668 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
4 x PLATE | PLT16*351.9 | +0.040 | +0.484 | 3 | 99 | 16.2 | 0 | 17.3 | 0.3 | 352 | 16 | 444.5 | pa-206 | 0.27856 | 0.156419 | 0.000256 | 0.0020467 | 0.0020467
17 x PLATE | PLT10*94.5 | +5.007 | +5.126 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
8 x PLATE | FL16*250 | +4.827 | +5.319 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*334.1 | +5.010 | +5.344 | 3 | 99 | 25 | 0 | 17.2 | 0.3 | 334.1 | 16 | 693.2 | pa-142 | 0.426332 | 0.231618 | 0.000256 | 0.00317411 | 0.00317411
8 x PLATE | PLT10*94.5 | +5.911 | +6.041 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +5.725 | +6.215 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*340.9 | +5.700 | +6.041 | 3 | 99 | 27.9 | 0 | 17.2 | 0.5 | 340.9 | 16 | 755.3 | pa-144 | 0.476663 | 0.257496 | 0.000256 | 0.00356032 | 0.00356032
PLATE | PLT16*494.7 | +5.328 | +5.344 | 3 | 99 | 24.4 | 0.2 | 17.2 | 0.3 | 494.8 | 16 | 521.3 | pa-176 | 0.417234 | 0.257884 | 0.000256 | 0.00311242 | 0.00311242
PLATE | PLT16*494.7 | +5.328 | +5.344 | 3 | 99 | 24.4 | 0.2 | 17.2 | 0.3 | 494.8 | 16 | 521.3 | pa-175 | 0.416442 | 0.257883 | 0.000256 | 0.00310619 | 0.00310619
PLATE | FL16*250 | +17.312 | +17.669 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*330.1 | +17.364 | +17.694 | 4 | 99 | 23.8 | 0 | 17.2 | 0.3 | 330.1 | 16 | 734.6 | pb-175 | 0.410933 | 0.2425 | 0.000256 | 0.00303813 | 0.00303813
PLATE | FL16*250 | +15.725 | +16.083 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*330.1 | +15.700 | +16.030 | 4 | 99 | 23.8 | 0 | 17.2 | 0.3 | 330.1 | 16 | 734.6 | pb-175 | 0.410933 | 0.2425 | 0.000256 | 0.00303813 | 0.00303813
PLATE | FL16*250 | +17.265 | +17.669 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*344.8 | +17.350 | +17.694 | 4 | 99 | 17.8 | 0 | 17.3 | 0.3 | 344.7 | 16 | 539.7 | pb-174 | 0.30762 | 0.186063 | 0.000256 | 0.00226129 | 0.00226129
PLATE | FL16*250 | +15.725 | +16.130 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*344.8 | +15.700 | +16.045 | 4 | 99 | 17.8 | 0 | 17.3 | 0.3 | 344.7 | 16 | 539.7 | pb-174 | 0.30762 | 0.186063 | 0.000256 | 0.00226129 | 0.00226129
PLATE | PLT16*352.5 | +14.992 | +15.344 | 4 | 99 | 14.1 | 0 | 17.5 | 0.2 | 352.5 | 16 | 428.2 | pb-173 | 0.247434 | 0.150994 | 0.000256 | 0.00180754 | 0.00180754
PLATE | FL16*250 | +14.827 | +15.309 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*343.4 | +14.986 | +15.344 | 4 | 99 | 11.9 | 0 | 17.5 | 0.2 | 343.5 | 16 | 358 | pb-172 | 0.209066 | 0.12295 | 0.000256 | 0.00151779 | 0.00151779
PLATE | FL16*250 | +10.625 | +11.107 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*343.4 | +10.590 | +10.948 | 3 | 99 | 11.9 | 0 | 17.5 | 0.2 | 343.5 | 16 | 358 | pa-215 | 0.209066 | 0.12295 | 0.000256 | 0.00151779 | 0.00151779
PLATE | FL16*250 | +9.730 | +10.209 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*342.5 | +9.885 | +10.234 | 3 | 99 | 11.6 | 0 | 17.7 | 0.2 | 342.5 | 16 | 349.3 | pa-214 | 0.20435 | 0.119617 | 0.000256 | 0.00148188 | 0.00148188
PLATE | FL16*250 | +9.664 | +10.154 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*343.9 | +9.838 | +10.234 | 3 | 99 | 13.7 | 0 | 17.5 | 0.2 | 343.9 | 16 | 395.9 | pa-211 | 0.236769 | 0.136177 | 0.000256 | 0.00172936 | 0.00172936
PLATE | PLT16*352.5 | +10.590 | +10.943 | 3 | 99 | 14.1 | 0 | 17.5 | 0.2 | 352.5 | 16 | 428.5 | pa-212 | 0.247521 | 0.151046 | 0.000256 | 0.0018082 | 0.0018082
PLATE | FL16*250 | +9.705 | +10.189 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*343.4 | +9.868 | +10.234 | 3 | 99 | 12.4 | 0 | 17.5 | 0.2 | 343.5 | 16 | 366.5 | pa-210 | 0.214798 | 0.125872 | 0.000256 | 0.00156155 | 0.00156155
PLATE | FL16*250 | +4.774 | +5.264 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*343.5 | +4.949 | +5.344 | 3 | 99 | 13.7 | 0 | 17.5 | 0.2 | 343.5 | 16 | 395.8 | pa-211 | 0.236481 | 0.13597 | 0.000256 | 0.00172714 | 0.00172714
PLATE | FL16*250 | +5.745 | +6.230 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*343.4 | +5.700 | +6.067 | 3 | 99 | 12.4 | 0 | 17.5 | 0.2 | 343.5 | 16 | 366.5 | pa-210 | 0.214798 | 0.125872 | 0.000256 | 0.00156155 | 0.00156155
PLATE | FL16*250 | +4.802 | +5.289 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*341.8 | +4.970 | +5.344 | 3 | 99 | 12.4 | 0 | 17.5 | 0.2 | 341.8 | 16 | 374.6 | pa-209 | 0.219557 | 0.128051 | 0.000256 | 0.00159785 | 0.00159785
PLATE | FL16*250 | +5.725 | +6.205 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*342.5 | +5.700 | +6.049 | 3 | 99 | 11.3 | 0 | 17.7 | 0.2 | 342.5 | 16 | 349.3 | pa-208 | 0.19977 | 0.119617 | 0.000256 | 0.0014465 | 0.0014465
2 x PLATE | PLT10*94.5 | +0.319 | +0.449 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +0.133 | +0.623 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353 | +0.040 | +0.449 | 3 | 99 | 14.7 | 0 | 17.5 | 0.3 | 353 | 16 | 408.9 | pa-207 | 0.255391 | 0.144389 | 0.000256 | 0.00187056 | 0.00187056
2 x PLATE | PLT10*94.5 | +0.289 | +0.426 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +0.108 | +0.595 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.9 | +0.040 | +0.428 | 3 | 99 | 13.7 | 0 | 17.5 | 0.2 | 353 | 16 | 387.6 | pa-205 | 0.241189 | 0.136758 | 0.000256 | 0.00176251 | 0.00176251
20 x PLATE | PLT10*94.5 | +6.019 | +6.137 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +5.825 | +6.318 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
4 x PLATE | PLT16*344 | +5.700 | +6.133 | 5 | 99 | 15.5 | 0 | 17.3 | 0.3 | 343.9 | 16 | 433.4 | pc-305 | 0.268077 | 0.149088 | 0.000256 | 0.0019689 | 0.0019689
20 x PLATE | PLT10*94.5 | +11.808 | +11.926 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT16*333.4 | +11.811 | +12.144 | 5 | 99 | 24.8 | 0 | 17.2 | 0.3 | 333.4 | 16 | 687.9 | pc-393 | 0.422054 | 0.229382 | 0.000256 | 0.00314129 | 0.00314129
3 x PLATE | PLT10*94.5 | +0.621 | +0.740 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +0.428 | +0.920 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*351.9 | +0.040 | +0.737 | 3 | 99 | 20.6 | 0 | 17.3 | 0.3 | 352 | 16 | 696.8 | pa-173 | 0.356464 | 0.245195 | 0.000256 | 0.00262043 | 0.00262043
PLATE | PLT10*94.5 | +0.621 | +0.740 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +0.827 | +0.923 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +0.623 | +1.114 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*345.6 | +0.040 | +0.915 | 3 | 99 | 25.2 | 0 | 17.3 | 0.3 | 345.6 | 16 | 874.7 | pa-172 | 0.436904 | 0.302306 | 0.000256 | 0.00321931 | 0.00321931
2 x PLATE | PLT10*94.5 | +4.814 | +4.910 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +4.623 | +5.114 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*342.1 | +4.822 | +5.344 | 3 | 99 | 19.4 | 0 | 17.2 | 0.3 | 342.1 | 16 | 522.1 | pa-171 | 0.336143 | 0.178587 | 0.000256 | 0.00248878 | 0.00248878
4 x PLATE | PLT10*94.5 | +6.092 | +6.194 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +5.890 | +6.382 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*338.4 | +5.700 | +6.187 | 3 | 99 | 17.6 | 0 | 17.3 | 0.3 | 338.4 | 16 | 486.7 | pa-170 | 0.305127 | 0.164681 | 0.000256 | 0.00225124 | 0.00225124
2 x PLATE | PLT10*94.5 | +9.741 | +9.843 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +9.552 | +10.044 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*338.4 | +9.748 | +10.234 | 3 | 99 | 17.6 | 0 | 17.3 | 0.3 | 338.4 | 16 | 486.7 | pa-170 | 0.305127 | 0.164681 | 0.000256 | 0.00225124 | 0.00225124
3 x PLATE | PLT10*94.5 | +5.007 | +5.126 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +4.827 | +5.319 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*334 | +5.010 | +5.344 | 3 | 99 | 26.3 | 0 | 17.2 | 0.3 | 334 | 16 | 724.5 | pa-188 | 0.448006 | 0.241919 | 0.000256 | 0.00333954 | 0.00333954
3 x PLATE | PLT20*140 | +5.345 | +5.365 | 3 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pa-42 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
4 x PLATE | PLT20*140 | +5.680 | +5.700 | 3 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pa-42 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
PLATE | PLT20*140 | +15.680 | +15.700 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pc-54 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
6 x PLATE | FL16*250 | +5.825 | +6.318 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-211 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
6 x PLATE | PLT16*344 | +5.700 | +6.133 | 5 | 99 | 15.5 | 0 | 17.3 | 0.3 | 343.9 | 16 | 433.4 | pc-261 | 0.268077 | 0.149088 | 0.000256 | 0.0019689 | 0.0019689
6 x PLATE | FL16*250 | +11.627 | +12.119 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-211 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
3 x PLATE | PLT16*333.4 | +11.811 | +12.144 | 5 | 99 | 24.8 | 0 | 17.2 | 0.3 | 333.4 | 16 | 687.9 | pc-213 | 0.422054 | 0.229382 | 0.000256 | 0.00314129 | 0.00314129
8 x PLATE | PLT10*94.5 | +10.881 | +11.004 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +10.690 | +11.182 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
4 x PLATE | PLT16*340.7 | +10.590 | +11.002 | 3 | 99 | 14.4 | 0 | 17.5 | 0.2 | 340.8 | 16 | 411.8 | pa-204 | 0.248695 | 0.140279 | 0.000256 | 0.00182057 | 0.00182057
8 x PLATE | PLT10*94.5 | +15.006 | +15.129 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +14.827 | +15.319 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*336.8 | +15.008 | +15.344 | 4 | 99 | 26 | 0 | 17.2 | 0.3 | 336.7 | 16 | 715.5 | pb-188 | 0.444318 | 0.240955 | 0.000256 | 0.0033121 | 0.0033121
2 x PLATE | PLT16*334.2 | +5.010 | +5.344 | 3 | 99 | 25 | 0 | 17.2 | 0.3 | 334.2 | 16 | 694 | pa-142 | 0.426929 | 0.231933 | 0.000256 | 0.00317869 | 0.00317869
3 x PLATE | PLT10*94.5 | +0.618 | +0.737 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +0.425 | +0.918 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352 | +0.040 | +0.734 | 3 | 99 | 20.5 | 0 | 17.3 | 0.3 | 352 | 16 | 694.4 | pa-201 | 0.355376 | 0.244398 | 0.000256 | 0.00261231 | 0.00261231
3 x PLATE | PLT10*94.5 | +0.618 | +0.737 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT16*351.9 | +0.040 | +0.735 | 3 | 99 | 20.5 | 0 | 17.3 | 0.3 | 352 | 16 | 694.6 | pa-201 | 0.355441 | 0.244446 | 0.000256 | 0.0026128 | 0.0026128
