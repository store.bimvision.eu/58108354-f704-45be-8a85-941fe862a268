Properties of the parts of a building model (IFC2X3), part 9 of 22

# IfcDiscreteAccessory: GUSSET PLATE (958)
Name | Description | Bottom elevation | Top elevation | Phase | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
GUSSET PLATE | PLT10*175.9 | +38.931 | +38.941 | 7 | 2.2 | 0 | 28.6 | 0.1 | 175.9 | 210.5 | pe-102 | 0.0617684 | 0.0370287 | 0.000275363 | 0.000275363
GUSSET PLATE | PLT10*175.9 | +38.931 | +38.941 | 7 | 2.1 | 0 | 28.6 | 0.1 | 175.9 | 206.9 | pe-101 | 0.0612643 | 0.0364086 | 0.000273102 | 0.000273102
GUSSET PLATE | PLT10*176.8 | +38.931 | +38.941 | 7 | 2.2 | 0 | 28.6 | 0.1 | 176.8 | 213.3 | pe-100 | 0.0620502 | 0.0377096 | 0.000276557 | 0.000276557
GUSSET PLATE | PLT10*176.8 | +38.931 | +38.941 | 7 | 2.1 | 0 | 28.6 | 0.1 | 176.8 | 207.5 | pe-99 | 0.0612663 | 0.0366903 | 0.00027306 | 0.00027306
GUSSET PLATE | PLT10*131.6 | +48.593 | +48.603 | 7 | 2.1 | 0 | 28.7 | 0.1 | 131.6 | 240.2 | pe-98 | 0.0596833 | 0.0316252 | 0.000264771 | 0.000264771
2 x GUSSET PLATE | PLT10*160.5 | +48.593 | +48.603 | 7 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pe-75 | 0.0703425 | 0.0421247 | 0.000314238 | 0.000314238
GUSSET PLATE | PLT10*142.5 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pe-97 | 0.0567125 | 0.0313561 | 0.000251411 | 0.000251411
2 x GUSSET PLATE | PLT10*170.5 | +48.593 | +48.603 | 7 | 2.3 | 0 | 28.5 | 0.1 | 170.5 | 228.6 | pe-77 | 0.064809 | 0.0389786 | 0.000289241 | 0.000289241
3 x GUSSET PLATE | PLT10*137.2 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 137.2 | 224.9 | pe-82 | 0.0568532 | 0.0308457 | 0.000251913 | 0.000251913
GUSSET PLATE | PLT10*142.5 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pe-96 | 0.0570691 | 0.0313561 | 0.000253165 | 0.000253165
GUSSET PLATE | PLT10*137.2 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 137.2 | 224.9 | pe-82 | 0.0568668 | 0.0308457 | 0.00025198 | 0.00025198
2 x GUSSET PLATE | PLT10*161.7 | +48.593 | +48.603 | 7 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258.3 | pe-95 | 0.0696695 | 0.0417649 | 0.000311211 | 0.000311211
2 x GUSSET PLATE | PLT10*161.7 | +48.593 | +48.603 | 7 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258.3 | pe-95 | 0.0696695 | 0.0417648 | 0.000311211 | 0.000311211
2 x GUSSET PLATE | PLT10*170.6 | +48.593 | +48.603 | 7 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pe-77 | 0.0647785 | 0.0389599 | 0.000289103 | 0.000289103
2 x GUSSET PLATE | PLT10*170.6 | +48.593 | +48.603 | 7 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pe-80 | 0.0658454 | 0.0396423 | 0.000294059 | 0.000294059
GUSSET PLATE | PLT10*147.9 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 147.8 | 214.9 | pe-89 | 0.056983 | 0.0317733 | 0.00025281 | 0.00025281
GUSSET PLATE | PLT10*141.2 | +48.593 | +48.603 | 7 | 2.2 | 0 | 28.6 | 0.1 | 141.2 | 245.2 | pe-88 | 0.0637481 | 0.0346233 | 0.000284111 | 0.000284111
GUSSET PLATE | PLT10*136.9 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pe-82 | 0.0568741 | 0.0308272 | 0.000252002 | 0.000252002
GUSSET PLATE | PLT10*140.9 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pe-81 | 0.0576086 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*158.2 | +48.593 | +48.603 | 7 | 2.6 | 0 | 28.5 | 0.1 | 158.2 | 274.9 | pe-87 | 0.0727471 | 0.0434829 | 0.000325168 | 0.000325168
GUSSET PLATE | PLT10*142.4 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 222.4 | pe-86 | 0.0571438 | 0.0316716 | 0.000253306 | 0.000253306
GUSSET PLATE | PLT10*141.1 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 141.1 | 217.2 | pe-85 | 0.0555457 | 0.0306329 | 0.000245958 | 0.000245958
GUSSET PLATE | PLT10*157.7 | +48.593 | +48.603 | 7 | 2.6 | 0 | 28.5 | 0.1 | 157.7 | 276.6 | pe-84 | 0.0730228 | 0.0436243 | 0.000326405 | 0.000326405
GUSSET PLATE | PLT10*141.2 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 141.2 | 224.4 | pe-83 | 0.0574568 | 0.0316857 | 0.000254735 | 0.000254735
GUSSET PLATE | PLT10*140.9 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pe-81 | 0.0576085 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*136.9 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pe-82 | 0.056874 | 0.0308272 | 0.000252001 | 0.000252001
2 x GUSSET PLATE | PLT10*140.8 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.5 | pe-81 | 0.0576789 | 0.0317475 | 0.00025575 | 0.00025575
GUSSET PLATE | PLT10*170.6 | +48.593 | +48.603 | 7 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pe-80 | 0.0658269 | 0.0396316 | 0.000293974 | 0.000293974
GUSSET PLATE | PLT10*170.6 | +48.593 | +48.603 | 7 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pe-80 | 0.0658459 | 0.0396423 | 0.000294061 | 0.000294061
GUSSET PLATE | PLT10*144.4 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.6 | pe-79 | 0.0560827 | 0.0312867 | 0.000248473 | 0.000248473
GUSSET PLATE | PLT10*163 | +48.593 | +48.603 | 7 | 2.1 | 0 | 28.6 | 0.1 | 163 | 209.2 | pe-78 | 0.0590361 | 0.0341005 | 0.000262746 | 0.000262746
GUSSET PLATE | PLT10*170.6 | +48.593 | +48.603 | 7 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pe-77 | 0.064779 | 0.0389599 | 0.000289105 | 0.000289105
GUSSET PLATE | PLT10*170.6 | +48.593 | +48.603 | 7 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pe-77 | 0.0647598 | 0.038949 | 0.000289018 | 0.000289018
GUSSET PLATE | PLT10*169.5 | +48.593 | +48.603 | 7 | 2.3 | 0 | 28.5 | 0.1 | 169.5 | 232.1 | pe-76 | 0.0654016 | 0.0393392 | 0.000291932 | 0.000291932
GUSSET PLATE | PLT10*160.4 | +48.593 | +48.603 | 7 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.9 | pe-75 | 0.0704233 | 0.0421679 | 0.000314601 | 0.000314601
GUSSET PLATE | PLT10*160.5 | +48.593 | +48.603 | 7 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pe-75 | 0.0703419 | 0.0421247 | 0.000314235 | 0.000314235
2 x GUSSET PLATE | PLT10*142.5 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pe-97 | 0.0567125 | 0.0313561 | 0.000251411 | 0.000251411
3 x GUSSET PLATE | PLT10*160.5 | +44.468 | +44.478 | 7 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pe-75 | 0.0703425 | 0.0421247 | 0.000314238 | 0.000314238
2 x GUSSET PLATE | PLT10*170.5 | +44.468 | +44.478 | 7 | 2.3 | 0 | 28.5 | 0.1 | 170.5 | 228.6 | pe-77 | 0.064809 | 0.0389786 | 0.000289241 | 0.000289241
3 x GUSSET PLATE | PLT10*137.2 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 137.2 | 224.9 | pe-82 | 0.0568532 | 0.0308457 | 0.000251913 | 0.000251913
GUSSET PLATE | PLT10*142.5 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pe-96 | 0.0570691 | 0.0313561 | 0.000253165 | 0.000253165
GUSSET PLATE | PLT10*137.2 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 137.2 | 224.9 | pe-82 | 0.0568668 | 0.0308457 | 0.00025198 | 0.00025198
2 x GUSSET PLATE | PLT10*161.7 | +44.468 | +44.478 | 7 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258.3 | pe-95 | 0.0696695 | 0.0417649 | 0.000311211 | 0.000311211
2 x GUSSET PLATE | PLT10*161.7 | +44.468 | +44.478 | 7 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258.3 | pe-95 | 0.0696695 | 0.0417648 | 0.000311211 | 0.000311211
GUSSET PLATE | PLT10*154.1 | +44.468 | +44.478 | 7 | 2.6 | 0 | 28.5 | 0.1 | 154.1 | 286.6 | pe-94 | 0.0742776 | 0.0441647 | 0.000331879 | 0.000331879
GUSSET PLATE | PLT10*134.1 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 134.1 | 232.6 | pe-93 | 0.0582392 | 0.0311895 | 0.000258209 | 0.000258209
GUSSET PLATE | PLT10*134.5 | +44.468 | +44.478 | 7 | 2.5 | 0 | 28.5 | 0.1 | 134.5 | 270.7 | pe-92 | 0.0693675 | 0.03641 | 0.000310024 | 0.000310024
2 x GUSSET PLATE | PLT10*154.5 | +44.468 | +44.478 | 7 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 267.3 | pe-90 | 0.0696028 | 0.0412969 | 0.000310369 | 0.000310369
2 x GUSSET PLATE | PLT10*163.5 | +44.468 | +44.478 | 7 | 2.2 | 0 | 28.6 | 0.1 | 163.5 | 234.3 | pe-91 | 0.0640416 | 0.0383117 | 0.000285283 | 0.000285283
GUSSET PLATE | PLT10*163.6 | +44.468 | +44.478 | 7 | 2.2 | 0 | 28.6 | 0.1 | 163.6 | 234.1 | pe-91 | 0.0640219 | 0.0383005 | 0.000285194 | 0.000285194
2 x GUSSET PLATE | PLT10*163.5 | +44.468 | +44.478 | 7 | 2.2 | 0 | 28.6 | 0.1 | 163.5 | 235.1 | pe-91 | 0.0642625 | 0.0384507 | 0.000286306 | 0.000286306
2 x GUSSET PLATE | PLT10*154.5 | +44.468 | +44.478 | 7 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 268.1 | pe-90 | 0.0698163 | 0.0414282 | 0.000311354 | 0.000311354
GUSSET PLATE | PLT10*163.6 | +44.468 | +44.478 | 7 | 2.2 | 0 | 28.6 | 0.1 | 163.6 | 235 | pe-91 | 0.0642428 | 0.0384395 | 0.000286217 | 0.000286217
GUSSET PLATE | PLT10*154.5 | +44.468 | +44.478 | 7 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 267.3 | pe-90 | 0.0696159 | 0.0412969 | 0.000310433 | 0.000310433
GUSSET PLATE | PLT10*170.6 | +44.468 | +44.478 | 7 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pe-77 | 0.0647785 | 0.0389599 | 0.000289103 | 0.000289103
GUSSET PLATE | PLT10*170.6 | +44.468 | +44.478 | 7 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pe-80 | 0.0658454 | 0.0396423 | 0.000294059 | 0.000294059
GUSSET PLATE | PLT10*147.9 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 147.8 | 214.9 | pe-89 | 0.056983 | 0.0317733 | 0.00025281 | 0.00025281
GUSSET PLATE | PLT10*141.2 | +44.468 | +44.478 | 7 | 2.2 | 0 | 28.6 | 0.1 | 141.2 | 245.2 | pe-88 | 0.0637481 | 0.0346233 | 0.000284111 | 0.000284111
GUSSET PLATE | PLT10*136.9 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pe-82 | 0.0568741 | 0.0308272 | 0.000252002 | 0.000252002
GUSSET PLATE | PLT10*140.9 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pe-81 | 0.0576086 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*158.2 | +44.468 | +44.478 | 7 | 2.6 | 0 | 28.5 | 0.1 | 158.2 | 274.9 | pe-87 | 0.0727471 | 0.0434829 | 0.000325168 | 0.000325168
GUSSET PLATE | PLT10*142.4 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 222.4 | pe-86 | 0.0571438 | 0.0316716 | 0.000253306 | 0.000253306
GUSSET PLATE | PLT10*141.1 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 141.1 | 217.2 | pe-85 | 0.0555457 | 0.0306329 | 0.000245958 | 0.000245958
GUSSET PLATE | PLT10*157.7 | +44.468 | +44.478 | 7 | 2.6 | 0 | 28.5 | 0.1 | 157.7 | 276.6 | pe-84 | 0.0730228 | 0.0436243 | 0.000326405 | 0.000326405
GUSSET PLATE | PLT10*141.2 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 141.2 | 224.4 | pe-83 | 0.0574568 | 0.0316857 | 0.000254735 | 0.000254735
GUSSET PLATE | PLT10*140.9 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pe-81 | 0.0576085 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*136.9 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pe-82 | 0.056874 | 0.0308272 | 0.000252001 | 0.000252001
2 x GUSSET PLATE | PLT10*140.8 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.5 | pe-81 | 0.0576789 | 0.0317475 | 0.00025575 | 0.00025575
GUSSET PLATE | PLT10*144.4 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.4 | pe-79 | 0.0560392 | 0.0312583 | 0.00024827 | 0.00024827
GUSSET PLATE | PLT10*170.6 | +44.468 | +44.478 | 7 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pe-80 | 0.0658269 | 0.0396316 | 0.000293974 | 0.000293974
GUSSET PLATE | PLT10*170.6 | +44.468 | +44.478 | 7 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pe-80 | 0.0658459 | 0.0396423 | 0.000294061 | 0.000294061
GUSSET PLATE | PLT10*144.4 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.6 | pe-79 | 0.0560827 | 0.0312867 | 0.000248473 | 0.000248473
GUSSET PLATE | PLT10*163 | +44.468 | +44.478 | 7 | 2.1 | 0 | 28.6 | 0.1 | 163 | 209.2 | pe-78 | 0.0590361 | 0.0341005 | 0.000262746 | 0.000262746
2 x GUSSET PLATE | PLT10*160.4 | +44.468 | +44.478 | 7 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.9 | pe-75 | 0.0704233 | 0.0421679 | 0.000314601 | 0.000314601
GUSSET PLATE | PLT10*170.6 | +44.468 | +44.478 | 7 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pe-77 | 0.064779 | 0.0389599 | 0.000289105 | 0.000289105
GUSSET PLATE | PLT10*170.6 | +44.468 | +44.478 | 7 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pe-77 | 0.0647598 | 0.038949 | 0.000289018 | 0.000289018
GUSSET PLATE | PLT10*169.5 | +44.468 | +44.478 | 7 | 2.3 | 0 | 28.5 | 0.1 | 169.5 | 232.1 | pe-76 | 0.0654016 | 0.0393392 | 0.000291932 | 0.000291932
GUSSET PLATE | PLT10*160.5 | +44.468 | +44.478 | 7 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pe-75 | 0.0703419 | 0.0421247 | 0.000314235 | 0.000314235
GUSSET PLATE | PLT10*142.5 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pd-95 | 0.0567125 | 0.0313561 | 0.000251411 | 0.000251411
3 x GUSSET PLATE | PLT10*160.5 | +36.163 | +36.173 | 6 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pd-56 | 0.0703425 | 0.0421247 | 0.000314238 | 0.000314238
GUSSET PLATE | PLT10*155 | +36.163 | +36.173 | 6 | 2.1 | 0 | 28.6 | 0.1 | 155 | 219.7 | pd-90 | 0.0595967 | 0.0340794 | 0.000265097 | 0.000265097
GUSSET PLATE | PLT10*180.4 | +36.163 | +36.173 | 6 | 2.1 | 0 | 28.6 | 0.1 | 180.4 | 194.4 | pd-92 | 0.0589259 | 0.0350547 | 0.000262276 | 0.000262276
GUSSET PLATE | PLT10*172.7 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 172.7 | 185.5 | pd-94 | 0.0548532 | 0.0320188 | 0.000243335 | 0.000243335
GUSSET PLATE | PLT10*179.2 | +36.163 | +36.173 | 6 | 2.1 | 0 | 28.6 | 0.1 | 179.1 | 198.9 | pd-93 | 0.0597473 | 0.0356481 | 0.000266067 | 0.000266067
GUSSET PLATE | PLT10*170.6 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 170.6 | 185.8 | pd-91 | 0.0544331 | 0.0317012 | 0.000241368 | 0.000241368
GUSSET PLATE | PLT10*180.4 | +36.163 | +36.173 | 6 | 2.1 | 0 | 28.6 | 0.1 | 180.4 | 194.4 | pd-92 | 0.0589415 | 0.0350743 | 0.000262346 | 0.000262346
GUSSET PLATE | PLT10*170.5 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 170.5 | 185.8 | pd-91 | 0.0544139 | 0.0316863 | 0.000241278 | 0.000241278
GUSSET PLATE | PLT10*170.4 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 170.5 | 185.8 | pd-91 | 0.054401 | 0.0316703 | 0.00024122 | 0.00024122
GUSSET PLATE | PLT10*170.5 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 170.5 | 185.8 | pd-91 | 0.0544202 | 0.0316851 | 0.00024131 | 0.00024131
GUSSET PLATE | PLT10*155 | +36.163 | +36.173 | 6 | 2.1 | 0 | 28.6 | 0.1 | 155 | 219.7 | pd-90 | 0.0595869 | 0.0340663 | 0.000265051 | 0.000265051
GUSSET PLATE | PLT10*155.1 | +36.163 | +36.173 | 6 | 2.1 | 0 | 28.6 | 0.1 | 155.2 | 219.7 | pd-90 | 0.0596128 | 0.0340875 | 0.000265175 | 0.000265175
GUSSET PLATE | PLT10*155.1 | +36.163 | +36.173 | 6 | 2.1 | 0 | 28.6 | 0.1 | 155.2 | 219.7 | pd-90 | 0.0596226 | 0.0341006 | 0.00026522 | 0.00026522
GUSSET PLATE | PLT10*181.9 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.6 | 0.1 | 181.9 | 185.5 | pd-89 | 0.0574192 | 0.0337444 | 0.000255345 | 0.000255345
GUSSET PLATE | PLT10*181.9 | +36.163 | +36.173 | 6 | 2.1 | 0 | 28.6 | 0.1 | 181.9 | 188.5 | pd-88 | 0.0598932 | 0.0342683 | 0.000267204 | 0.000267204
GUSSET PLATE | PLT10*169 | +36.163 | +36.173 | 6 | 2.3 | 0 | 28.5 | 0.1 | 168.9 | 233.5 | pd-87 | 0.0656237 | 0.0394722 | 0.00029294 | 0.00029294
GUSSET PLATE | PLT10*169 | +36.163 | +36.173 | 6 | 2.3 | 0 | 28.5 | 0.1 | 168.9 | 240.7 | pd-86 | 0.0665783 | 0.0406873 | 0.000297163 | 0.000297163
GUSSET PLATE | PLT10*170.9 | +36.163 | +36.173 | 6 | 2.3 | 0 | 28.5 | 0.1 | 171 | 227.4 | pd-85 | 0.0646208 | 0.038863 | 0.000288386 | 0.000288386
GUSSET PLATE | PLT10*170.9 | +36.163 | +36.173 | 6 | 2.3 | 0 | 28.5 | 0.1 | 171 | 234.3 | pd-84 | 0.0655331 | 0.0400316 | 0.000292429 | 0.000292429
GUSSET PLATE | PLT10*140.4 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 140.4 | 216 | pd-83 | 0.0551249 | 0.0303328 | 0.000244004 | 0.000244004
GUSSET PLATE | PLT10*140.5 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 140.4 | 216 | pd-83 | 0.055144 | 0.0303516 | 0.000244095 | 0.000244095
GUSSET PLATE | PLT10*160.6 | +36.163 | +36.173 | 6 | 2.5 | 0 | 28.5 | 0.1 | 160.6 | 262.3 | pd-56 | 0.0703206 | 0.042113 | 0.00031414 | 0.00031414
3 x GUSSET PLATE | PLT10*137.2 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 137.2 | 224.9 | pd-63 | 0.0568532 | 0.0308457 | 0.000251913 | 0.000251913
GUSSET PLATE | PLT10*142.5 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pd-77 | 0.0570691 | 0.0313561 | 0.000253165 | 0.000253165
GUSSET PLATE | PLT10*137.2 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 137.2 | 224.9 | pd-63 | 0.0568668 | 0.0308457 | 0.00025198 | 0.00025198
2 x GUSSET PLATE | PLT10*161.7 | +36.163 | +36.173 | 6 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258.3 | pd-76 | 0.0696695 | 0.0417649 | 0.000311211 | 0.000311211
2 x GUSSET PLATE | PLT10*161.7 | +36.163 | +36.173 | 6 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258.3 | pd-76 | 0.0696695 | 0.0417648 | 0.000311211 | 0.000311211
GUSSET PLATE | PLT10*141.8 | +36.163 | +36.173 | 6 | 2.9 | 0 | 28.5 | 0.1 | 141.8 | 345.9 | pd-75 | 0.0844385 | 0.0490526 | 0.00037736 | 0.00037736
GUSSET PLATE | PLT10*141.8 | +36.163 | +36.173 | 6 | 2.9 | 0 | 28.5 | 0.1 | 141.8 | 345.9 | pd-75 | 0.0844385 | 0.0490526 | 0.000377359 | 0.000377359
GUSSET PLATE | PLT10*202.2 | +36.163 | +36.173 | 6 | 4 | 0.1 | 27.8 | 0.1 | 202.2 | 259.3 | pd-48 | 0.109999 | 0.0524431 | 0.000505891 | 0.000505891
GUSSET PLATE | PLT10*154.1 | +36.163 | +36.173 | 6 | 2.6 | 0 | 28.5 | 0.1 | 154.1 | 286.6 | pd-74 | 0.0742776 | 0.0441647 | 0.000331879 | 0.000331879
GUSSET PLATE | PLT10*134.1 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 134.1 | 232.6 | pd-73 | 0.0582392 | 0.0311895 | 0.000258209 | 0.000258209
GUSSET PLATE | PLT10*134.5 | +36.163 | +36.173 | 6 | 2.5 | 0 | 28.5 | 0.1 | 134.5 | 270.7 | pd-72 | 0.0693675 | 0.03641 | 0.000310024 | 0.000310024
2 x GUSSET PLATE | PLT10*154.5 | +36.163 | +36.173 | 6 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 267.3 | pd-70 | 0.0696028 | 0.0412969 | 0.000310369 | 0.000310369
2 x GUSSET PLATE | PLT10*163.5 | +36.163 | +36.173 | 6 | 2.2 | 0 | 28.6 | 0.1 | 163.5 | 234.3 | pd-71 | 0.0640416 | 0.0383117 | 0.000285283 | 0.000285283
GUSSET PLATE | PLT10*163.6 | +36.163 | +36.173 | 6 | 2.2 | 0 | 28.6 | 0.1 | 163.6 | 234.1 | pd-71 | 0.0640219 | 0.0383005 | 0.000285194 | 0.000285194
2 x GUSSET PLATE | PLT10*163.5 | +36.163 | +36.173 | 6 | 2.2 | 0 | 28.6 | 0.1 | 163.5 | 235.1 | pd-71 | 0.0642625 | 0.0384507 | 0.000286306 | 0.000286306
2 x GUSSET PLATE | PLT10*154.5 | +36.163 | +36.173 | 6 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 268.1 | pd-70 | 0.0698163 | 0.0414282 | 0.000311354 | 0.000311354
GUSSET PLATE | PLT10*163.6 | +36.163 | +36.173 | 6 | 2.2 | 0 | 28.6 | 0.1 | 163.6 | 235 | pd-71 | 0.0642428 | 0.0384395 | 0.000286217 | 0.000286217
GUSSET PLATE | PLT10*154.5 | +36.163 | +36.173 | 6 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 267.3 | pd-70 | 0.0696159 | 0.0412969 | 0.000310433 | 0.000310433
GUSSET PLATE | PLT10*170.6 | +36.163 | +36.173 | 6 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pd-58 | 0.0647785 | 0.0389599 | 0.000289103 | 0.000289103
GUSSET PLATE | PLT10*170.6 | +36.163 | +36.173 | 6 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pd-61 | 0.0658454 | 0.0396423 | 0.000294059 | 0.000294059
GUSSET PLATE | PLT10*147.9 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 147.8 | 214.9 | pd-69 | 0.056983 | 0.0317733 | 0.00025281 | 0.00025281
GUSSET PLATE | PLT10*141.2 | +36.163 | +36.173 | 6 | 2.2 | 0 | 28.6 | 0.1 | 141.2 | 245.2 | pd-68 | 0.0637481 | 0.0346233 | 0.000284111 | 0.000284111
GUSSET PLATE | PLT10*141.1 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 141.1 | 217.2 | pd-82 | 0.0555457 | 0.0306329 | 0.000245958 | 0.000245958
GUSSET PLATE | PLT10*157.7 | +36.163 | +36.173 | 6 | 2.6 | 0 | 28.5 | 0.1 | 157.7 | 276.6 | pd-65 | 0.0730228 | 0.0436243 | 0.000326405 | 0.000326405
GUSSET PLATE | PLT10*141.2 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 141.2 | 224.4 | pd-64 | 0.0574568 | 0.0316857 | 0.000254735 | 0.000254735
GUSSET PLATE | PLT10*170.6 | +36.163 | +36.173 | 6 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pd-61 | 0.0658269 | 0.0396316 | 0.000293974 | 0.000293974
GUSSET PLATE | PLT10*170.6 | +36.163 | +36.173 | 6 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pd-61 | 0.0658459 | 0.0396423 | 0.000294061 | 0.000294061
GUSSET PLATE | PLT10*144.4 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.6 | pd-60 | 0.0560827 | 0.0312867 | 0.000248473 | 0.000248473
GUSSET PLATE | PLT10*163 | +36.163 | +36.173 | 6 | 2.1 | 0 | 28.6 | 0.1 | 163 | 209.2 | pd-59 | 0.0590361 | 0.0341005 | 0.000262746 | 0.000262746
GUSSET PLATE | PLT10*170.6 | +36.163 | +36.173 | 6 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pd-58 | 0.064779 | 0.0389599 | 0.000289105 | 0.000289105
GUSSET PLATE | PLT10*170.6 | +36.163 | +36.173 | 6 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pd-58 | 0.0647598 | 0.038949 | 0.000289018 | 0.000289018
GUSSET PLATE | PLT10*169.5 | +36.163 | +36.173 | 6 | 2.3 | 0 | 28.5 | 0.1 | 169.5 | 232.1 | pd-57 | 0.0654016 | 0.0393392 | 0.000291932 | 0.000291932
GUSSET PLATE | PLT10*160.4 | +36.163 | +36.173 | 6 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.9 | pd-56 | 0.0704233 | 0.0421679 | 0.000314601 | 0.000314601
GUSSET PLATE | PLT10*160.5 | +36.163 | +36.173 | 6 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pd-56 | 0.0703419 | 0.0421247 | 0.000314235 | 0.000314235
GUSSET PLATE | PLT10*175.9 | +28.973 | +28.983 | 6 | 2.2 | 0 | 28.6 | 0.1 | 175.9 | 210.5 | pd-81 | 0.0617684 | 0.0370287 | 0.000275363 | 0.000275363
GUSSET PLATE | PLT10*175.9 | +28.973 | +28.983 | 6 | 2.1 | 0 | 28.6 | 0.1 | 175.9 | 206.9 | pd-80 | 0.0612643 | 0.0364086 | 0.000273102 | 0.000273102
GUSSET PLATE | PLT10*176.8 | +28.973 | +28.983 | 6 | 2.2 | 0 | 28.6 | 0.1 | 176.8 | 213.3 | pd-79 | 0.0620502 | 0.0377096 | 0.000276557 | 0.000276557
GUSSET PLATE | PLT10*176.8 | +28.973 | +28.983 | 6 | 2.1 | 0 | 28.6 | 0.1 | 176.8 | 207.5 | pd-78 | 0.0612663 | 0.0366903 | 0.00027306 | 0.00027306
GUSSET PLATE | PLT10*142.5 | +28.973 | +28.983 | 6 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pd-77 | 0.0570691 | 0.0313561 | 0.000253165 | 0.000253165
2 x GUSSET PLATE | PLT10*161.7 | +28.973 | +28.983 | 6 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258.3 | pd-76 | 0.0696695 | 0.0417649 | 0.000311211 | 0.000311211
2 x GUSSET PLATE | PLT10*161.7 | +28.973 | +28.983 | 6 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258.3 | pd-76 | 0.0696695 | 0.0417648 | 0.000311211 | 0.000311211
GUSSET PLATE | PLT10*141.8 | +28.973 | +28.983 | 6 | 2.9 | 0 | 28.5 | 0.1 | 141.8 | 345.9 | pd-75 | 0.0844385 | 0.0490526 | 0.00037736 | 0.00037736
GUSSET PLATE | PLT10*141.8 | +28.973 | +28.983 | 6 | 2.9 | 0 | 28.5 | 0.1 | 141.8 | 345.9 | pd-75 | 0.0844385 | 0.0490526 | 0.000377359 | 0.000377359
GUSSET PLATE | PLT10*202.2 | +28.973 | +28.983 | 6 | 4 | 0.1 | 27.8 | 0.1 | 202.2 | 259.3 | pd-48 | 0.109999 | 0.0524431 | 0.000505891 | 0.000505891
GUSSET PLATE | PLT10*154.1 | +28.973 | +28.983 | 6 | 2.6 | 0 | 28.5 | 0.1 | 154.1 | 286.6 | pd-74 | 0.0742776 | 0.0441647 | 0.000331879 | 0.000331879
GUSSET PLATE | PLT10*134.1 | +28.973 | +28.983 | 6 | 1.9 | 0 | 28.7 | 0.1 | 134.1 | 232.6 | pd-73 | 0.0582392 | 0.0311895 | 0.000258209 | 0.000258209
GUSSET PLATE | PLT10*134.5 | +28.973 | +28.983 | 6 | 2.5 | 0 | 28.5 | 0.1 | 134.5 | 270.7 | pd-72 | 0.0693675 | 0.03641 | 0.000310024 | 0.000310024
2 x GUSSET PLATE | PLT10*154.5 | +28.973 | +28.983 | 6 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 267.3 | pd-70 | 0.0696028 | 0.0412969 | 0.000310369 | 0.000310369
2 x GUSSET PLATE | PLT10*163.5 | +28.973 | +28.983 | 6 | 2.2 | 0 | 28.6 | 0.1 | 163.5 | 234.3 | pd-71 | 0.0640416 | 0.0383117 | 0.000285283 | 0.000285283
GUSSET PLATE | PLT10*163.6 | +28.973 | +28.983 | 6 | 2.2 | 0 | 28.6 | 0.1 | 163.6 | 234.1 | pd-71 | 0.0640219 | 0.0383005 | 0.000285194 | 0.000285194
2 x GUSSET PLATE | PLT10*163.5 | +28.973 | +28.983 | 6 | 2.2 | 0 | 28.6 | 0.1 | 163.5 | 235.1 | pd-71 | 0.0642625 | 0.0384507 | 0.000286306 | 0.000286306
2 x GUSSET PLATE | PLT10*154.5 | +28.973 | +28.983 | 6 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 268.1 | pd-70 | 0.0698163 | 0.0414282 | 0.000311354 | 0.000311354
GUSSET PLATE | PLT10*163.6 | +28.973 | +28.983 | 6 | 2.2 | 0 | 28.6 | 0.1 | 163.6 | 235 | pd-71 | 0.0642428 | 0.0384395 | 0.000286217 | 0.000286217
GUSSET PLATE | PLT10*154.5 | +28.973 | +28.983 | 6 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 267.3 | pd-70 | 0.0696159 | 0.0412969 | 0.000310433 | 0.000310433
2 x GUSSET PLATE | PLT10*170.6 | +28.973 | +28.983 | 6 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pd-58 | 0.0647785 | 0.0389599 | 0.000289103 | 0.000289103
2 x GUSSET PLATE | PLT10*170.6 | +28.973 | +28.983 | 6 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pd-61 | 0.0658454 | 0.0396423 | 0.000294059 | 0.000294059
GUSSET PLATE | PLT10*147.9 | +28.973 | +28.983 | 6 | 1.9 | 0 | 28.7 | 0.1 | 147.8 | 214.9 | pd-69 | 0.056983 | 0.0317733 | 0.00025281 | 0.00025281
GUSSET PLATE | PLT10*141.2 | +28.973 | +28.983 | 6 | 2.2 | 0 | 28.6 | 0.1 | 141.2 | 245.2 | pd-68 | 0.0637481 | 0.0346233 | 0.000284111 | 0.000284111
GUSSET PLATE | PLT10*136.9 | +28.973 | +28.983 | 6 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pd-63 | 0.0568741 | 0.0308272 | 0.000252002 | 0.000252002
GUSSET PLATE | PLT10*140.9 | +28.973 | +28.983 | 6 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pd-62 | 0.0576086 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*158.2 | +28.973 | +28.983 | 6 | 2.6 | 0 | 28.5 | 0.1 | 158.2 | 274.9 | pd-67 | 0.0727471 | 0.0434829 | 0.000325168 | 0.000325168
GUSSET PLATE | PLT10*142.4 | +28.973 | +28.983 | 6 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 222.4 | pd-66 | 0.0571438 | 0.0316716 | 0.000253306 | 0.000253306
GUSSET PLATE | PLT10*157.7 | +28.973 | +28.983 | 6 | 2.6 | 0 | 28.5 | 0.1 | 157.7 | 276.6 | pd-65 | 0.0730228 | 0.0436243 | 0.000326405 | 0.000326405
GUSSET PLATE | PLT10*141.2 | +28.973 | +28.983 | 6 | 1.9 | 0 | 28.7 | 0.1 | 141.2 | 224.4 | pd-64 | 0.0574568 | 0.0316857 | 0.000254735 | 0.000254735
GUSSET PLATE | PLT10*140.9 | +28.973 | +28.983 | 6 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pd-62 | 0.0576085 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*136.9 | +28.973 | +28.983 | 6 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pd-63 | 0.056874 | 0.0308272 | 0.000252001 | 0.000252001
2 x GUSSET PLATE | PLT10*140.8 | +28.973 | +28.983 | 6 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.5 | pd-62 | 0.0576789 | 0.0317475 | 0.00025575 | 0.00025575
GUSSET PLATE | PLT10*170.6 | +28.973 | +28.983 | 6 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pd-61 | 0.0658269 | 0.0396316 | 0.000293974 | 0.000293974
GUSSET PLATE | PLT10*170.6 | +28.973 | +28.983 | 6 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pd-61 | 0.0658459 | 0.0396423 | 0.000294061 | 0.000294061
GUSSET PLATE | PLT10*144.4 | +28.973 | +28.983 | 6 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.6 | pd-60 | 0.0560827 | 0.0312867 | 0.000248473 | 0.000248473
GUSSET PLATE | PLT10*163 | +28.973 | +28.983 | 6 | 2.1 | 0 | 28.6 | 0.1 | 163 | 209.2 | pd-59 | 0.0590361 | 0.0341005 | 0.000262746 | 0.000262746
GUSSET PLATE | PLT10*170.6 | +28.973 | +28.983 | 6 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pd-58 | 0.064779 | 0.0389599 | 0.000289105 | 0.000289105
GUSSET PLATE | PLT10*170.6 | +28.973 | +28.983 | 6 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pd-58 | 0.0647598 | 0.038949 | 0.000289018 | 0.000289018
GUSSET PLATE | PLT10*169.5 | +28.973 | +28.983 | 6 | 2.3 | 0 | 28.5 | 0.1 | 169.5 | 232.1 | pd-57 | 0.0654016 | 0.0393392 | 0.000291932 | 0.000291932
GUSSET PLATE | PLT10*160.4 | +28.973 | +28.983 | 6 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.9 | pd-56 | 0.0704233 | 0.0421679 | 0.000314601 | 0.000314601
GUSSET PLATE | PLT10*160.5 | +28.973 | +28.983 | 6 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pd-56 | 0.0703419 | 0.0421247 | 0.000314235 | 0.000314235
4 x GUSSET PLATE | PLT10*172.8 | +11.093 | +11.103 | 5 | 1.9 | 0 | 28.7 | 0.1 | 172.7 | 185.5 | pc-172 | 0.053719 | 0.0320369 | 0.000237803 | 0.000237803
GUSSET PLATE | PLT10*171.7 | +5.393 | +5.403 | 5 | 1.9 | 0 | 28.7 | 0.1 | 171.7 | 185.8 | pc-171 | 0.0534776 | 0.0318906 | 0.000236659 | 0.000236659
GUSSET PLATE | PLT10*178.7 | +5.393 | +5.403 | 5 | 2.1 | 0 | 28.6 | 0.1 | 178.7 | 200.7 | pc-170 | 0.0600722 | 0.0358673 | 0.000267567 | 0.000267567
GUSSET PLATE | PLT10*158.7 | +5.393 | +5.403 | 5 | 1.9 | 0 | 28.7 | 0.1 | 158.8 | 209.2 | pc-163 | 0.0577522 | 0.0332027 | 0.000256662 | 0.000256662
GUSSET PLATE | PLT10*170.1 | +5.393 | +5.403 | 5 | 2.2 | 0 | 28.6 | 0.1 | 170.1 | 231.2 | pc-169 | 0.0632982 | 0.0393372 | 0.00028175 | 0.00028175
GUSSET PLATE | PLT10*170.1 | +5.393 | +5.403 | 5 | 5.9 | 0.1 | 27.5 | 0.2 | 170.1 | 465.1 | pc-128 | 0.164333 | 0.0791128 | 0.00076126 | 0.00076126
GUSSET PLATE | PLT10*158.4 | +5.393 | +5.403 | 5 | 1.9 | 0 | 28.7 | 0.1 | 158.4 | 199.5 | pc-168 | 0.0545197 | 0.0315987 | 0.00024146 | 0.00024146
GUSSET PLATE | PLT10*162 | +5.393 | +5.403 | 5 | 1.7 | 0 | 28.7 | 0.1 | 162 | 189.4 | pc-167 | 0.053079 | 0.0307101 | 0.00023487 | 0.00023487
GUSSET PLATE | PLT10*170 | +5.393 | +5.403 | 5 | 1.7 | 0 | 28.9 | 0.1 | 169.9 | 180 | pc-141 | 0.050344 | 0.0306 | 0.000221 | 0.000221
2 x GUSSET PLATE | PLT10*167.6 | +11.093 | +11.103 | 5 | 2.2 | 0 | 28.5 | 0.1 | 167.6 | 208.5 | pc-164 | 0.0619594 | 0.034956 | 0.000276898 | 0.000276898
2 x GUSSET PLATE | PLT10*172.3 | +11.093 | +11.103 | 5 | 2.1 | 0 | 28.6 | 0.1 | 172.3 | 205 | pc-165 | 0.0591024 | 0.0353322 | 0.000262795 | 0.000262795
2 x GUSSET PLATE | PLT10*174.5 | +11.093 | +11.103 | 5 | 1.9 | 0 | 28.7 | 0.1 | 174.5 | 197.8 | pc-166 | 0.0578521 | 0.0345134 | 0.000257057 | 0.000257057
2 x GUSSET PLATE | PLT10*158.6 | +10.483 | +10.493 | 5 | 1.9 | 0 | 28.7 | 0.1 | 158.6 | 209.2 | pc-163 | 0.0577307 | 0.0331853 | 0.00025656 | 0.00025656
2 x GUSSET PLATE | PLT10*163.5 | +10.483 | +10.493 | 5 | 1.9 | 0 | 28.7 | 0.1 | 163.5 | 198.1 | pc-162 | 0.0560101 | 0.0324019 | 0.000248667 | 0.000248667
GUSSET PLATE | PLT10*175.3 | +10.483 | +10.493 | 5 | 1.9 | 0 | 28.6 | 0.1 | 175.4 | 196.5 | pc-161 | 0.0585878 | 0.0344413 | 0.000260807 | 0.000260807
GUSSET PLATE | PLT10*177.4 | +10.483 | +10.493 | 5 | 2.3 | 0 | 28.5 | 0.1 | 177.4 | 206.2 | pc-160 | 0.0642044 | 0.0365952 | 0.000287346 | 0.000287346
GUSSET PLATE | PLT10*177.2 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 177.1 | 184.6 | pb-143 | 0.055702 | 0.0327245 | 0.000247284 | 0.000247284
GUSSET PLATE | PLT10*180.3 | +21.353 | +21.363 | 4 | 2.1 | 0 | 28.6 | 0.1 | 180.4 | 198.7 | pb-144 | 0.0601052 | 0.035831 | 0.000267781 | 0.000267781
GUSSET PLATE | PLT10*170 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 169.9 | 186 | pb-145 | 0.0542914 | 0.0316368 | 0.000240692 | 0.000240692
GUSSET PLATE | PLT10*178.2 | +21.353 | +21.363 | 4 | 2.2 | 0 | 28.6 | 0.1 | 178.2 | 206.5 | pb-146 | 0.0614895 | 0.0368047 | 0.00027416 | 0.00027416
GUSSET PLATE | PLT10*158.8 | +17.943 | +17.953 | 4 | 2.5 | 0 | 28.5 | 0.1 | 158.8 | 268.5 | pb-147 | 0.0713408 | 0.0426494 | 0.000318724 | 0.000318724
GUSSET PLATE | PLT10*158.8 | +17.943 | +17.953 | 4 | 2.5 | 0 | 28.5 | 0.1 | 158.8 | 269.6 | pb-148 | 0.0714154 | 0.0428229 | 0.000319019 | 0.000319019
GUSSET PLATE | PLT10*168.6 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 168.7 | 197.5 | pb-149 | 0.0570507 | 0.0332998 | 0.000253558 | 0.000253558
GUSSET PLATE | PLT10*175.3 | +17.943 | +17.953 | 4 | 2.2 | 0 | 28.6 | 0.1 | 175.4 | 212.6 | pb-150 | 0.0621261 | 0.0372671 | 0.000277003 | 0.000277003
GUSSET PLATE | PLT10*136.4 | +17.943 | +17.953 | 4 | 1.7 | 0 | 28.7 | 0.1 | 136.3 | 207.5 | pb-151 | 0.0530235 | 0.0282776 | 0.000234134 | 0.000234134
GUSSET PLATE | PLT10*142.5 | +17.943 | +17.953 | 4 | 2.8 | 0 | 28.5 | 0.1 | 142.5 | 328 | pb-152 | 0.0801255 | 0.0467214 | 0.000357575 | 0.000357575
GUSSET PLATE | PLT10*162.5 | +17.943 | +17.953 | 4 | 1.7 | 0 | 28.7 | 0.1 | 162.4 | 187.3 | pb-153 | 0.0527698 | 0.0304454 | 0.000233557 | 0.000233557
GUSSET PLATE | PLT10*175.7 | +17.943 | +17.953 | 4 | 2.2 | 0 | 28.6 | 0.1 | 175.7 | 215.2 | pb-154 | 0.0629838 | 0.0378181 | 0.000281015 | 0.000281015
GUSSET PLATE | PLT10*167.9 | +17.943 | +17.953 | 4 | 2.3 | 0 | 28.5 | 0.1 | 167.9 | 237.2 | pb-155 | 0.0662244 | 0.0398287 | 0.000295662 | 0.000295662
GUSSET PLATE | PLT10*165.5 | +17.943 | +17.953 | 4 | 2.1 | 0 | 28.6 | 0.1 | 165.4 | 209.5 | pb-156 | 0.0599463 | 0.034675 | 0.000267042 | 0.000267042
GUSSET PLATE | PLT10*201.4 | +21.353 | +21.363 | 4 | 2.5 | 0 | 28.5 | 0.1 | 201.3 | 212.3 | pb-129 | 0.0703982 | 0.0427631 | 0.000316272 | 0.000316272
GUSSET PLATE | PLT10*181.3 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 181.3 | 183.8 | pb-130 | 0.0564859 | 0.0333204 | 0.000250937 | 0.000250937
GUSSET PLATE | PLT10*169.1 | +21.353 | +21.363 | 4 | 2.3 | 0 | 28.6 | 0.1 | 169.2 | 234.7 | pb-131 | 0.0644225 | 0.0396836 | 0.000287032 | 0.000287032
GUSSET PLATE | PLT10*158.5 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 158.4 | 209.2 | pb-132 | 0.057665 | 0.0331767 | 0.000256235 | 0.000256235
GUSSET PLATE | PLT10*177 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 177 | 184.4 | pb-133 | 0.0556868 | 0.0326561 | 0.000247229 | 0.000247229
GUSSET PLATE | PLT10*180.5 | +21.353 | +21.363 | 4 | 2.1 | 0 | 28.6 | 0.1 | 180.4 | 195.1 | pb-134 | 0.0590358 | 0.0352059 | 0.000262767 | 0.000262767
GUSSET PLATE | PLT10*174.2 | +21.353 | +21.363 | 4 | 2.2 | 0 | 28.6 | 0.1 | 174.1 | 217.5 | pb-135 | 0.062928 | 0.0378876 | 0.000280654 | 0.000280654
GUSSET PLATE | PLT10*165.2 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 165.1 | 197.8 | pb-136 | 0.0563844 | 0.0327 | 0.000250433 | 0.000250433
GUSSET PLATE | PLT10*168.3 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 168.3 | 186.3 | pb-137 | 0.0539795 | 0.0313439 | 0.000239246 | 0.000239246
GUSSET PLATE | PLT10*177.9 | +21.353 | +21.363 | 4 | 2.1 | 0 | 28.6 | 0.1 | 177.9 | 204.7 | pb-138 | 0.0607381 | 0.036411 | 0.000270616 | 0.000270616
GUSSET PLATE | PLT10*165.6 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 165.7 | 186.8 | pb-139 | 0.0533924 | 0.0309349 | 0.000236479 | 0.000236479
GUSSET PLATE | PLT10*185.8 | +21.353 | +21.363 | 4 | 2.1 | 0 | 28.6 | 0.1 | 185.8 | 186.8 | pb-140 | 0.0591772 | 0.034718 | 0.000263651 | 0.000263651
GUSSET PLATE | PLT10*179.1 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 179.1 | 187.3 | pb-141 | 0.0565382 | 0.0335489 | 0.000251077 | 0.000251077
GUSSET PLATE | PLT10*174 | +17.943 | +17.953 | 4 | 2.1 | 0 | 28.6 | 0.1 | 174 | 205 | pb-142 | 0.0596374 | 0.0356702 | 0.000265356 | 0.000265356
GUSSET PLATE | PLT10*169 | +17.943 | +17.953 | 4 | 2.3 | 0 | 28.5 | 0.1 | 168.9 | 233.5 | pb-109 | 0.0656237 | 0.0394722 | 0.00029294 | 0.00029294
GUSSET PLATE | PLT10*169 | +17.943 | +17.953 | 4 | 2.3 | 0 | 28.5 | 0.1 | 168.9 | 240.7 | pb-110 | 0.0665783 | 0.0406873 | 0.000297163 | 0.000297163
GUSSET PLATE | PLT10*174 | +17.943 | +17.953 | 4 | 2.2 | 0 | 28.6 | 0.1 | 174 | 216.9 | pb-111 | 0.0628754 | 0.0377585 | 0.00028043 | 0.00028043
GUSSET PLATE | PLT10*179.1 | +17.943 | +17.953 | 4 | 2.2 | 0 | 28.5 | 0.1 | 179.1 | 199.3 | pb-112 | 0.0620978 | 0.0356977 | 0.000277445 | 0.000277445
GUSSET PLATE | PLT10*181.9 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.6 | 0.1 | 181.9 | 185.5 | pb-113 | 0.0574192 | 0.0337444 | 0.000255345 | 0.000255345
GUSSET PLATE | PLT10*181.9 | +21.353 | +21.363 | 4 | 2.1 | 0 | 28.6 | 0.1 | 181.9 | 188.5 | pb-114 | 0.0598932 | 0.0342683 | 0.000267204 | 0.000267204
GUSSET PLATE | PLT10*169 | +21.353 | +21.363 | 4 | 2.3 | 0 | 28.5 | 0.1 | 168.9 | 233.5 | pb-109 | 0.0656237 | 0.0394722 | 0.00029294 | 0.00029294
GUSSET PLATE | PLT10*169 | +21.353 | +21.363 | 4 | 2.3 | 0 | 28.5 | 0.1 | 168.9 | 240.7 | pb-110 | 0.0665783 | 0.0406873 | 0.000297163 | 0.000297163
GUSSET PLATE | PLT10*170.9 | +21.353 | +21.363 | 4 | 2.3 | 0 | 28.5 | 0.1 | 171 | 227.4 | pb-115 | 0.0646208 | 0.038863 | 0.000288386 | 0.000288386
GUSSET PLATE | PLT10*170.9 | +21.353 | +21.363 | 4 | 2.3 | 0 | 28.5 | 0.1 | 171 | 234.3 | pb-116 | 0.0655331 | 0.0400316 | 0.000292429 | 0.000292429
GUSSET PLATE | PLT10*134.3 | +24.208 | +24.218 | 4 | 2.7 | 0 | 28.7 | 0.1 | 134.3 | 332.9 | pb-117 | 0.0773517 | 0.0447162 | 0.000343758 | 0.000343758
GUSSET PLATE | PLT10*134.3 | +24.208 | +24.218 | 4 | 2.6 | 0 | 28.6 | 0.1 | 134.3 | 319 | pb-118 | 0.07563 | 0.0428471 | 0.000336338 | 0.000336338
GUSSET PLATE | PLT10*160.9 | +21.353 | +21.363 | 4 | 2.5 | 0 | 28.5 | 0.1 | 160.8 | 255 | pb-119 | 0.0716737 | 0.0410255 | 0.000321551 | 0.000321551
GUSSET PLATE | PLT10*151.1 | +21.353 | +21.363 | 4 | 2.5 | 0 | 28.5 | 0.1 | 151.1 | 254.8 | pb-120 | 0.071743 | 0.0385139 | 0.000322279 | 0.000322279
GUSSET PLATE | PLT10*133.8 | +21.350 | +21.360 | 4 | 3.2 | 0 | 28.3 | 0.1 | 133.8 | 318.4 | pb-121 | 0.0891574 | 0.0426196 | 0.000402043 | 0.000402043
GUSSET PLATE | PLT10*133.8 | +21.350 | +21.360 | 4 | 2.5 | 0 | 28.7 | 0.1 | 133.8 | 303.7 | pb-122 | 0.0719401 | 0.0406521 | 0.00031942 | 0.00031942
GUSSET PLATE | PLT10*143.1 | +19.645 | +19.655 | 4 | 2.5 | 0 | 28.6 | 0.1 | 143.1 | 281.1 | pb-123 | 0.0696558 | 0.0402265 | 0.000309827 | 0.000309827
GUSSET PLATE | PLT10*143.1 | +19.645 | +19.655 | 4 | 2.5 | 0 | 28.7 | 0.1 | 143.1 | 292.1 | pb-124 | 0.0710288 | 0.0418081 | 0.00031578 | 0.00031578
GUSSET PLATE | PLT10*133.8 | +17.940 | +17.950 | 4 | 3.2 | 0 | 28.3 | 0.1 | 133.8 | 318.4 | pb-121 | 0.0891574 | 0.0426196 | 0.000402043 | 0.000402043
GUSSET PLATE | PLT10*133.8 | +17.940 | +17.950 | 4 | 2.5 | 0 | 28.7 | 0.1 | 133.8 | 303.7 | pb-122 | 0.0719401 | 0.0406521 | 0.00031942 | 0.00031942
GUSSET PLATE | PLT10*139.9 | +15.590 | +15.600 | 4 | 2.5 | 0 | 28.7 | 0.1 | 139.8 | 288.3 | pb-125 | 0.0690467 | 0.0403219 | 0.000306396 | 0.000306396
GUSSET PLATE | PLT10*139.9 | +15.590 | +15.600 | 4 | 2.5 | 0 | 28.6 | 0.1 | 139.8 | 293.9 | pb-126 | 0.0716538 | 0.0411112 | 0.000318696 | 0.000318696
GUSSET PLATE | PLT10*142.7 | +15.590 | +15.600 | 4 | 2.5 | 0 | 28.6 | 0.1 | 142.8 | 282.8 | pb-127 | 0.0699201 | 0.0403444 | 0.000311 | 0.000311
GUSSET PLATE | PLT10*142.7 | +15.590 | +15.600 | 4 | 2.6 | 0 | 28.5 | 0.1 | 142.8 | 284.8 | pb-128 | 0.0741603 | 0.0406327 | 0.000331451 | 0.000331451
GUSSET PLATE | PLT10*143.1 | +13.035 | +13.045 | 4 | 2.5 | 0 | 28.6 | 0.1 | 143.1 | 281.1 | pb-123 | 0.0696559 | 0.0402265 | 0.000309827 | 0.000309827
GUSSET PLATE | PLT10*143.1 | +13.035 | +13.045 | 4 | 2.5 | 0 | 28.7 | 0.1 | 143.1 | 292.1 | pb-124 | 0.0710286 | 0.041808 | 0.000315779 | 0.000315779
GUSSET PLATE | PLT10*143.1 | +8.035 | +8.045 | 3 | 2.5 | 0 | 28.7 | 0.1 | 143.1 | 292.1 | pa-95 | 0.0710286 | 0.041808 | 0.000315779 | 0.000315779
GUSSET PLATE | PLT10*143.1 | +8.035 | +8.045 | 3 | 2.5 | 0 | 28.6 | 0.1 | 143.1 | 281.1 | pa-96 | 0.0696558 | 0.0402265 | 0.000309827 | 0.000309827
GUSSET PLATE | PLT10*157.6 | +10.483 | +10.493 | 3 | 2.2 | 0 | 28.6 | 0.1 | 157.7 | 230 | pa-97 | 0.0630013 | 0.0362237 | 0.000280956 | 0.000280956
GUSSET PLATE | PLT10*161.7 | +10.483 | +10.493 | 3 | 2.6 | 0 | 28.3 | 0.1 | 161.7 | 239.9 | pa-98 | 0.0730006 | 0.0387977 | 0.000329083 | 0.000329083
GUSSET PLATE | PLT10*180.5 | +10.483 | +10.493 | 3 | 2.3 | 0 | 28.5 | 0.1 | 180.4 | 217.9 | pa-99 | 0.0660708 | 0.0393333 | 0.000295846 | 0.000295846
GUSSET PLATE | PLT10*181.2 | +10.483 | +10.493 | 3 | 2.3 | 0 | 28.5 | 0.1 | 181.3 | 217.9 | pa-100 | 0.0661693 | 0.0394733 | 0.000296295 | 0.000296295
GUSSET PLATE | PLT10*174.3 | +10.483 | +10.493 | 3 | 2.2 | 0 | 28.6 | 0.1 | 174.3 | 217.2 | pa-101 | 0.0628725 | 0.0378512 | 0.0002804 | 0.0002804
GUSSET PLATE | PLT10*174.3 | +10.483 | +10.493 | 3 | 2.2 | 0 | 28.6 | 0.1 | 174.3 | 216 | pa-102 | 0.0627168 | 0.0376554 | 0.000279705 | 0.000279705
GUSSET PLATE | PLT10*179.4 | +10.483 | +10.493 | 3 | 2.3 | 0 | 28.5 | 0.1 | 179.5 | 217.9 | pa-103 | 0.0657994 | 0.0391145 | 0.000294561 | 0.000294561
GUSSET PLATE | PLT10*180 | +10.483 | +10.493 | 3 | 2.3 | 0 | 28.5 | 0.1 | 180 | 217.9 | pa-104 | 0.0658972 | 0.0392533 | 0.000295007 | 0.000295007
GUSSET PLATE | PLT10*165.5 | +10.483 | +10.493 | 3 | 2.5 | 0 | 28.5 | 0.1 | 165.4 | 246.5 | pa-105 | 0.0677174 | 0.0408155 | 0.000302396 | 0.000302396
GUSSET PLATE | PLT10*154.9 | +10.483 | +10.493 | 3 | 2.1 | 0 | 28.6 | 0.1 | 154.8 | 219.7 | pa-106 | 0.0595693 | 0.0340519 | 0.000264967 | 0.000264967
GUSSET PLATE | PLT10*139.9 | +10.480 | +10.490 | 3 | 2.5 | 0 | 28.7 | 0.1 | 139.8 | 288.3 | pa-117 | 0.0690467 | 0.0403219 | 0.000306396 | 0.000306396
GUSSET PLATE | PLT10*139.9 | +10.480 | +10.490 | 3 | 2.5 | 0 | 28.6 | 0.1 | 139.8 | 293.9 | pa-118 | 0.0716538 | 0.0411112 | 0.000318696 | 0.000318696
GUSSET PLATE | PLT10*142.7 | +10.480 | +10.490 | 3 | 2.5 | 0 | 28.6 | 0.1 | 142.8 | 282.8 | pa-119 | 0.0699201 | 0.0403444 | 0.000311 | 0.000311
GUSSET PLATE | PLT10*142.7 | +10.480 | +10.490 | 3 | 2.6 | 0 | 28.5 | 0.1 | 142.8 | 284.8 | pa-120 | 0.0741603 | 0.0406327 | 0.000331451 | 0.000331451
GUSSET PLATE | PLT10*139.6 | +5.590 | +5.600 | 3 | 2.5 | 0 | 28.7 | 0.1 | 139.6 | 289.4 | pa-107 | 0.0692253 | 0.0404067 | 0.000307189 | 0.000307189
GUSSET PLATE | PLT10*142.1 | +5.590 | +5.600 | 3 | 2.5 | 0 | 28.6 | 0.1 | 142.1 | 267.1 | pa-108 | 0.0696741 | 0.0379509 | 0.000310768 | 0.000310768
GUSSET PLATE | PLT10*142.1 | +5.590 | +5.600 | 3 | 2.3 | 0 | 28.7 | 0.1 | 142.1 | 267.4 | pa-109 | 0.0660548 | 0.0379933 | 0.000293213 | 0.000293213
GUSSET PLATE | PLT10*139.6 | +5.590 | +5.600 | 3 | 2.5 | 0 | 28.7 | 0.1 | 139.6 | 277.3 | pa-110 | 0.0676436 | 0.0387194 | 0.000300293 | 0.000300293
GUSSET PLATE | PLT10*135 | +2.590 | +2.600 | 3 | 1.9 | 0 | 28.7 | 0.1 | 135 | 235.5 | pa-111 | 0.0572807 | 0.0317921 | 0.000253284 | 0.000253284
GUSSET PLATE | PLT10*146.4 | +2.590 | +2.600 | 3 | 2.5 | 0 | 28.6 | 0.1 | 146.4 | 279.5 | pa-112 | 0.0693087 | 0.0409102 | 0.000308233 | 0.000308233
GUSSET PLATE | PLT10*179.4 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 179.5 | 184.9 | pa-113 | 0.05651 | 0.0331711 | 0.000251095 | 0.000251095
GUSSET PLATE | PLT10*176.2 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 176.3 | 184.9 | pa-114 | 0.0555055 | 0.0325741 | 0.000246367 | 0.000246367
GUSSET PLATE | PLT10*182.2 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.6 | 0.1 | 182.3 | 188.2 | pa-115 | 0.0577757 | 0.034285 | 0.000256931 | 0.000256931
GUSSET PLATE | PLT10*182.2 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.6 | 0.1 | 182.3 | 187.3 | pa-116 | 0.0576512 | 0.0341273 | 0.00025637 | 0.00025637
2 x GUSSET PLATE | PLT10*160.5 | +21.353 | +21.363 | 4 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pb-86 | 0.0703425 | 0.0421247 | 0.000314238 | 0.000314238
GUSSET PLATE | PLT10*140.5 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 140.4 | 216.2 | pb-87 | 0.0551881 | 0.0303734 | 0.000244299 | 0.000244299
2 x GUSSET PLATE | PLT10*137.1 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 137.1 | 224.7 | pb-88 | 0.0567875 | 0.030804 | 0.000251607 | 0.000251607
GUSSET PLATE | PLT10*140.6 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 140.6 | 216.2 | pb-87 | 0.0551716 | 0.0303694 | 0.000244224 | 0.000244224
GUSSET PLATE | PLT10*160.6 | +21.353 | +21.363 | 4 | 2.5 | 0 | 28.5 | 0.1 | 160.6 | 262.3 | pb-86 | 0.0703206 | 0.042113 | 0.00031414 | 0.00031414
GUSSET PLATE | PLT10*170.6 | +21.353 | +21.363 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pb-93 | 0.0658278 | 0.0396316 | 0.000293979 | 0.000293979
GUSSET PLATE | PLT10*170.6 | +21.353 | +21.363 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pb-92 | 0.0647785 | 0.0389599 | 0.000289103 | 0.000289103
GUSSET PLATE | PLT10*170.6 | +21.353 | +21.363 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pb-92 | 0.0647608 | 0.038949 | 0.000289022 | 0.000289022
GUSSET PLATE | PLT10*161.8 | +21.353 | +21.363 | 4 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 262 | pb-98 | 0.0706492 | 0.0423831 | 0.000315749 | 0.000315749
GUSSET PLATE | PLT10*170.6 | +21.353 | +21.363 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pb-93 | 0.0658454 | 0.0396423 | 0.000294059 | 0.000294059
GUSSET PLATE | PLT10*161.8 | +21.353 | +21.363 | 4 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258 | pb-99 | 0.0696158 | 0.0417359 | 0.00031097 | 0.00031097
GUSSET PLATE | PLT10*141.2 | +21.353 | +21.363 | 4 | 2.2 | 0 | 28.6 | 0.1 | 141.2 | 245.2 | pb-100 | 0.0637481 | 0.0346233 | 0.000284111 | 0.000284111
GUSSET PLATE | PLT10*140.9 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pb-94 | 0.0576086 | 0.0317279 | 0.000255429 | 0.000255429
GUSSET PLATE | PLT10*136.9 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pb-88 | 0.0568741 | 0.0308272 | 0.000252002 | 0.000252002
GUSSET PLATE | PLT10*140.9 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pb-94 | 0.0576086 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*158.2 | +21.353 | +21.363 | 4 | 2.6 | 0 | 28.5 | 0.1 | 158.2 | 274.9 | pb-101 | 0.0727471 | 0.0434829 | 0.000325168 | 0.000325168
GUSSET PLATE | PLT10*142.4 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 222.4 | pb-102 | 0.0571438 | 0.0316716 | 0.000253306 | 0.000253306
GUSSET PLATE | PLT10*141.1 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 141.1 | 217.2 | pb-103 | 0.0555457 | 0.0306329 | 0.000245958 | 0.000245958
GUSSET PLATE | PLT10*141.2 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 141.2 | 224.4 | pb-104 | 0.0574568 | 0.0316857 | 0.000254735 | 0.000254735
2 x GUSSET PLATE | PLT10*140.8 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.5 | pb-94 | 0.0576789 | 0.0317475 | 0.00025575 | 0.00025575
GUSSET PLATE | PLT10*170.6 | +21.353 | +21.363 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pb-93 | 0.0658269 | 0.0396316 | 0.000293974 | 0.000293974
GUSSET PLATE | PLT10*170.6 | +21.353 | +21.363 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pb-93 | 0.0658459 | 0.0396423 | 0.000294061 | 0.000294061
GUSSET PLATE | PLT10*144.4 | +21.353 | +21.363 | 4 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.6 | pb-95 | 0.0560827 | 0.0312867 | 0.000248473 | 0.000248473
GUSSET PLATE | PLT10*163 | +21.353 | +21.363 | 4 | 2.1 | 0 | 28.6 | 0.1 | 163 | 209.2 | pb-96 | 0.0590361 | 0.0341005 | 0.000262746 | 0.000262746
GUSSET PLATE | PLT10*170.6 | +21.353 | +21.363 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pb-92 | 0.064779 | 0.0389599 | 0.000289105 | 0.000289105
GUSSET PLATE | PLT10*170.6 | +21.353 | +21.363 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pb-92 | 0.0647598 | 0.038949 | 0.000289018 | 0.000289018
GUSSET PLATE | PLT10*169.5 | +21.353 | +21.363 | 4 | 2.3 | 0 | 28.5 | 0.1 | 169.5 | 232.1 | pb-97 | 0.0654016 | 0.0393392 | 0.000291932 | 0.000291932
GUSSET PLATE | PLT10*160.4 | +21.353 | +21.363 | 4 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.9 | pb-86 | 0.0704233 | 0.0421679 | 0.000314601 | 0.000314601
GUSSET PLATE | PLT10*160.5 | +21.353 | +21.363 | 4 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pb-86 | 0.0703419 | 0.0421247 | 0.000314235 | 0.000314235
GUSSET PLATE | PLT10*130.7 | +17.943 | +17.953 | 4 | 2.1 | 0 | 28.7 | 0.1 | 130.7 | 241.1 | pb-89 | 0.0596755 | 0.0315225 | 0.000264685 | 0.000264685
GUSSET PLATE | PLT10*152.3 | +17.943 | +17.953 | 4 | 2.7 | 0 | 28.5 | 0.1 | 152.2 | 297.8 | pb-90 | 0.0765085 | 0.0453653 | 0.000342013 | 0.000342013
GUSSET PLATE | PLT10*132.3 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 132.2 | 236.6 | pb-91 | 0.058861 | 0.0313056 | 0.000261 | 0.000261
2 x GUSSET PLATE | PLT10*170.6 | +17.943 | +17.953 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pb-92 | 0.0647785 | 0.0389599 | 0.000289103 | 0.000289103
GUSSET PLATE | PLT10*170.6 | +17.943 | +17.953 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pb-93 | 0.0658278 | 0.0396316 | 0.000293979 | 0.000293979
2 x GUSSET PLATE | PLT10*170.6 | +17.943 | +17.953 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pb-93 | 0.0658454 | 0.0396423 | 0.000294059 | 0.000294059
GUSSET PLATE | PLT10*170.6 | +17.943 | +17.953 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pb-92 | 0.0647608 | 0.038949 | 0.000289022 | 0.000289022
GUSSET PLATE | PLT10*134.7 | +17.943 | +17.953 | 4 | 2.1 | 0 | 28.7 | 0.1 | 134.7 | 242 | pb-105 | 0.0607481 | 0.0326015 | 0.000269723 | 0.000269723
GUSSET PLATE | PLT10*147.9 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 147.8 | 214.9 | pb-106 | 0.056983 | 0.0317733 | 0.00025281 | 0.00025281
GUSSET PLATE | PLT10*141.2 | +17.943 | +17.953 | 4 | 2.2 | 0 | 28.6 | 0.1 | 141.2 | 245.2 | pb-100 | 0.0637481 | 0.0346233 | 0.000284111 | 0.000284111
GUSSET PLATE | PLT10*136.9 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pb-88 | 0.0568741 | 0.0308272 | 0.000252002 | 0.000252002
GUSSET PLATE | PLT10*140.9 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pb-94 | 0.0576086 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*158.2 | +17.943 | +17.953 | 4 | 2.6 | 0 | 28.5 | 0.1 | 158.2 | 274.9 | pb-101 | 0.0727471 | 0.0434829 | 0.000325168 | 0.000325168
GUSSET PLATE | PLT10*142.4 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 222.4 | pb-102 | 0.0571438 | 0.0316716 | 0.000253306 | 0.000253306
GUSSET PLATE | PLT10*160.5 | +17.943 | +17.953 | 4 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pb-86 | 0.0703425 | 0.0421247 | 0.000314238 | 0.000314238
GUSSET PLATE | PLT10*141.1 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 141.1 | 217.2 | pb-103 | 0.0555457 | 0.0306329 | 0.000245958 | 0.000245958
GUSSET PLATE | PLT10*157.7 | +17.943 | +17.953 | 4 | 2.6 | 0 | 28.5 | 0.1 | 157.7 | 276.6 | pb-107 | 0.0730228 | 0.0436243 | 0.000326405 | 0.000326405
GUSSET PLATE | PLT10*141.2 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 141.2 | 224.4 | pb-104 | 0.0574568 | 0.0316857 | 0.000254735 | 0.000254735
GUSSET PLATE | PLT10*140.9 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pb-94 | 0.0576085 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*136.9 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pb-88 | 0.056874 | 0.0308272 | 0.000252001 | 0.000252001
2 x GUSSET PLATE | PLT10*140.8 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.5 | pb-94 | 0.0576789 | 0.0317475 | 0.00025575 | 0.00025575
GUSSET PLATE | PLT10*144.4 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.4 | pb-95 | 0.0560392 | 0.0312583 | 0.00024827 | 0.00024827
GUSSET PLATE | PLT10*170.6 | +17.943 | +17.953 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pb-93 | 0.0658269 | 0.0396316 | 0.000293974 | 0.000293974
GUSSET PLATE | PLT10*170.6 | +17.943 | +17.953 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pb-93 | 0.0658459 | 0.0396423 | 0.000294061 | 0.000294061
GUSSET PLATE | PLT10*144.4 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.6 | pb-95 | 0.0560827 | 0.0312867 | 0.000248473 | 0.000248473
GUSSET PLATE | PLT10*163 | +17.943 | +17.953 | 4 | 2.1 | 0 | 28.6 | 0.1 | 163 | 209.2 | pb-96 | 0.0590361 | 0.0341005 | 0.000262746 | 0.000262746
GUSSET PLATE | PLT10*141.1 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 141.1 | 217.2 | pb-108 | 0.0555992 | 0.030638 | 0.000246216 | 0.000246216
2 x GUSSET PLATE | PLT10*160.4 | +17.943 | +17.953 | 4 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.9 | pb-86 | 0.0704233 | 0.0421679 | 0.000314601 | 0.000314601
GUSSET PLATE | PLT10*170.6 | +17.943 | +17.953 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pb-92 | 0.064779 | 0.0389599 | 0.000289105 | 0.000289105
GUSSET PLATE | PLT10*170.6 | +17.943 | +17.953 | 4 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pb-92 | 0.0647598 | 0.038949 | 0.000289018 | 0.000289018
GUSSET PLATE | PLT10*169.5 | +17.943 | +17.953 | 4 | 2.3 | 0 | 28.5 | 0.1 | 169.5 | 232.1 | pb-97 | 0.0654016 | 0.0393392 | 0.000291932 | 0.000291932
GUSSET PLATE | PLT10*160.5 | +17.943 | +17.953 | 4 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pb-86 | 0.0703419 | 0.0421247 | 0.000314235 | 0.000314235
2 x GUSSET PLATE | PLT10*163.7 | +17.943 | +17.953 | 4 | 2.1 | 0 | 28.6 | 0.1 | 163.6 | 208.8 | pb-157 | 0.0589708 | 0.0341873 | 0.00026244 | 0.00026244
2 x GUSSET PLATE | PLT10*175.9 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 175.9 | 184.9 | pb-158 | 0.0554828 | 0.0325007 | 0.000246277 | 0.000246277
GUSSET PLATE | PLT10*165.7 | +17.943 | +17.953 | 4 | 2.1 | 0 | 28.6 | 0.1 | 165.7 | 208.8 | pb-159 | 0.0594492 | 0.0345731 | 0.000264706 | 0.000264706
GUSSET PLATE | PLT10*171.9 | +17.943 | +17.953 | 4 | 2.1 | 0 | 28.6 | 0.1 | 172 | 206.7 | pb-160 | 0.0595011 | 0.035499 | 0.000264658 | 0.000264658
GUSSET PLATE | PLT10*181.2 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.6 | 0.1 | 181.3 | 191.2 | pb-161 | 0.05837 | 0.0346532 | 0.000259703 | 0.000259703
GUSSET PLATE | PLT10*179.8 | +17.943 | +17.953 | 4 | 1.9 | 0 | 28.7 | 0.1 | 179.7 | 183.8 | pb-162 | 0.0562245 | 0.0330633 | 0.000249736 | 0.000249736
6 x GUSSET PLATE | PLT10*165 | +15.593 | +15.603 | 4 | 2.2 | 0 | 28.6 | 0.1 | 165 | 229.3 | pb-82 | 0.0632082 | 0.037835 | 0.000281506 | 0.000281506
GUSSET PLATE | PLT10*144.4 | +15.593 | +15.603 | 4 | 2.2 | 0 | 28.6 | 0.1 | 144.4 | 239.7 | pb-83 | 0.0629201 | 0.0346433 | 0.000280289 | 0.000280289
5 x GUSSET PLATE | PLT10*165 | +15.593 | +15.603 | 4 | 2.2 | 0 | 28.6 | 0.1 | 165 | 230 | pb-82 | 0.0633649 | 0.037934 | 0.000282232 | 0.000282232
GUSSET PLATE | PLT10*157 | +15.593 | +15.603 | 4 | 2.5 | 0 | 28.6 | 0.1 | 157 | 258.4 | pb-84 | 0.06815 | 0.0405579 | 0.000303848 | 0.000303848
GUSSET PLATE | PLT10*144.8 | +15.593 | +15.603 | 4 | 2.2 | 0 | 28.6 | 0.1 | 144.8 | 235 | pb-85 | 0.0621918 | 0.0340159 | 0.000277226 | 0.000277226
2 x GUSSET PLATE | PLT10*161.8 | +10.483 | +10.493 | 3 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 262 | pa-77 | 0.0706492 | 0.0423831 | 0.000315749 | 0.000315749
GUSSET PLATE | PLT10*152.3 | +5.593 | +5.603 | 3 | 2.7 | 0 | 28.5 | 0.1 | 152.2 | 297.8 | pa-121 | 0.0765085 | 0.0453653 | 0.000342013 | 0.000342013
GUSSET PLATE | PLT10*132.3 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 132.2 | 236.6 | pa-122 | 0.058861 | 0.0313056 | 0.000261 | 0.000261
GUSSET PLATE | PLT10*134.7 | +5.593 | +5.603 | 3 | 2.1 | 0 | 28.7 | 0.1 | 134.7 | 242 | pa-123 | 0.0607481 | 0.0326015 | 0.000269723 | 0.000269723
GUSSET PLATE | PLT10*130.7 | +5.593 | +5.603 | 3 | 2.1 | 0 | 28.7 | 0.1 | 130.7 | 241.1 | pa-124 | 0.0596755 | 0.0315225 | 0.000264685 | 0.000264685
GUSSET PLATE | PLT10*134.5 | +17.943 | +17.953 | 4 | 2.5 | 0 | 28.5 | 0.1 | 134.5 | 270.7 | pb-77 | 0.0693675 | 0.03641 | 0.000310024 | 0.000310024
2 x GUSSET PLATE | PLT10*154.5 | +17.943 | +17.953 | 4 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 267.3 | pb-78 | 0.0696028 | 0.0412969 | 0.000310369 | 0.000310369
2 x GUSSET PLATE | PLT10*163.5 | +17.943 | +17.953 | 4 | 2.2 | 0 | 28.6 | 0.1 | 163.5 | 234.3 | pb-79 | 0.0640416 | 0.0383117 | 0.000285283 | 0.000285283
GUSSET PLATE | PLT10*163.6 | +17.943 | +17.953 | 4 | 2.2 | 0 | 28.6 | 0.1 | 163.6 | 234.1 | pb-79 | 0.0640219 | 0.0383005 | 0.000285194 | 0.000285194
2 x GUSSET PLATE | PLT10*163.5 | +17.943 | +17.953 | 4 | 2.2 | 0 | 28.6 | 0.1 | 163.5 | 235.1 | pb-79 | 0.0642625 | 0.0384507 | 0.000286306 | 0.000286306
2 x GUSSET PLATE | PLT10*154.5 | +17.943 | +17.953 | 4 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 268.1 | pb-78 | 0.0698163 | 0.0414282 | 0.000311354 | 0.000311354
GUSSET PLATE | PLT10*163.6 | +17.943 | +17.953 | 4 | 2.2 | 0 | 28.6 | 0.1 | 163.6 | 235 | pb-79 | 0.0642428 | 0.0384395 | 0.000286217 | 0.000286217
GUSSET PLATE | PLT10*154.5 | +17.943 | +17.953 | 4 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 267.3 | pb-78 | 0.0696159 | 0.0412969 | 0.000310433 | 0.000310433
GUSSET PLATE | PLT10*145.8 | +17.943 | +17.953 | 4 | 2.7 | 0 | 28.5 | 0.1 | 145.9 | 307.2 | pb-80 | 0.076557 | 0.0447884 | 0.000341614 | 0.000341614
GUSSET PLATE | PLT10*125.8 | +17.943 | +17.953 | 4 | 2.2 | 0 | 28.7 | 0.1 | 125.8 | 256.4 | pb-81 | 0.0623896 | 0.0322689 | 0.000276915 | 0.000276915
GUSSET PLATE | PLT10*134.7 | +10.483 | +10.493 | 3 | 2.1 | 0 | 28.7 | 0.1 | 134.7 | 242 | pa-125 | 0.0607481 | 0.0326015 | 0.000269723 | 0.000269723
GUSSET PLATE | PLT10*159.7 | +10.483 | +10.493 | 3 | 2.1 | 0 | 28.7 | 0.1 | 159.7 | 244.7 | pa-126 | 0.0596791 | 0.0390666 | 0.000264701 | 0.000286024
GUSSET PLATE | PLT10*152.3 | +10.483 | +10.493 | 3 | 2.7 | 0 | 28.5 | 0.1 | 152.2 | 297.8 | pa-127 | 0.0765085 | 0.0453653 | 0.000342013 | 0.000342013
GUSSET PLATE | PLT10*132.3 | +10.483 | +10.493 | 3 | 1.9 | 0 | 28.7 | 0.1 | 132.2 | 236.6 | pa-128 | 0.058861 | 0.0313056 | 0.000261 | 0.000261
2 x GUSSET PLATE | PLT10*161.8 | +10.483 | +10.493 | 3 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258 | pa-79 | 0.0696158 | 0.0417359 | 0.00031097 | 0.00031097
GUSSET PLATE | PLT10*170.6 | +10.483 | +10.493 | 3 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pa-78 | 0.0647785 | 0.0389599 | 0.000289103 | 0.000289103
GUSSET PLATE | PLT10*141.5 | +10.483 | +10.493 | 3 | 2.9 | 0 | 28.5 | 0.1 | 141.5 | 347.8 | pa-129 | 0.0847753 | 0.049213 | 0.000378866 | 0.000378866
GUSSET PLATE | PLT10*141.5 | +10.483 | +10.493 | 3 | 2.9 | 0 | 28.5 | 0.1 | 141.5 | 347.8 | pa-129 | 0.0847751 | 0.0492128 | 0.000378865 | 0.000378865
GUSSET PLATE | PLT10*187.1 | +10.483 | +10.493 | 3 | 3.7 | 0 | 27.8 | 0.1 | 187.1 | 258.8 | pa-63 | 0.101686 | 0.0484276 | 0.000465877 | 0.000465877
2 x GUSSET PLATE | PLT10*170.6 | +10.483 | +10.493 | 3 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pa-78 | 0.064779 | 0.0389599 | 0.000289105 | 0.000289105
GUSSET PLATE | PLT10*147.9 | +10.483 | +10.493 | 3 | 1.9 | 0 | 28.7 | 0.1 | 147.8 | 214.9 | pa-84 | 0.056983 | 0.0317733 | 0.00025281 | 0.00025281
GUSSET PLATE | PLT10*141.2 | +10.483 | +10.493 | 3 | 2.2 | 0 | 28.6 | 0.1 | 141.2 | 245.2 | pa-85 | 0.0637481 | 0.0346233 | 0.000284111 | 0.000284111
GUSSET PLATE | PLT10*140.9 | +10.483 | +10.493 | 3 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pa-74 | 0.0576086 | 0.0317279 | 0.000255429 | 0.000255429
GUSSET PLATE | PLT10*158.2 | +10.483 | +10.493 | 3 | 2.6 | 0 | 28.5 | 0.1 | 158.2 | 274.9 | pa-75 | 0.0727471 | 0.0434829 | 0.000325168 | 0.000325168
GUSSET PLATE | PLT10*142.4 | +10.483 | +10.493 | 3 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 222.4 | pa-76 | 0.0571438 | 0.0316716 | 0.000253306 | 0.000253306
2 x GUSSET PLATE | PLT10*170.6 | +10.483 | +10.493 | 3 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pa-80 | 0.0658454 | 0.0396423 | 0.000294059 | 0.000294059
GUSSET PLATE | PLT10*160.5 | +10.483 | +10.493 | 3 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pa-81 | 0.0703425 | 0.0421247 | 0.000314238 | 0.000314238
GUSSET PLATE | PLT10*141.1 | +10.483 | +10.493 | 3 | 1.9 | 0 | 28.7 | 0.1 | 141.1 | 217.2 | pa-82 | 0.0555457 | 0.0306329 | 0.000245958 | 0.000245958
GUSSET PLATE | PLT10*136.9 | +10.483 | +10.493 | 3 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pa-73 | 0.0568742 | 0.0308274 | 0.000252002 | 0.000252002
GUSSET PLATE | PLT10*157.7 | +10.483 | +10.493 | 3 | 2.6 | 0 | 28.5 | 0.1 | 157.7 | 276.6 | pa-83 | 0.0730228 | 0.0436243 | 0.000326405 | 0.000326405
GUSSET PLATE | PLT10*141.2 | +10.483 | +10.493 | 3 | 1.9 | 0 | 28.7 | 0.1 | 141.2 | 224.4 | pa-86 | 0.0574568 | 0.0316857 | 0.000254735 | 0.000254735
GUSSET PLATE | PLT10*140.9 | +10.483 | +10.493 | 3 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pa-74 | 0.0576085 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*136.9 | +10.483 | +10.493 | 3 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pa-73 | 0.056874 | 0.0308272 | 0.000252001 | 0.000252001
2 x GUSSET PLATE | PLT10*140.8 | +10.483 | +10.493 | 3 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.5 | pa-74 | 0.0576789 | 0.0317475 | 0.00025575 | 0.00025575
GUSSET PLATE | PLT10*144.4 | +10.483 | +10.493 | 3 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.4 | pa-87 | 0.0560392 | 0.0312583 | 0.00024827 | 0.00024827
GUSSET PLATE | PLT10*170.6 | +10.483 | +10.493 | 3 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pa-80 | 0.0658269 | 0.0396316 | 0.000293974 | 0.000293974
GUSSET PLATE | PLT10*170.6 | +10.483 | +10.493 | 3 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pa-80 | 0.0658459 | 0.0396423 | 0.000294061 | 0.000294061
GUSSET PLATE | PLT10*144.4 | +10.483 | +10.493 | 3 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.6 | pa-87 | 0.0560827 | 0.0312867 | 0.000248473 | 0.000248473
GUSSET PLATE | PLT10*163 | +10.483 | +10.493 | 3 | 2.1 | 0 | 28.6 | 0.1 | 163 | 209.2 | pa-88 | 0.0590361 | 0.0341005 | 0.000262746 | 0.000262746
2 x GUSSET PLATE | PLT10*160.4 | +10.483 | +10.493 | 3 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.9 | pa-81 | 0.0704233 | 0.0421679 | 0.000314601 | 0.000314601
GUSSET PLATE | PLT10*170.6 | +10.483 | +10.493 | 3 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pa-78 | 0.0647598 | 0.038949 | 0.000289018 | 0.000289018
GUSSET PLATE | PLT10*169.5 | +10.483 | +10.493 | 3 | 2.3 | 0 | 28.5 | 0.1 | 169.5 | 232.1 | pa-90 | 0.0654016 | 0.0393392 | 0.000291932 | 0.000291932
GUSSET PLATE | PLT10*136.9 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pa-73 | 0.0568741 | 0.0308273 | 0.000252002 | 0.000252002
GUSSET PLATE | PLT10*136.9 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pa-73 | 0.0568741 | 0.0308272 | 0.000252002 | 0.000252002
GUSSET PLATE | PLT10*140.9 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pa-74 | 0.0576086 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*158.2 | +5.593 | +5.603 | 3 | 2.6 | 0 | 28.5 | 0.1 | 158.2 | 274.9 | pa-75 | 0.0727471 | 0.0434829 | 0.000325168 | 0.000325168
GUSSET PLATE | PLT10*142.4 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 222.4 | pa-76 | 0.0571761 | 0.0316716 | 0.000253466 | 0.000253466
2 x GUSSET PLATE | PLT10*161.8 | +5.593 | +5.603 | 3 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 262 | pa-77 | 0.0706492 | 0.0423831 | 0.000315749 | 0.000315749
