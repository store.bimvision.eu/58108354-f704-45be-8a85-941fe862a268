Properties of the parts of a building model (IFC2X3), part 8 of 22

# IfcDiscreteAccessory: END PLATE (3408)
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
END PLATE | PLT16*170 | +2.556 | +2.744 | 5 | 8 | 4 | 0 | 18.8 | 0.1 | 169.9 | 16 | 188 | pc-263 | 0.075376 | 0.075376 | 0.00272 | 0.00051136 | 0.00051136
END PLATE | PLT16*235 | +17.694 | +18.044 | 4 | 8 | 8.2 | 0 | 17.9 | 0.2 | 190 | 16 | 349.6 | pb-207 | 0.150115 | 0.183019 | 0.00376 | 0.00106278 | 0.00131449
END PLATE | PLT20*190 | +17.694 | +18.044 | 4 | 8 | 10.5 | 0 | 14.8 | 0.2 | 190 | 20 | 349.6 | pb-2 | 0.154432 | 0.154432 | 0.0038 | 0.00132848 | 0.00132848
END PLATE | PLT16*190 | +17.494 | +18.044 | 4 | 8 | 13.1 | 0 | 17.7 | 0.2 | 190 | 16 | 549.6 | pb-196 | 0.232515 | 0.232515 | 0.00304 | 0.00167078 | 0.00167078
END PLATE | PLT20*190 | +17.494 | +18.044 | 4 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pb-12 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*235 | +10.234 | +10.790 | 3 | 8 | 18.6 | 0 | 14.4 | 0.3 | 235 | 20 | 555.6 | pa-5 | 0.268242 | 0.292755 | 0.0047 | 0.0023748 | 0.00261132
END PLATE | PLT20*225 | +10.240 | +10.584 | 5 | 8 | 11.3 | 0 | 14.6 | 0.2 | 225 | 20 | 343.6 | pc-4 | 0.165087 | 0.177364 | 0.0045 | 0.00143574 | 0.0015462
END PLATE | PLT20*190 | +15.024 | +15.900 | 4 | 8 | 26.1 | 0 | 14.4 | 0.3 | 190 | 20 | 875.6 | pb-1 | 0.375352 | 0.375352 | 0.0038 | 0.00332728 | 0.00332728
END PLATE | PLT20*190 | +9.934 | +10.584 | 3 | 8 | 19.4 | 0 | 14.4 | 0.3 | 190 | 20 | 649.6 | pa-2 | 0.280432 | 0.280432 | 0.0038 | 0.00246848 | 0.00246848
END PLATE | PLT20*190 | +10.240 | +10.910 | 3 | 8 | 20 | 0 | 14.4 | 0.3 | 190 | 20 | 669.6 | pa-1 | 0.288832 | 0.288832 | 0.0038 | 0.00254448 | 0.00254448
END PLATE | PLT20*190 | +5.124 | +5.694 | 3 | 8 | 17 | 0 | 14.4 | 0.2 | 190 | 20 | 569.6 | pa-32 | 0.246832 | 0.246832 | 0.0038 | 0.00216448 | 0.00216448
END PLATE | PLT20*190 | +5.350 | +6.020 | 3 | 8 | 20 | 0 | 14.4 | 0.3 | 190 | 20 | 669.6 | pa-1 | 0.288832 | 0.288832 | 0.0038 | 0.00254448 | 0.00254448
END PLATE | PLT20*190 | +5.350 | +5.900 | 3 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pa-31 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*235 | +5.344 | +5.900 | 3 | 8 | 18.6 | 0 | 14.4 | 0.3 | 235 | 20 | 555.6 | pa-5 | 0.268283 | 0.292756 | 0.0047 | 0.0023752 | 0.00261132
END PLATE | PLT20*190 | +5.344 | +5.694 | 5 | 8 | 10.5 | 0 | 14.8 | 0.2 | 190 | 20 | 349.6 | pc-56 | 0.154432 | 0.154432 | 0.0038 | 0.00132848 | 0.00132848
END PLATE | PLT20*190 | +5.344 | +5.694 | 5 | 8 | 10.5 | 0 | 14.8 | 0.2 | 190 | 20 | 349.6 | pc-55 | 0.154432 | 0.154432 | 0.0038 | 0.00132848 | 0.00132848
2 x END PLATE | PLT20*190 | +2.400 | +2.950 | 5 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-27 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +5.344 | +5.920 | 5 | 8 | 17.2 | 0 | 14.4 | 0.2 | 190 | 20 | 575.6 | pc-26 | 0.249352 | 0.249352 | 0.0038 | 0.00218728 | 0.00218728
END PLATE | PLT20*240 | +5.344 | +5.920 | 5 | 8 | 19.4 | 0 | 14.4 | 0.3 | 240 | 20 | 575.6 | pc-1 | 0.279448 | 0.308912 | 0.0048 | 0.0024778 | 0.00276288
2 x END PLATE | PLT20*190 | +2.400 | +2.950 | 3 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pa-31 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
2 x END PLATE | PLT12*85 | +2.576 | +2.720 | 5 | 8 | 1.3 | 0 | 25.9 | 0 | 85 | 12 | 144 | pc-95 | 0.029976 | 0.029976 | 0.00102 | 0.00014688 | 0.00014688

# IfcDiscreteAccessory: FLANGE PLATE (28)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Bottom elevation: +12.156; Top elevation: +12.488; Phase: 5; Class: 8
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 14.8 m2; Net surface area: 0.1 m2; Width: 20 mm; Length: 331.6 mm
Pset_PlateCommon - LoadBearing: yes
Name | Description | Weight (kg) | Height (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
23 x FLANGE PLATE | FL20*180 | 9.3 | 180 | pc-23 | 0.139829 | 0.0036 | 0.00119366
2 x FLANGE PLATE | PLT20*190 | 9.9 | 190 | pc-24 | 0.14686 | 0.0038 | 0.00125997
FLANGE PLATE | FL20*180 | 9.3 | 180 | pc-25 | 0.13984 | 0.0036 | 0.00119376
2 x FLANGE PLATE | FL20*180 | 9.3 | 180 | pc-23 | 0.13984 | 0.0036 | 0.00119376

# IfcDiscreteAccessory: FLOOR BRACE (6)
In: Undefined
Description: L70*70*8; Material: STEEL/S355JR
Tekla Common - Phase: 5; Class: 6
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 32.6 m2; Height: 70 mm; Width: 70 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00106497 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
FLOOR BRACE | +12.320 | +12.390 | 9.7 | 0.3 | 1147.7 | mc-452 | 0.31249 | 0.00121197 | 0.00122227
FLOOR BRACE | +9.920 | +9.990 | 8.5 | 0.3 | 1007.4 | mc-450 | 0.274282 | 0.00106379 | 0.00107282
FLOOR BRACE | +12.320 | +12.390 | 10.6 | 0.3 | 1266.4 | mc-451 | 0.344805 | 0.00133731 | 0.00134866
FLOOR BRACE | +7.720 | +7.790 | 8.5 | 0.3 | 1007.4 | mc-450 | 0.274282 | 0.00106379 | 0.00107282
FLOOR BRACE | +5.520 | +5.590 | 8.5 | 0.3 | 1007.4 | mc-450 | 0.274282 | 0.00106379 | 0.00107282
FLOOR BRACE | +5.520 | +5.590 | 7 | 0.2 | 832.1 | mc-449 | 0.226566 | 0.000878722 | 0.000886184

# IfcDiscreteAccessory: FRAME (7)
In: Undefined
Description: L80*80*8; Material: STEEL/S355JR
Tekla Common - Phase: 3; Class: 6
Tekla Quantity - Volume: 0 m3; Area per tons: 32.3 m2; Height: 80 mm; Width: 80 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00122675 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
FRAME | +5.710 | +6.090 | 3.7 | 0 | 0.1 | 380 | ma-117 | 0.118338 | 0.00046208 | 0.000466166
3 x FRAME | +5.710 | +6.090 | 3.7 | 0 | 0.1 | 380 | ma-116 | 0.118338 | 0.00046208 | 0.000466166
2 x FRAME | +6.020 | +6.100 | 9.5 | 0.1 | 0.3 | 984 | ma-115 | 0.306433 | 0.00115507 | 0.00120712
FRAME | +6.020 | +6.100 | 9.5 | 0.1 | 0.3 | 984 | ma-114 | 0.306433 | 0.00115507 | 0.00120712

# IfcDiscreteAccessory: GUSSET PLATE (958)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Class: 8
Tekla Quantity - Volume: 0 m3; Width: 10 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.0001 m2
Name | Description | Bottom elevation | Top elevation | Phase | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
GUSSET PLATE | PLT10*138.6 | +63.340 | +63.350 | 8 | 1.9 | 0 | 28.7 | 0.1 | 138.6 | 219.5 | pf-118 | 0.0570951 | 0.0304136 | 0.000253369 | 0.000253369
GUSSET PLATE | PLT10*138.5 | +63.340 | +63.350 | 8 | 2.1 | 0 | 28.7 | 0.1 | 138.6 | 239.5 | pf-119 | 0.0610817 | 0.0331619 | 0.000271457 | 0.000271457
GUSSET PLATE | PLT10*179.5 | +63.340 | +63.350 | 8 | 2.1 | 0 | 28.5 | 0.1 | 179.5 | 189.4 | pf-120 | 0.0604743 | 0.0340106 | 0.000270124 | 0.000270124
GUSSET PLATE | PLT10*184.2 | +63.340 | +63.350 | 8 | 2.2 | 0 | 28.5 | 0.1 | 184.2 | 194.4 | pf-121 | 0.0631916 | 0.0358082 | 0.000282894 | 0.000282894
GUSSET PLATE | PLT10*141.8 | +63.340 | +63.350 | 8 | 2.1 | 0 | 28.6 | 0.1 | 141.8 | 234.7 | pf-122 | 0.0609 | 0.0332839 | 0.000270832 | 0.000270832
GUSSET PLATE | PLT10*155.8 | +63.340 | +63.350 | 8 | 2.7 | 0 | 28.5 | 0.1 | 155.8 | 273.9 | pf-123 | 0.0773249 | 0.0426668 | 0.000347442 | 0.000347442
4 x GUSSET PLATE | PLT10*154.8 | +63.340 | +63.350 | 8 | 2.8 | 0 | 28.3 | 0.1 | 154.8 | 277.6 | pf-124 | 0.0780441 | 0.0429752 | 0.000350709 | 0.000350709
GUSSET PLATE | PLT10*181 | +63.340 | +63.350 | 8 | 2.2 | 0 | 28.5 | 0.1 | 181 | 198.7 | pf-125 | 0.0623949 | 0.0359599 | 0.00027887 | 0.00027887
GUSSET PLATE | PLT10*181.5 | +63.340 | +63.350 | 8 | 2.1 | 0 | 28.5 | 0.1 | 181.5 | 189.6 | pf-126 | 0.0611514 | 0.0344161 | 0.000273238 | 0.000273238
GUSSET PLATE | PLT10*155.2 | +63.340 | +63.350 | 8 | 2.6 | 0 | 28.5 | 0.1 | 155.2 | 279.2 | pf-127 | 0.0728381 | 0.0433324 | 0.000325356 | 0.000325356
GUSSET PLATE | PLT10*181.9 | +63.340 | +63.350 | 8 | 1.9 | 0 | 28.6 | 0.1 | 181.9 | 188.5 | pf-128 | 0.057874 | 0.0342911 | 0.000257404 | 0.000257404
GUSSET PLATE | PLT10*141.5 | +63.340 | +63.350 | 8 | 2.1 | 0 | 28.6 | 0.1 | 141.5 | 234.7 | pf-122 | 0.0608185 | 0.0332208 | 0.000270442 | 0.000270442
GUSSET PLATE | PLT10*189.4 | +63.340 | +63.350 | 8 | 2.3 | 0 | 28.5 | 0.1 | 189.4 | 193.3 | pf-129 | 0.0643946 | 0.0366127 | 0.000288542 | 0.000288542
GUSSET PLATE | PLT10*139.8 | +63.340 | +63.350 | 8 | 2.1 | 0 | 28.7 | 0.1 | 139.8 | 234.7 | pf-130 | 0.0602239 | 0.0328177 | 0.000267594 | 0.000267594
GUSSET PLATE | PLT10*155.8 | +63.340 | +63.350 | 8 | 2.6 | 0 | 28.5 | 0.1 | 155.8 | 279.9 | pf-127 | 0.0731981 | 0.0436019 | 0.000327056 | 0.000327056
GUSSET PLATE | PLT10*179.7 | +63.340 | +63.350 | 8 | 2.1 | 0 | 28.5 | 0.1 | 179.7 | 190.6 | pf-131 | 0.0604168 | 0.0342509 | 0.000269771 | 0.000269771
GUSSET PLATE | PLT10*180.6 | +63.340 | +63.350 | 8 | 2.2 | 0 | 28.5 | 0.1 | 180.6 | 200.3 | pf-132 | 0.0627168 | 0.0361692 | 0.000280364 | 0.000280364
2 x GUSSET PLATE | PLT10*154.6 | +63.340 | +63.350 | 8 | 2.2 | 0 | 28.5 | 0.1 | 154.6 | 224.9 | pf-133 | 0.0627542 | 0.0347686 | 0.000280252 | 0.000280252
2 x GUSSET PLATE | PLT10*157 | +63.340 | +63.350 | 8 | 2.1 | 0 | 28.6 | 0.1 | 157 | 219.9 | pf-134 | 0.0606289 | 0.0345118 | 0.000270059 | 0.000270059
GUSSET PLATE | PLT10*177.1 | +63.340 | +63.350 | 8 | 2.2 | 0 | 28.5 | 0.1 | 177.1 | 203.2 | pf-135 | 0.0637576 | 0.0359732 | 0.000285329 | 0.000285329
GUSSET PLATE | PLT10*177.1 | +63.340 | +63.350 | 8 | 2.2 | 0 | 28.5 | 0.1 | 177.1 | 203.2 | pf-136 | 0.0621813 | 0.0359732 | 0.000277711 | 0.000277711
GUSSET PLATE | PLT10*166.8 | +63.340 | +63.350 | 8 | 2.3 | 0 | 28.5 | 0.1 | 166.8 | 241.1 | pf-137 | 0.0668672 | 0.0402035 | 0.000298572 | 0.000298572
GUSSET PLATE | PLT10*159.5 | +63.340 | +63.350 | 8 | 2.3 | 0 | 28.5 | 0.1 | 159.5 | 224.7 | pf-138 | 0.0641742 | 0.0358247 | 0.000287034 | 0.000287034
GUSSET PLATE | PLT10*168.7 | +63.340 | +63.350 | 8 | 1.9 | 0 | 28.7 | 0.1 | 168.7 | 197.5 | pf-139 | 0.0571546 | 0.0333114 | 0.000254063 | 0.000254063
GUSSET PLATE | PLT10*175.4 | +63.340 | +63.350 | 8 | 2.3 | 0 | 28.5 | 0.1 | 175.4 | 208.8 | pf-140 | 0.0648851 | 0.0366208 | 0.000290545 | 0.000290545
GUSSET PLATE | PLT10*166.8 | +63.340 | +63.350 | 8 | 2.3 | 0 | 28.5 | 0.1 | 166.8 | 241.1 | pf-137 | 0.0668669 | 0.0402033 | 0.000298571 | 0.000298571
GUSSET PLATE | PLT10*156.4 | +63.340 | +63.350 | 8 | 2.2 | 0 | 28.5 | 0.1 | 156.4 | 219.7 | pf-141 | 0.0619132 | 0.0343514 | 0.000276426 | 0.000276426
GUSSET PLATE | PLT10*154.3 | +63.340 | +63.350 | 8 | 2.6 | 0 | 28.5 | 0.1 | 154.3 | 285.8 | pf-142 | 0.0741622 | 0.044093 | 0.000331372 | 0.000331372
GUSSET PLATE | PLT10*159.9 | +63.340 | +63.350 | 8 | 2.5 | 0 | 28.5 | 0.1 | 159.9 | 264.7 | pf-143 | 0.0707088 | 0.0423184 | 0.000315885 | 0.000315885
GUSSET PLATE | PLT10*154.3 | +63.340 | +63.350 | 8 | 2.1 | 0 | 28.6 | 0.1 | 154.3 | 219.9 | pf-144 | 0.0611556 | 0.0339361 | 0.000272676 | 0.000272676
GUSSET PLATE | PLT10*151.5 | +63.340 | +63.350 | 8 | 2.1 | 0 | 28.6 | 0.1 | 151.5 | 219.7 | pf-145 | 0.0598641 | 0.0332711 | 0.000266386 | 0.000266386
GUSSET PLATE | PLT10*178.2 | +63.340 | +63.350 | 8 | 2.3 | 0 | 28.5 | 0.1 | 178.2 | 209.7 | pf-146 | 0.0646145 | 0.0373769 | 0.000289154 | 0.000289154
GUSSET PLATE | FL10*150 | +63.340 | +63.350 | 8 | 2.6 | 0 | 28.5 | 0.1 | 149.9 | 266.2 | pf-147 | 0.0733822 | 0.0399047 | 0.000328829 | 0.000328829
GUSSET PLATE | PLT10*183.2 | +63.340 | +63.350 | 8 | 2.2 | 0 | 28.5 | 0.1 | 183.2 | 196 | pf-148 | 0.0624177 | 0.0359169 | 0.000279109 | 0.000279109
GUSSET PLATE | PLT10*142.8 | +63.340 | +63.350 | 8 | 1.9 | 0 | 28.7 | 0.1 | 142.8 | 219.7 | pf-149 | 0.0570905 | 0.0313762 | 0.000253166 | 0.000253166
GUSSET PLATE | PLT10*148.2 | +63.340 | +63.350 | 8 | 2.1 | 0 | 28.6 | 0.1 | 148.2 | 224.9 | pf-150 | 0.0603144 | 0.0333426 | 0.000268482 | 0.000268482
GUSSET PLATE | PLT10*160.4 | +63.340 | +63.350 | 8 | 2.7 | 0 | 28.5 | 0.1 | 160.4 | 274.6 | pf-151 | 0.0768101 | 0.0440515 | 0.000344922 | 0.000344922
GUSSET PLATE | PLT10*174.1 | +63.340 | +63.350 | 8 | 2.2 | 0 | 28.6 | 0.1 | 174.1 | 217.9 | pf-152 | 0.0629986 | 0.0379337 | 0.000280976 | 0.000280976
GUSSET PLATE | PLT10*166.5 | +63.340 | +63.350 | 8 | 2.1 | 0 | 28.6 | 0.1 | 166.5 | 203 | pf-153 | 0.0593715 | 0.0337965 | 0.000264658 | 0.000264658
GUSSET PLATE | PLT10*157.3 | +63.340 | +63.350 | 8 | 2.8 | 0 | 28.5 | 0.1 | 157.3 | 287 | pf-154 | 0.0790994 | 0.0451429 | 0.000355297 | 0.000355297
GUSSET PLATE | PLT10*157.3 | +63.340 | +63.350 | 8 | 2.5 | 0 | 28.5 | 0.1 | 157.3 | 274.2 | pf-105 | 0.0722611 | 0.0431249 | 0.000322854 | 0.000322854
GUSSET PLATE | PLT10*157.3 | +63.340 | +63.350 | 8 | 2.7 | 0 | 28.5 | 0.1 | 157.3 | 287 | pf-155 | 0.0765048 | 0.0451429 | 0.000342688 | 0.000342688
GUSSET PLATE | PLT10*157.3 | +63.340 | +63.350 | 8 | 2.5 | 0 | 28.5 | 0.1 | 157.3 | 274.2 | pf-105 | 0.0722612 | 0.0431249 | 0.000322855 | 0.000322855
2 x GUSSET PLATE | PLT10*160.3 | +63.340 | +63.350 | 8 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 263.1 | pf-90 | 0.0704462 | 0.0421796 | 0.000314704 | 0.000314704
GUSSET PLATE | PLT10*148 | +63.340 | +63.350 | 8 | 2.1 | 0 | 28.6 | 0.1 | 148 | 224.9 | pf-150 | 0.060246 | 0.03329 | 0.000268155 | 0.000268155
GUSSET PLATE | PLT10*148 | +63.340 | +63.350 | 8 | 2.1 | 0 | 28.6 | 0.1 | 148 | 224.9 | pf-150 | 0.0602459 | 0.03329 | 0.000268155 | 0.000268155
GUSSET PLATE | PLT10*154.1 | +63.340 | +63.350 | 8 | 2.6 | 0 | 28.5 | 0.1 | 154.1 | 286.6 | pf-112 | 0.0742777 | 0.0441648 | 0.000331879 | 0.000331879
GUSSET PLATE | PLT10*134.1 | +63.340 | +63.350 | 8 | 1.9 | 0 | 28.7 | 0.1 | 134.1 | 232.6 | pf-113 | 0.0582257 | 0.0311836 | 0.000258147 | 0.000258147
3 x GUSSET PLATE | PLT10*179.7 | +63.340 | +63.350 | 8 | 3.3 | 0 | 28.3 | 0.1 | 179.7 | 319.8 | pf-156 | 0.0918466 | 0.0574711 | 0.000414687 | 0.000414687
GUSSET PLATE | PLT10*179.7 | +63.340 | +63.350 | 8 | 3.4 | 0 | 28.1 | 0.1 | 179.7 | 315.8 | pf-157 | 0.0966319 | 0.0567522 | 0.000438308 | 0.000438308
2 x GUSSET PLATE | PLT10*201.3 | +63.340 | +63.350 | 8 | 2.8 | 0 | 28.3 | 0.1 | 201.3 | 243.3 | pf-158 | 0.0779806 | 0.0489792 | 0.000351413 | 0.000351413
2 x GUSSET PLATE | PLT10*196.7 | +63.340 | +63.350 | 8 | 2.8 | 0 | 28.3 | 0.1 | 196.7 | 229.3 | pf-159 | 0.0775471 | 0.0450975 | 0.000350514 | 0.000350514
2 x GUSSET PLATE | PLT10*200.1 | +63.340 | +63.350 | 8 | 2.7 | 0 | 28.3 | 0.1 | 200.1 | 239.9 | pf-160 | 0.0765063 | 0.0479898 | 0.000344445 | 0.000344445
2 x GUSSET PLATE | PLT10*188 | +63.340 | +63.350 | 8 | 2.5 | 0 | 28.5 | 0.1 | 188 | 221.5 | pf-161 | 0.0700906 | 0.0416297 | 0.000314871 | 0.000314871
GUSSET PLATE | PLT10*172 | +63.340 | +63.350 | 8 | 3.2 | 0 | 28.3 | 0.1 | 172 | 329 | pf-162 | 0.0914779 | 0.0566077 | 0.000412333 | 0.000412333
GUSSET PLATE | PLT10*172 | +63.340 | +63.350 | 8 | 3.4 | 0 | 28.1 | 0.1 | 172 | 329 | pf-163 | 0.0977159 | 0.0566077 | 0.000442792 | 0.000442792
GUSSET PLATE | PLT10*158.8 | +63.343 | +63.353 | 8 | 2.5 | 0 | 28.5 | 0.1 | 158.8 | 278.1 | pf-166 | 0.0725956 | 0.0441535 | 0.000324228 | 0.000324228
GUSSET PLATE | PLT10*158.8 | +63.343 | +63.353 | 8 | 2.7 | 0 | 28.5 | 0.1 | 158.8 | 268.7 | pf-167 | 0.0761712 | 0.042666 | 0.000342153 | 0.000342153
GUSSET PLATE | PLT10*176.3 | +70.543 | +70.553 | 8 | 2.2 | 0 | 28.6 | 0.1 | 176.3 | 210.2 | pf-164 | 0.0616868 | 0.0370613 | 0.000274973 | 0.000274973
GUSSET PLATE | PLT10*167.6 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 167.6 | 187 | pf-165 | 0.0541532 | 0.0313508 | 0.000240073 | 0.000240073
GUSSET PLATE | PLT10*128.2 | +55.198 | +55.208 | 8 | 2.2 | 0 | 28.7 | 0.1 | 128.2 | 258.3 | pf-168 | 0.0635412 | 0.0331247 | 0.000282363 | 0.000282363
GUSSET PLATE | PLT10*146.6 | +55.198 | +55.208 | 8 | 2.8 | 0 | 28.5 | 0.1 | 146.6 | 320 | pf-169 | 0.0799433 | 0.0469063 | 0.000357253 | 0.000357253
GUSSET PLATE | PLT10*156.1 | +63.343 | +63.353 | 8 | 2.6 | 0 | 28.5 | 0.1 | 156.1 | 278.7 | pf-175 | 0.0730161 | 0.0435098 | 0.000326241 | 0.000326241
GUSSET PLATE | PLT10*156.1 | +63.343 | +63.353 | 8 | 2.5 | 0 | 28.5 | 0.1 | 156.1 | 272.8 | pf-176 | 0.0721937 | 0.0425771 | 0.000322615 | 0.000322615
GUSSET PLATE | PLT10*156.1 | +38.931 | +38.941 | 7 | 2.6 | 0 | 28.5 | 0.1 | 156.1 | 278.7 | pe-137 | 0.0730161 | 0.0435098 | 0.000326241 | 0.000326241
GUSSET PLATE | PLT10*156.1 | +38.931 | +38.941 | 7 | 2.5 | 0 | 28.5 | 0.1 | 156.1 | 272.8 | pe-136 | 0.0721937 | 0.0425771 | 0.000322615 | 0.000322615
GUSSET PLATE | PLT10*164.1 | +48.593 | +48.603 | 7 | 2.1 | 0 | 28.6 | 0.1 | 164.1 | 208.5 | pe-134 | 0.0587664 | 0.0342094 | 0.00026146 | 0.00026146
2 x GUSSET PLATE | PLT10*171 | +48.593 | +48.603 | 7 | 2.3 | 0 | 28.5 | 0.1 | 171 | 226.2 | pe-135 | 0.0643294 | 0.0386778 | 0.000287038 | 0.000287038
GUSSET PLATE | PLT10*164.1 | +48.593 | +48.603 | 7 | 2.1 | 0 | 28.6 | 0.1 | 164.1 | 208.5 | pe-134 | 0.0587662 | 0.0342093 | 0.000261459 | 0.000261459
2 x GUSSET PLATE | PLT10*172.5 | +48.593 | +48.603 | 7 | 2.2 | 0 | 28.6 | 0.1 | 172.5 | 222.2 | pe-133 | 0.0637511 | 0.0383197 | 0.000284426 | 0.000284426
2 x GUSSET PLATE | PLT10*171 | +48.593 | +48.603 | 7 | 2.3 | 0 | 28.5 | 0.1 | 171 | 227 | pe-104 | 0.0645564 | 0.0388232 | 0.000288093 | 0.000288093
2 x GUSSET PLATE | PLT10*179.1 | +48.593 | +48.603 | 7 | 2.1 | 0 | 28.6 | 0.1 | 179.1 | 199.3 | pe-132 | 0.0598236 | 0.0356929 | 0.000266421 | 0.000266421
GUSSET PLATE | PLT10*177.7 | +48.593 | +48.603 | 7 | 2.1 | 0 | 28.6 | 0.1 | 177.7 | 204.2 | pe-131 | 0.0606785 | 0.0362883 | 0.000270358 | 0.000270358
GUSSET PLATE | PLT10*167.9 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 167.9 | 186.3 | pe-130 | 0.0538969 | 0.0312797 | 0.000238859 | 0.000238859
2 x GUSSET PLATE | PLT10*175.3 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 175.4 | 184.9 | pe-129 | 0.0553662 | 0.0324118 | 0.000245732 | 0.000245732
2 x GUSSET PLATE | PLT10*163.2 | +48.593 | +48.603 | 7 | 2.2 | 0 | 28.6 | 0.1 | 163.2 | 219.5 | pe-128 | 0.0617094 | 0.0357972 | 0.000275152 | 0.000275152
2 x GUSSET PLATE | PLT10*182.3 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.6 | 0.1 | 182.3 | 186.8 | pe-127 | 0.0575496 | 0.0340524 | 0.000255899 | 0.000255899
2 x GUSSET PLATE | PLT10*182.4 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.6 | 0.1 | 182.3 | 186.5 | pe-127 | 0.057501 | 0.0340165 | 0.000255673 | 0.000255673
2 x GUSSET PLATE | PLT10*177.7 | +48.593 | +48.603 | 7 | 1.9 | 0 | 28.7 | 0.1 | 177.7 | 184.4 | pe-126 | 0.0558203 | 0.0327575 | 0.000247852 | 0.000247852
GUSSET PLATE | PLT10*166.4 | +48.593 | +48.603 | 7 | 2.5 | 0 | 28.5 | 0.1 | 166.5 | 242.2 | pe-125 | 0.0670524 | 0.0403102 | 0.000299409 | 0.000299409
GUSSET PLATE | PLT10*157.2 | +48.593 | +48.603 | 7 | 2.1 | 0 | 28.6 | 0.1 | 157.3 | 219.7 | pe-124 | 0.0601638 | 0.0345371 | 0.000267798 | 0.000267798
2 x GUSSET PLATE | PLT10*153.3 | +48.593 | +48.603 | 7 | 2.1 | 0 | 28.7 | 0.1 | 153.3 | 219.9 | pe-121 | 0.0591318 | 0.0336948 | 0.000262883 | 0.000262883
2 x GUSSET PLATE | PLT10*162.1 | +48.593 | +48.603 | 7 | 2.1 | 0 | 28.6 | 0.1 | 162.1 | 219.5 | pe-123 | 0.0614266 | 0.0355669 | 0.000273808 | 0.000273808
2 x GUSSET PLATE | PLT10*153.5 | +48.593 | +48.603 | 7 | 2.1 | 0 | 28.7 | 0.1 | 153.5 | 219.9 | pe-121 | 0.0591955 | 0.0337468 | 0.000263187 | 0.000263187
GUSSET PLATE | PLT10*136.3 | +48.593 | +48.603 | 7 | 2.1 | 0 | 28.7 | 0.1 | 136.3 | 239.5 | pe-122 | 0.0606584 | 0.032642 | 0.000269475 | 0.000269475
GUSSET PLATE | PLT10*155.1 | +48.593 | +48.603 | 7 | 2.6 | 0 | 28.5 | 0.1 | 155.2 | 282.8 | pe-119 | 0.073766 | 0.0438461 | 0.000329634 | 0.000329634
GUSSET PLATE | PLT10*153.7 | +48.593 | +48.603 | 7 | 2.6 | 0 | 28.5 | 0.1 | 153.7 | 288.2 | pe-120 | 0.0744868 | 0.0442945 | 0.000332796 | 0.000332796
GUSSET PLATE | PLT10*155.1 | +48.593 | +48.603 | 7 | 2.6 | 0 | 28.5 | 0.1 | 155.2 | 282.8 | pe-119 | 0.0736825 | 0.0438461 | 0.000329228 | 0.000329228
2 x GUSSET PLATE | PLT10*169.2 | +48.593 | +48.603 | 7 | 2.1 | 0 | 28.6 | 0.1 | 169.2 | 208.3 | pe-118 | 0.060284 | 0.0352448 | 0.000268657 | 0.000268657
GUSSET PLATE | PLT10*147.9 | +48.593 | +48.603 | 7 | 2.1 | 0 | 28.6 | 0.1 | 148 | 230 | pe-117 | 0.0607769 | 0.0340093 | 0.000270401 | 0.000270401
GUSSET PLATE | PLT10*160.6 | +48.593 | +48.603 | 7 | 2.5 | 0 | 28.5 | 0.1 | 160.6 | 262.3 | pe-75 | 0.0703206 | 0.042113 | 0.00031414 | 0.00031414
GUSSET PLATE | PLT10*176.8 | +44.468 | +44.478 | 7 | 2.1 | 0 | 28.6 | 0.1 | 176.8 | 208.8 | pe-116 | 0.0614266 | 0.0368845 | 0.000273779 | 0.000273779
GUSSET PLATE | PLT10*168.9 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.7 | 0.1 | 168.9 | 186.8 | pe-115 | 0.054413 | 0.0315536 | 0.000241291 | 0.000241291
GUSSET PLATE | PLT10*176.2 | +36.163 | +36.173 | 6 | 2.2 | 0 | 28.6 | 0.1 | 176.3 | 210.6 | pd-114 | 0.0617524 | 0.0371057 | 0.000275273 | 0.000275273
GUSSET PLATE | PLT10*167.3 | +36.163 | +36.173 | 6 | 1.9 | 0 | 28.7 | 0.1 | 167.3 | 187.1 | pd-113 | 0.0540877 | 0.0312996 | 0.000239766 | 0.000239766
2 x GUSSET PLATE | PLT10*160.5 | +28.973 | +28.983 | 6 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pd-56 | 0.0703425 | 0.0421247 | 0.000314238 | 0.000314238
GUSSET PLATE | PLT10*160.6 | +28.973 | +28.983 | 6 | 2.5 | 0 | 28.5 | 0.1 | 160.6 | 262.3 | pd-56 | 0.0703206 | 0.042113 | 0.00031414 | 0.00031414
2 x GUSSET PLATE | PLT10*142.5 | +28.973 | +28.983 | 6 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pd-95 | 0.0567125 | 0.0313561 | 0.000251411 | 0.000251411
GUSSET PLATE | PLT10*142.6 | +28.973 | +28.983 | 6 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pd-95 | 0.0567324 | 0.0313757 | 0.000251506 | 0.000251506
GUSSET PLATE | PLT10*149.7 | +28.973 | +28.983 | 6 | 2.1 | 0 | 28.7 | 0.1 | 149.7 | 224.9 | pd-112 | 0.0597232 | 0.0336769 | 0.000265537 | 0.000265537
GUSSET PLATE | PLT10*149.2 | +28.973 | +28.983 | 6 | 2.1 | 0 | 28.7 | 0.1 | 149.2 | 224.9 | pd-112 | 0.0596429 | 0.0335722 | 0.000265164 | 0.000265164
GUSSET PLATE | PLT10*173.3 | +28.973 | +28.983 | 6 | 2.2 | 0 | 28.6 | 0.1 | 173.3 | 219.5 | pd-111 | 0.0632874 | 0.0380244 | 0.000282312 | 0.000282312
GUSSET PLATE | PLT10*170.6 | +28.973 | +28.983 | 6 | 2.1 | 0 | 28.6 | 0.1 | 170.6 | 208.3 | pd-110 | 0.0605615 | 0.0355203 | 0.000269954 | 0.000269954
GUSSET PLATE | PLT10*129.1 | +15.593 | +15.603 | 5 | 2.1 | 0 | 28.7 | 0.1 | 129.1 | 246.5 | pc-198 | 0.0609345 | 0.0318331 | 0.000270254 | 0.000270254
GUSSET PLATE | PLT10*120.5 | +15.593 | +15.603 | 5 | 1.9 | 0 | 28.9 | 0.1 | 120.5 | 245.2 | pc-197 | 0.0576842 | 0.0295422 | 0.000254579 | 0.000254579
GUSSET PLATE | FL10*130 | +15.593 | +15.603 | 5 | 5.4 | 0.1 | 27.9 | 0.1 | 130 | 537.6 | pc-159 | 0.146692 | 0.0698835 | 0.000668805 | 0.000668805
2 x GUSSET PLATE | PLT10*162.1 | +15.593 | +15.603 | 5 | 2.3 | 0 | 28.6 | 0.1 | 162.1 | 256.8 | pc-190 | 0.0671861 | 0.0416372 | 0.000299222 | 0.000299222
2 x GUSSET PLATE | PLT10*168.7 | +15.593 | +15.603 | 5 | 2.2 | 0 | 28.6 | 0.1 | 168.7 | 234.7 | pc-194 | 0.0638667 | 0.0395982 | 0.000284332 | 0.000284332
2 x GUSSET PLATE | PLT10*163.5 | +15.593 | +15.603 | 5 | 2.3 | 0 | 28.6 | 0.1 | 163.5 | 252 | pc-193 | 0.0664646 | 0.0412103 | 0.000295995 | 0.000295995
2 x GUSSET PLATE | PLT10*160.8 | +15.593 | +15.603 | 5 | 2.5 | 0 | 28.6 | 0.1 | 160.8 | 261.6 | pc-192 | 0.0678975 | 0.0420506 | 0.0003024 | 0.0003024
2 x GUSSET PLATE | PLT10*166.8 | +15.593 | +15.603 | 5 | 2.3 | 0 | 28.6 | 0.1 | 166.8 | 240.9 | pc-191 | 0.0647897 | 0.0401855 | 0.000288485 | 0.000288485
GUSSET PLATE | PLT10*162.1 | +15.593 | +15.603 | 5 | 6.3 | 0.1 | 27.5 | 0.2 | 162.1 | 513.7 | pc-158 | 0.174109 | 0.0832744 | 0.000805822 | 0.000805822
GUSSET PLATE | PLT10*166.8 | +15.593 | +15.603 | 5 | 6.1 | 0.1 | 27.5 | 0.2 | 166.8 | 481.8 | pc-157 | 0.167395 | 0.0803709 | 0.000775121 | 0.000775121
GUSSET PLATE | PLT10*160.8 | +15.593 | +15.603 | 5 | 6.3 | 0.1 | 27.5 | 0.2 | 160.8 | 523.2 | pc-156 | 0.176035 | 0.0841012 | 0.000814595 | 0.000814595
GUSSET PLATE | PLT10*163.5 | +15.593 | +15.603 | 5 | 6.3 | 0.1 | 27.5 | 0.2 | 163.5 | 504.1 | pc-155 | 0.172126 | 0.0824206 | 0.000796772 | 0.000796772
GUSSET PLATE | PLT10*168.7 | +15.593 | +15.603 | 5 | 5.9 | 0.1 | 27.5 | 0.2 | 168.7 | 469.6 | pc-154 | 0.164706 | 0.0791965 | 0.000762773 | 0.000762773
GUSSET PLATE | PLT10*164.4 | +15.593 | +15.603 | 5 | 2.6 | 0 | 28.7 | 0.1 | 164.4 | 324 | pc-196 | 0.0740345 | 0.0532684 | 0.000328005 | 0.000328005
GUSSET PLATE | PLT10*164.4 | +15.593 | +15.603 | 5 | 2.6 | 0 | 28.5 | 0.1 | 164.4 | 249 | pc-195 | 0.0724725 | 0.040939 | 0.000325318 | 0.000325318
GUSSET PLATE | PLT10*153.5 | +15.593 | +15.603 | 5 | 6.8 | 0.1 | 27.6 | 0.2 | 153.5 | 595.4 | pc-153 | 0.190293 | 0.0914007 | 0.000879235 | 0.000879235
GUSSET PLATE | PLT10*155.3 | +15.593 | +15.603 | 5 | 2.1 | 0 | 28.5 | 0.1 | 155.2 | 214.5 | pc-189 | 0.0611455 | 0.0333054 | 0.000272837 | 0.000272837
GUSSET PLATE | PLT10*151.1 | +15.593 | +15.603 | 5 | 2.2 | 0 | 28.6 | 0.1 | 151.1 | 223.9 | pc-188 | 0.0620227 | 0.0338351 | 0.000276606 | 0.000276606
GUSSET PLATE | PLT10*169.9 | +15.593 | +15.603 | 5 | 1.7 | 0 | 28.7 | 0.1 | 169.9 | 182.1 | pc-187 | 0.052796 | 0.0309366 | 0.000233635 | 0.000233635
GUSSET PLATE | PLT10*165.7 | +15.593 | +15.603 | 5 | 1.7 | 0 | 28.7 | 0.1 | 165.7 | 183.1 | pc-182 | 0.052011 | 0.030348 | 0.000229968 | 0.000229968
2 x GUSSET PLATE | PLT10*168.3 | +15.593 | +15.603 | 5 | 2.2 | 0 | 28.6 | 0.1 | 168.3 | 219 | pc-183 | 0.0615658 | 0.0368738 | 0.000274063 | 0.000274063
2 x GUSSET PLATE | PLT10*162.2 | +15.593 | +15.603 | 5 | 2.3 | 0 | 28.6 | 0.1 | 162.1 | 239.7 | pc-184 | 0.0650278 | 0.0388798 | 0.000289769 | 0.000289769
2 x GUSSET PLATE | PLT10*162.2 | +15.593 | +15.603 | 5 | 2.3 | 0 | 28.6 | 0.1 | 162.1 | 238.8 | pc-184 | 0.064808 | 0.0387419 | 0.000288751 | 0.000288751
GUSSET PLATE | PLT10*177 | +15.593 | +15.603 | 5 | 1.9 | 0 | 28.7 | 0.1 | 177 | 189.1 | pc-186 | 0.0563252 | 0.0334765 | 0.000250021 | 0.000250021
GUSSET PLATE | PLT10*165.4 | +15.593 | +15.603 | 5 | 1.9 | 0 | 28.6 | 0.1 | 165.4 | 206.7 | pc-185 | 0.0586086 | 0.0341924 | 0.000260796 | 0.000260796
GUSSET PLATE | PLT10*166.6 | +15.593 | +15.603 | 5 | 1.7 | 0 | 28.7 | 0.1 | 166.6 | 183.1 | pc-182 | 0.0522469 | 0.0305036 | 0.000231074 | 0.000231074
GUSSET PLATE | PLT10*168.3 | +15.593 | +15.603 | 5 | 2.1 | 0 | 28.7 | 0.1 | 168.3 | 218.2 | pc-181 | 0.0595392 | 0.0367307 | 0.00026427 | 0.00026427
GUSSET PLATE | PLT10*169.9 | +15.593 | +15.603 | 5 | 1.7 | 0 | 28.9 | 0.1 | 169.9 | 182.1 | pc-180 | 0.0516269 | 0.0309366 | 0.000227943 | 0.000227943
GUSSET PLATE | PLT10*168.3 | +15.593 | +15.603 | 5 | 2.2 | 0 | 28.6 | 0.1 | 168.3 | 218.2 | pc-179 | 0.0622434 | 0.0367307 | 0.000277395 | 0.000277395
GUSSET PLATE | PLT10*156.1 | +28.973 | +28.983 | 6 | 2.6 | 0 | 28.5 | 0.1 | 156.1 | 278.7 | pd-109 | 0.0730161 | 0.0435098 | 0.000326241 | 0.000326241
GUSSET PLATE | PLT10*156.1 | +28.973 | +28.983 | 6 | 2.5 | 0 | 28.5 | 0.1 | 156.1 | 272.8 | pd-108 | 0.0721937 | 0.0425771 | 0.000322615 | 0.000322615
GUSSET PLATE | PLT10*179.9 | +5.593 | +5.603 | 5 | 1.9 | 0 | 28.7 | 0.1 | 180 | 196.1 | pc-178 | 0.0577866 | 0.0352871 | 0.000256655 | 0.000256655
GUSSET PLATE | PLT10*179.9 | +5.593 | +5.603 | 5 | 1.9 | 0 | 28.7 | 0.1 | 180 | 189.4 | pc-177 | 0.0554398 | 0.0340702 | 0.000246036 | 0.000246036
GUSSET PLATE | PLT10*181.4 | +12.393 | +12.403 | 5 | 1.9 | 0 | 28.7 | 0.1 | 181.5 | 190.3 | pc-176 | 0.0574045 | 0.034533 | 0.000255045 | 0.000255045
GUSSET PLATE | PLT10*181.4 | +12.393 | +12.403 | 5 | 2.1 | 0 | 28.5 | 0.1 | 181.5 | 191.2 | pc-175 | 0.0603456 | 0.0346944 | 0.000269279 | 0.000269279
GUSSET PLATE | PLT10*120 | +12.390 | +12.400 | 5 | 1.3 | 0 | 29.4 | 0 | 120 | 140 | pc-147 | 0.0388 | 0.0168 | 0.000168 | 0.000168
GUSSET PLATE | FL10*130 | +12.390 | +12.400 | 5 | 1.3 | 0 | 29.4 | 0 | 130 | 130 | pc-145 | 0.0375036 | 0.0169 | 0.000162547 | 0.000169
2 x GUSSET PLATE | FL10*130 | +12.390 | +12.400 | 5 | 1.5 | 0 | 29.2 | 0 | 130 | 140 | pc-146 | 0.0418 | 0.0182 | 0.000182 | 0.000182
2 x GUSSET PLATE | FL10*130 | +9.990 | +10.000 | 5 | 1.5 | 0 | 29.2 | 0 | 130 | 140 | pc-146 | 0.0418 | 0.0182 | 0.000182 | 0.000182
2 x GUSSET PLATE | FL10*130 | +7.790 | +7.800 | 5 | 1.5 | 0 | 29.2 | 0 | 130 | 140 | pc-146 | 0.0418 | 0.0182 | 0.000182 | 0.000182
3 x GUSSET PLATE | FL10*130 | +5.590 | +5.600 | 5 | 1.5 | 0 | 29.2 | 0 | 130 | 140 | pc-146 | 0.0418 | 0.0182 | 0.000182 | 0.000182
GUSSET PLATE | FL10*130 | +5.590 | +5.600 | 5 | 1.5 | 0 | 29.2 | 0 | 130 | 160 | pc-144 | 0.043049 | 0.0208 | 0.000188088 | 0.000208
6 x GUSSET PLATE | PLT10*170 | +5.793 | +5.803 | 5 | 1.7 | 0 | 28.9 | 0.1 | 169.9 | 180 | pc-141 | 0.050344 | 0.0306 | 0.000221 | 0.000221
GUSSET PLATE | PLT10*170 | +5.793 | +5.803 | 5 | 3.8 | 0 | 27.8 | 0.1 | 169.9 | 301.2 | pc-152 | 0.106455 | 0.0512046 | 0.000487005 | 0.000487005
GUSSET PLATE | PLT10*170 | +5.793 | +5.803 | 5 | 6.6 | 0.1 | 27.5 | 0.2 | 169.9 | 522 | pc-140 | 0.180605 | 0.0887481 | 0.000837522 | 0.000837522
GUSSET PLATE | PLT10*170 | +5.793 | +5.803 | 5 | 6.6 | 0.1 | 27.5 | 0.2 | 169.9 | 525.5 | pc-139 | 0.181595 | 0.0893315 | 0.000842155 | 0.000842155
GUSSET PLATE | PLT10*151.1 | +5.793 | +5.803 | 5 | 2.1 | 0 | 28.7 | 0.1 | 151.1 | 219.9 | pc-174 | 0.058995 | 0.0332374 | 0.000262213 | 0.000262213
GUSSET PLATE | PLT10*160.2 | +5.793 | +5.803 | 5 | 2.5 | 0 | 28.5 | 0.1 | 160.2 | 263.6 | pc-173 | 0.0705397 | 0.0422291 | 0.000315125 | 0.000315125
GUSSET PLATE | PLT10*169.5 | +5.793 | +5.803 | 5 | 6.6 | 0.1 | 27.5 | 0.2 | 169.5 | 525.6 | pc-138 | 0.181361 | 0.0890883 | 0.000840978 | 0.000840978
GUSSET PLATE | PLT10*170 | +5.793 | +5.803 | 5 | 6.6 | 0.1 | 27.5 | 0.2 | 169.9 | 521.7 | pc-137 | 0.180498 | 0.0886851 | 0.00083702 | 0.00083702
GUSSET PLATE | PLT10*170 | +5.793 | +5.803 | 5 | 4.1 | 0.1 | 27.8 | 0.1 | 169.9 | 349.7 | pc-151 | 0.115103 | 0.059455 | 0.000527519 | 0.000527519
GUSSET PLATE | PLT10*166.7 | +70.540 | +70.550 | 8 | 2.1 | 0 | 28.7 | 0.1 | 166.6 | 212.9 | pf-75 | 0.059161 | 0.0354797 | 0.000262751 | 0.000262751
GUSSET PLATE | PLT10*171.4 | +70.540 | +70.550 | 8 | 1.9 | 0 | 28.7 | 0.1 | 171.4 | 201.4 | pf-76 | 0.0581902 | 0.0345243 | 0.000258648 | 0.000258648
GUSSET PLATE | PLT10*190.5 | +70.540 | +70.550 | 8 | 2.2 | 0 | 28.5 | 0.1 | 190.5 | 196.5 | pf-77 | 0.0627921 | 0.0374373 | 0.000280429 | 0.000280429
GUSSET PLATE | PLT10*174.3 | +70.540 | +70.550 | 8 | 1.9 | 0 | 28.7 | 0.1 | 174.3 | 187.6 | pf-78 | 0.0550578 | 0.0327081 | 0.00024397 | 0.00024397
GUSSET PLATE | PLT10*143.2 | +68.340 | +68.350 | 8 | 2.5 | 0 | 28.6 | 0.1 | 143.2 | 282.7 | pf-79 | 0.0700557 | 0.0404678 | 0.000311665 | 0.000311665
GUSSET PLATE | PLT10*143.2 | +68.340 | +68.350 | 8 | 2.5 | 0 | 28.7 | 0.1 | 143.2 | 292 | pf-80 | 0.0710084 | 0.0417986 | 0.00031569 | 0.00031569
GUSSET PLATE | PLT10*144.2 | +66.140 | +66.150 | 8 | 1.9 | 0 | 28.7 | 0.1 | 144.2 | 225.2 | pf-73 | 0.0574082 | 0.0324715 | 0.000254389 | 0.000254389
GUSSET PLATE | PLT10*153.2 | +66.140 | +66.150 | 8 | 2.5 | 0 | 28.5 | 0.1 | 153.3 | 248.5 | pf-74 | 0.0680186 | 0.0380583 | 0.000303832 | 0.000303832
GUSSET PLATE | PLT10*143.5 | +48.590 | +48.600 | 7 | 2.5 | 0 | 28.6 | 0.1 | 143.5 | 279.6 | pe-114 | 0.0694392 | 0.0401296 | 0.000308865 | 0.000308865
GUSSET PLATE | PLT10*125.2 | +48.590 | +48.600 | 7 | 1.9 | 0 | 28.9 | 0.1 | 125.2 | 230.4 | pe-113 | 0.0537026 | 0.0288476 | 0.000236464 | 0.000236464
GUSSET PLATE | PLT10*141.9 | +63.340 | +63.350 | 8 | 2.5 | 0 | 28.7 | 0.1 | 141.8 | 297 | pf-81 | 0.0717717 | 0.0421552 | 0.000319069 | 0.000319069
GUSSET PLATE | PLT10*144.4 | +63.340 | +63.350 | 8 | 2.5 | 0 | 28.6 | 0.1 | 144.4 | 276.4 | pf-82 | 0.0689418 | 0.0399063 | 0.000306655 | 0.000306655
GUSSET PLATE | PLT10*141.9 | +63.340 | +63.350 | 8 | 2.5 | 0 | 28.6 | 0.1 | 141.8 | 285.6 | pf-83 | 0.0703583 | 0.0405392 | 0.000312946 | 0.000312946
GUSSET PLATE | PLT10*144.4 | +63.340 | +63.350 | 8 | 2.6 | 0 | 28.5 | 0.1 | 144.4 | 278.3 | pf-84 | 0.0730579 | 0.040186 | 0.000326503 | 0.000326503
GUSSET PLATE | PLT10*143.1 | +60.625 | +60.635 | 8 | 2.5 | 0 | 28.6 | 0.1 | 143.1 | 281.1 | pf-172 | 0.0696558 | 0.0402265 | 0.000309827 | 0.000309827
GUSSET PLATE | PLT10*143.1 | +60.625 | +60.635 | 8 | 2.5 | 0 | 28.7 | 0.1 | 143.1 | 292.1 | pf-80 | 0.0710286 | 0.041808 | 0.000315779 | 0.000315779
GUSSET PLATE | PLT10*134.7 | +57.910 | +57.920 | 8 | 1.9 | 0 | 28.7 | 0.1 | 134.7 | 230.4 | pf-170 | 0.0559358 | 0.0310489 | 0.000247097 | 0.000247097
GUSSET PLATE | PLT10*134.7 | +57.910 | +57.920 | 8 | 1.9 | 0 | 28.7 | 0.1 | 134.7 | 230.4 | pf-171 | 0.056226 | 0.0310489 | 0.000248528 | 0.000248528
GUSSET PLATE | PLT10*146.2 | +55.195 | +55.205 | 8 | 2.5 | 0 | 28.7 | 0.1 | 146.2 | 280.2 | pf-173 | 0.0692351 | 0.0409585 | 0.000307833 | 0.000307833
GUSSET PLATE | PLT10*145.9 | +55.195 | +55.205 | 8 | 2.5 | 0 | 28.5 | 0.1 | 145.9 | 271.8 | pf-174 | 0.0718086 | 0.0396641 | 0.000320846 | 0.000320846
GUSSET PLATE | PLT10*134.7 | +52.930 | +52.940 | 8 | 1.9 | 0 | 28.7 | 0.1 | 134.7 | 230.4 | pf-170 | 0.0559358 | 0.0310489 | 0.000247097 | 0.000247097
GUSSET PLATE | PLT10*134.7 | +52.930 | +52.940 | 8 | 1.9 | 0 | 28.7 | 0.1 | 134.7 | 230.4 | pf-171 | 0.056226 | 0.0310489 | 0.000248528 | 0.000248528
GUSSET PLATE | PLT10*143.1 | +51.043 | +51.053 | 8 | 2.5 | 0 | 28.7 | 0.1 | 143.1 | 292.1 | pf-80 | 0.0710286 | 0.041808 | 0.000315779 | 0.000315779
GUSSET PLATE | PLT10*143.1 | +51.043 | +51.053 | 8 | 2.5 | 0 | 28.6 | 0.1 | 143.1 | 281.1 | pf-172 | 0.0696558 | 0.0402265 | 0.000309827 | 0.000309827
GUSSET PLATE | PLT10*143.1 | +46.903 | +46.913 | 7 | 2.5 | 0 | 28.7 | 0.1 | 143.1 | 292.1 | pe-112 | 0.0710286 | 0.041808 | 0.000315779 | 0.000315779
GUSSET PLATE | PLT10*143.1 | +46.903 | +46.913 | 7 | 2.5 | 0 | 28.6 | 0.1 | 143.1 | 281.1 | pe-111 | 0.0696558 | 0.0402265 | 0.000309827 | 0.000309827
GUSSET PLATE | PLT10*138.5 | +44.465 | +44.475 | 7 | 2.8 | 0 | 28.5 | 0.1 | 138.6 | 310.5 | pe-110 | 0.0791825 | 0.0430055 | 0.000354205 | 0.000354205
GUSSET PLATE | PLT10*138.8 | +44.465 | +44.475 | 7 | 2.6 | 0 | 28.7 | 0.1 | 138.8 | 310.9 | pe-109 | 0.0739045 | 0.0431411 | 0.000328507 | 0.000328507
GUSSET PLATE | PLT10*143.1 | +41.696 | +41.706 | 7 | 2.5 | 0 | 28.7 | 0.1 | 143.1 | 292.1 | pe-112 | 0.0710286 | 0.041808 | 0.000315779 | 0.000315779
GUSSET PLATE | PLT10*143.1 | +41.696 | +41.706 | 7 | 2.5 | 0 | 28.6 | 0.1 | 143.1 | 281.1 | pe-111 | 0.0696558 | 0.0402265 | 0.000309827 | 0.000309827
GUSSET PLATE | PLT10*138.5 | +38.928 | +38.938 | 7 | 2.8 | 0 | 28.5 | 0.1 | 138.6 | 310.5 | pe-110 | 0.0791825 | 0.0430055 | 0.000354205 | 0.000354205
GUSSET PLATE | PLT10*138.8 | +38.928 | +38.938 | 7 | 2.6 | 0 | 28.7 | 0.1 | 138.8 | 310.9 | pe-109 | 0.0739045 | 0.0431411 | 0.000328507 | 0.000328507
GUSSET PLATE | PLT10*145 | +36.160 | +36.170 | 6 | 2.5 | 0 | 28.7 | 0.1 | 145 | 276.2 | pd-107 | 0.0678998 | 0.0400532 | 0.000301607 | 0.000301607
GUSSET PLATE | PLT10*145 | +36.160 | +36.170 | 6 | 2.2 | 0 | 28.7 | 0.1 | 145 | 256.4 | pd-106 | 0.0643143 | 0.0371846 | 0.000285449 | 0.000285449
GUSSET PLATE | PLT10*147.8 | +36.160 | +36.170 | 6 | 2.2 | 0 | 28.7 | 0.1 | 147.8 | 246.8 | pd-105 | 0.0628029 | 0.0364661 | 0.000278696 | 0.000278696
GUSSET PLATE | PLT10*147.8 | +36.160 | +36.170 | 6 | 2.5 | 0 | 28.5 | 0.1 | 147.8 | 266.2 | pd-104 | 0.070999 | 0.0393377 | 0.000317253 | 0.000317253
GUSSET PLATE | PLT10*140.6 | +33.889 | +33.899 | 6 | 2.5 | 0 | 28.6 | 0.1 | 140.6 | 290.8 | pd-103 | 0.0711583 | 0.040893 | 0.000316497 | 0.000316497
GUSSET PLATE | PLT10*140.6 | +33.889 | +33.899 | 6 | 2.5 | 0 | 28.7 | 0.1 | 140.6 | 302.5 | pd-102 | 0.0726183 | 0.0425482 | 0.000322816 | 0.000322816
GUSSET PLATE | PLT10*134.3 | +31.618 | +31.628 | 6 | 2.7 | 0 | 28.7 | 0.1 | 134.3 | 332.9 | pd-101 | 0.0773517 | 0.0447162 | 0.000343758 | 0.000343758
GUSSET PLATE | PLT10*134.3 | +31.618 | +31.628 | 6 | 2.6 | 0 | 28.6 | 0.1 | 134.3 | 319 | pd-100 | 0.07563 | 0.0428471 | 0.000336338 | 0.000336338
GUSSET PLATE | PLT10*138.5 | +28.970 | +28.980 | 6 | 2.7 | 0 | 28.5 | 0.1 | 138.6 | 300.8 | pd-99 | 0.0767626 | 0.0416619 | 0.000343069 | 0.000343069
GUSSET PLATE | PLT10*138.8 | +28.970 | +28.980 | 6 | 2.6 | 0 | 28.7 | 0.1 | 138.8 | 310.9 | pd-98 | 0.0739045 | 0.0431411 | 0.000328507 | 0.000328507
GUSSET PLATE | PLT10*143.1 | +26.305 | +26.315 | 6 | 2.5 | 0 | 28.7 | 0.1 | 143.1 | 292.1 | pd-97 | 0.0710286 | 0.041808 | 0.000315779 | 0.000315779
GUSSET PLATE | PLT10*143.1 | +26.305 | +26.315 | 6 | 2.5 | 0 | 28.6 | 0.1 | 143.1 | 281.1 | pd-96 | 0.0696558 | 0.0402265 | 0.000309827 | 0.000309827
3 x GUSSET PLATE | PLT10*160.5 | +70.543 | +70.553 | 8 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pf-90 | 0.0703425 | 0.0421247 | 0.000314238 | 0.000314238
GUSSET PLATE | PLT10*160.6 | +70.543 | +70.553 | 8 | 2.5 | 0 | 28.5 | 0.1 | 160.6 | 262.3 | pf-90 | 0.0703206 | 0.042113 | 0.00031414 | 0.00031414
2 x GUSSET PLATE | PLT10*142.5 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pf-98 | 0.0567125 | 0.0313561 | 0.000251411 | 0.000251411
GUSSET PLATE | PLT10*142.6 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pf-98 | 0.0567324 | 0.0313757 | 0.000251506 | 0.000251506
2 x GUSSET PLATE | PLT10*183.1 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 183.2 | 183.5 | pf-101 | 0.0569317 | 0.0335939 | 0.000253028 | 0.000253028
GUSSET PLATE | PLT10*183.1 | +70.543 | +70.553 | 8 | 5.1 | 0.1 | 27.5 | 0.1 | 183.2 | 370.9 | pf-63 | 0.13972 | 0.0679063 | 0.000646542 | 0.000646542
2 x GUSSET PLATE | PLT10*170.5 | +70.543 | +70.553 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.5 | 228.6 | pf-96 | 0.064809 | 0.0389786 | 0.000289241 | 0.000289241
3 x GUSSET PLATE | PLT10*137.2 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 137.2 | 224.9 | pf-86 | 0.0568532 | 0.0308457 | 0.000251913 | 0.000251913
GUSSET PLATE | PLT10*142.5 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pf-99 | 0.0570691 | 0.0313561 | 0.000253165 | 0.000253165
GUSSET PLATE | PLT10*137.2 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 137.2 | 224.9 | pf-86 | 0.0568668 | 0.0308457 | 0.00025198 | 0.00025198
2 x GUSSET PLATE | PLT10*161.7 | +70.543 | +70.553 | 8 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258.3 | pf-100 | 0.0696695 | 0.0417649 | 0.000311211 | 0.000311211
2 x GUSSET PLATE | PLT10*161.7 | +70.543 | +70.553 | 8 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258.3 | pf-100 | 0.0696695 | 0.0417648 | 0.000311211 | 0.000311211
GUSSET PLATE | PLT10*154.1 | +70.543 | +70.553 | 8 | 2.6 | 0 | 28.5 | 0.1 | 154.1 | 286.6 | pf-112 | 0.0742776 | 0.0441647 | 0.000331879 | 0.000331879
GUSSET PLATE | PLT10*134.1 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 134.1 | 232.6 | pf-113 | 0.0582392 | 0.0311895 | 0.000258209 | 0.000258209
GUSSET PLATE | PLT10*134.5 | +70.543 | +70.553 | 8 | 2.5 | 0 | 28.5 | 0.1 | 134.5 | 270.7 | pf-114 | 0.0693675 | 0.03641 | 0.000310024 | 0.000310024
2 x GUSSET PLATE | PLT10*154.5 | +70.543 | +70.553 | 8 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 267.3 | pf-115 | 0.0696028 | 0.0412969 | 0.000310369 | 0.000310369
2 x GUSSET PLATE | PLT10*163.5 | +70.543 | +70.553 | 8 | 2.2 | 0 | 28.6 | 0.1 | 163.5 | 234.3 | pf-116 | 0.0640416 | 0.0383117 | 0.000285283 | 0.000285283
GUSSET PLATE | PLT10*163.6 | +70.543 | +70.553 | 8 | 2.2 | 0 | 28.6 | 0.1 | 163.6 | 234.1 | pf-116 | 0.0640219 | 0.0383005 | 0.000285194 | 0.000285194
2 x GUSSET PLATE | PLT10*163.5 | +70.543 | +70.553 | 8 | 2.2 | 0 | 28.6 | 0.1 | 163.5 | 235.1 | pf-116 | 0.0642625 | 0.0384507 | 0.000286306 | 0.000286306
2 x GUSSET PLATE | PLT10*154.5 | +70.543 | +70.553 | 8 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 268.1 | pf-115 | 0.0698163 | 0.0414282 | 0.000311354 | 0.000311354
GUSSET PLATE | PLT10*163.6 | +70.543 | +70.553 | 8 | 2.2 | 0 | 28.6 | 0.1 | 163.6 | 235 | pf-116 | 0.0642428 | 0.0384395 | 0.000286217 | 0.000286217
GUSSET PLATE | PLT10*154.5 | +70.543 | +70.553 | 8 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 267.3 | pf-115 | 0.0696159 | 0.0412969 | 0.000310433 | 0.000310433
GUSSET PLATE | PLT10*170.6 | +70.543 | +70.553 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pf-96 | 0.0647785 | 0.0389599 | 0.000289103 | 0.000289103
GUSSET PLATE | PLT10*170.6 | +70.543 | +70.553 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pf-93 | 0.0658454 | 0.0396423 | 0.000294059 | 0.000294059
GUSSET PLATE | PLT10*141.2 | +70.543 | +70.553 | 8 | 2.2 | 0 | 28.6 | 0.1 | 141.2 | 245.2 | pf-85 | 0.0637481 | 0.0346233 | 0.000284111 | 0.000284111
GUSSET PLATE | PLT10*136.9 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pf-86 | 0.0568741 | 0.0308272 | 0.000252002 | 0.000252002
GUSSET PLATE | PLT10*140.9 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pf-87 | 0.0576086 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*158.2 | +70.543 | +70.553 | 8 | 2.6 | 0 | 28.5 | 0.1 | 158.2 | 274.9 | pf-88 | 0.0727471 | 0.0434829 | 0.000325168 | 0.000325168
GUSSET PLATE | PLT10*142.4 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 222.4 | pf-89 | 0.0571438 | 0.0316716 | 0.000253306 | 0.000253306
GUSSET PLATE | PLT10*141.1 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 141.1 | 217.2 | pf-91 | 0.0555457 | 0.0306329 | 0.000245958 | 0.000245958
GUSSET PLATE | PLT10*141.2 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 141.2 | 224.4 | pf-92 | 0.0574568 | 0.0316857 | 0.000254735 | 0.000254735
GUSSET PLATE | PLT10*140.9 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pf-87 | 0.0576085 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*136.9 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pf-86 | 0.056874 | 0.0308272 | 0.000252001 | 0.000252001
2 x GUSSET PLATE | PLT10*140.8 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.5 | pf-87 | 0.0576789 | 0.0317475 | 0.00025575 | 0.00025575
GUSSET PLATE | PLT10*170.6 | +70.543 | +70.553 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pf-93 | 0.0658269 | 0.0396316 | 0.000293974 | 0.000293974
GUSSET PLATE | PLT10*170.6 | +70.543 | +70.553 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pf-93 | 0.0658459 | 0.0396423 | 0.000294061 | 0.000294061
GUSSET PLATE | PLT10*144.4 | +70.543 | +70.553 | 8 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.6 | pf-94 | 0.0560827 | 0.0312867 | 0.000248473 | 0.000248473
GUSSET PLATE | PLT10*163 | +70.543 | +70.553 | 8 | 2.1 | 0 | 28.6 | 0.1 | 163 | 209.2 | pf-95 | 0.0590361 | 0.0341005 | 0.000262746 | 0.000262746
GUSSET PLATE | PLT10*170.6 | +70.543 | +70.553 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pf-96 | 0.064779 | 0.0389599 | 0.000289105 | 0.000289105
GUSSET PLATE | PLT10*170.6 | +70.543 | +70.553 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pf-96 | 0.0647598 | 0.038949 | 0.000289018 | 0.000289018
GUSSET PLATE | PLT10*169.5 | +70.543 | +70.553 | 8 | 2.3 | 0 | 28.5 | 0.1 | 169.5 | 232.1 | pf-97 | 0.0654016 | 0.0393392 | 0.000291932 | 0.000291932
GUSSET PLATE | PLT10*160.4 | +70.543 | +70.553 | 8 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.9 | pf-90 | 0.0704233 | 0.0421679 | 0.000314601 | 0.000314601
GUSSET PLATE | PLT10*160.5 | +70.543 | +70.553 | 8 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pf-90 | 0.0703419 | 0.0421247 | 0.000314235 | 0.000314235
GUSSET PLATE | PLT10*131.6 | +48.593 | +48.603 | 7 | 2.1 | 0 | 28.7 | 0.1 | 131.6 | 239.2 | pe-98 | 0.059404 | 0.0314786 | 0.000263477 | 0.000263477
2 x GUSSET PLATE | PLT10*161.8 | +66.143 | +66.153 | 8 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 257.8 | pf-100 | 0.0695893 | 0.0417216 | 0.00031085 | 0.00031085
GUSSET PLATE | PLT10*153.8 | +66.143 | +66.153 | 8 | 2.3 | 0 | 28.5 | 0.1 | 153.7 | 239.9 | pf-102 | 0.0657009 | 0.0369004 | 0.000293609 | 0.000293609
GUSSET PLATE | PLT10*160.6 | +66.143 | +66.153 | 8 | 2.3 | 0 | 28.6 | 0.1 | 160.6 | 245.2 | pf-103 | 0.0659587 | 0.0393924 | 0.000293975 | 0.000293975
2 x GUSSET PLATE | PLT10*145.6 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 145.6 | 219.9 | pf-104 | 0.0574055 | 0.0320413 | 0.000254697 | 0.000254697
GUSSET PLATE | PLT10*143.2 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 143.2 | 219.9 | pf-98 | 0.0568562 | 0.0314975 | 0.000252093 | 0.000252093
GUSSET PLATE | PLT10*160.8 | +66.143 | +66.153 | 8 | 2.3 | 0 | 28.6 | 0.1 | 160.8 | 244.7 | pf-103 | 0.0658618 | 0.0393394 | 0.000293537 | 0.000293537
GUSSET PLATE | PLT10*147.3 | +66.143 | +66.153 | 8 | 1.7 | 0 | 29.2 | 0 | 147.3 | 210.6 | pf-62 | 0.0483219 | 0.0310463 | 0.000211139 | 0.000211139
GUSSET PLATE | PLT10*157.2 | +66.143 | +66.153 | 8 | 2.5 | 0 | 28.5 | 0.1 | 157.3 | 274.6 | pf-105 | 0.0723415 | 0.0431661 | 0.000323215 | 0.000323215
GUSSET PLATE | PLT10*165.1 | +66.143 | +66.153 | 8 | 2.5 | 0 | 28.5 | 0.1 | 165.1 | 246.5 | pf-106 | 0.0677519 | 0.0407086 | 0.000302569 | 0.000302569
GUSSET PLATE | PLT10*159.5 | +66.143 | +66.153 | 8 | 2.5 | 0 | 28.5 | 0.1 | 159.5 | 266 | pf-107 | 0.0709118 | 0.0424252 | 0.000316797 | 0.000316797
GUSSET PLATE | PLT10*140.3 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 140.4 | 219.9 | pf-108 | 0.0562016 | 0.0308555 | 0.000248987 | 0.000248987
GUSSET PLATE | PLT10*167.4 | +66.143 | +66.153 | 8 | 2.3 | 0 | 28.5 | 0.1 | 167.3 | 239 | pf-109 | 0.0665329 | 0.0400095 | 0.000297059 | 0.000297059
GUSSET PLATE | PLT10*153.8 | +66.143 | +66.153 | 8 | 2.1 | 0 | 28.6 | 0.1 | 153.7 | 219.7 | pf-110 | 0.0592862 | 0.0338209 | 0.000263619 | 0.000263619
GUSSET PLATE | PLT10*159.8 | +66.143 | +66.153 | 8 | 2.1 | 0 | 28.6 | 0.1 | 159.9 | 219.7 | pf-111 | 0.0608315 | 0.0350818 | 0.000270976 | 0.000270976
3 x GUSSET PLATE | PLT10*160.5 | +66.143 | +66.153 | 8 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pf-90 | 0.0703425 | 0.0421247 | 0.000314238 | 0.000314238
GUSSET PLATE | PLT10*160.6 | +66.143 | +66.153 | 8 | 2.5 | 0 | 28.5 | 0.1 | 160.6 | 262.3 | pf-90 | 0.0703206 | 0.042113 | 0.00031414 | 0.00031414
2 x GUSSET PLATE | PLT10*142.5 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pf-98 | 0.0567125 | 0.0313561 | 0.000251411 | 0.000251411
GUSSET PLATE | PLT10*142.6 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pf-98 | 0.0567324 | 0.0313757 | 0.000251506 | 0.000251506
2 x GUSSET PLATE | PLT10*183.1 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 183.2 | 183.5 | pf-101 | 0.0569317 | 0.0335939 | 0.000253028 | 0.000253028
GUSSET PLATE | PLT10*183.1 | +66.143 | +66.153 | 8 | 5.1 | 0.1 | 27.5 | 0.1 | 183.2 | 370.9 | pf-63 | 0.13972 | 0.0679063 | 0.000646542 | 0.000646542
2 x GUSSET PLATE | PLT10*170.5 | +66.143 | +66.153 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.5 | 228.6 | pf-96 | 0.064809 | 0.0389786 | 0.000289241 | 0.000289241
3 x GUSSET PLATE | PLT10*137.2 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 137.2 | 224.9 | pf-86 | 0.0568532 | 0.0308457 | 0.000251913 | 0.000251913
GUSSET PLATE | PLT10*142.5 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pf-99 | 0.0570691 | 0.0313561 | 0.000253165 | 0.000253165
GUSSET PLATE | PLT10*137.2 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 137.2 | 224.9 | pf-86 | 0.0568668 | 0.0308457 | 0.00025198 | 0.00025198
2 x GUSSET PLATE | PLT10*161.7 | +66.143 | +66.153 | 8 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258.3 | pf-100 | 0.0696695 | 0.0417649 | 0.000311211 | 0.000311211
2 x GUSSET PLATE | PLT10*161.7 | +66.143 | +66.153 | 8 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258.3 | pf-100 | 0.0696695 | 0.0417648 | 0.000311211 | 0.000311211
2 x GUSSET PLATE | PLT10*170.6 | +66.143 | +66.153 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pf-96 | 0.0647785 | 0.0389599 | 0.000289103 | 0.000289103
2 x GUSSET PLATE | PLT10*170.6 | +66.143 | +66.153 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pf-93 | 0.0658454 | 0.0396423 | 0.000294059 | 0.000294059
GUSSET PLATE | PLT10*141.2 | +66.143 | +66.153 | 8 | 2.2 | 0 | 28.6 | 0.1 | 141.2 | 245.2 | pf-85 | 0.0637481 | 0.0346233 | 0.000284111 | 0.000284111
GUSSET PLATE | PLT10*136.9 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pf-86 | 0.0568741 | 0.0308272 | 0.000252002 | 0.000252002
GUSSET PLATE | PLT10*140.9 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pf-87 | 0.0576086 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*158.2 | +66.143 | +66.153 | 8 | 2.6 | 0 | 28.5 | 0.1 | 158.2 | 274.9 | pf-88 | 0.0727471 | 0.0434829 | 0.000325168 | 0.000325168
GUSSET PLATE | PLT10*142.4 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 222.4 | pf-89 | 0.0571438 | 0.0316716 | 0.000253306 | 0.000253306
GUSSET PLATE | PLT10*141.1 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 141.1 | 217.2 | pf-91 | 0.0555457 | 0.0306329 | 0.000245958 | 0.000245958
GUSSET PLATE | PLT10*141.2 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 141.2 | 224.4 | pf-92 | 0.0574568 | 0.0316857 | 0.000254735 | 0.000254735
GUSSET PLATE | PLT10*140.9 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pf-87 | 0.0576085 | 0.0317278 | 0.000255428 | 0.000255428
GUSSET PLATE | PLT10*136.9 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pf-86 | 0.056874 | 0.0308272 | 0.000252001 | 0.000252001
2 x GUSSET PLATE | PLT10*140.8 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.5 | pf-87 | 0.0576789 | 0.0317475 | 0.00025575 | 0.00025575
GUSSET PLATE | PLT10*170.6 | +66.143 | +66.153 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pf-93 | 0.0658269 | 0.0396316 | 0.000293974 | 0.000293974
GUSSET PLATE | PLT10*170.6 | +66.143 | +66.153 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pf-93 | 0.0658459 | 0.0396423 | 0.000294061 | 0.000294061
GUSSET PLATE | PLT10*144.4 | +66.143 | +66.153 | 8 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.6 | pf-94 | 0.0560827 | 0.0312867 | 0.000248473 | 0.000248473
GUSSET PLATE | PLT10*163 | +66.143 | +66.153 | 8 | 2.1 | 0 | 28.6 | 0.1 | 163 | 209.2 | pf-95 | 0.0590361 | 0.0341005 | 0.000262746 | 0.000262746
GUSSET PLATE | PLT10*170.6 | +66.143 | +66.153 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pf-96 | 0.064779 | 0.0389599 | 0.000289105 | 0.000289105
GUSSET PLATE | PLT10*170.6 | +66.143 | +66.153 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pf-96 | 0.0647598 | 0.038949 | 0.000289018 | 0.000289018
GUSSET PLATE | PLT10*169.5 | +66.143 | +66.153 | 8 | 2.3 | 0 | 28.5 | 0.1 | 169.5 | 232.1 | pf-97 | 0.0654016 | 0.0393392 | 0.000291932 | 0.000291932
GUSSET PLATE | PLT10*160.4 | +66.143 | +66.153 | 8 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.9 | pf-90 | 0.0704233 | 0.0421679 | 0.000314601 | 0.000314601
GUSSET PLATE | PLT10*160.5 | +66.143 | +66.153 | 8 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pf-90 | 0.0703419 | 0.0421247 | 0.000314235 | 0.000314235
GUSSET PLATE | PLT10*154.1 | +63.340 | +63.350 | 8 | 2.8 | 0 | 28.5 | 0.1 | 154.1 | 282.7 | pf-117 | 0.0784659 | 0.0435484 | 0.000352464 | 0.000352464
GUSSET PLATE | PLT10*134.1 | +63.340 | +63.350 | 8 | 1.9 | 0 | 28.7 | 0.1 | 134.1 | 232.6 | pf-113 | 0.0582392 | 0.0311895 | 0.000258209 | 0.000258209
GUSSET PLATE | PLT10*142.5 | +55.198 | +55.208 | 8 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pf-98 | 0.0567125 | 0.0313561 | 0.000251411 | 0.000251411
2 x GUSSET PLATE | PLT10*160.5 | +55.198 | +55.208 | 8 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pf-90 | 0.0703425 | 0.0421247 | 0.000314238 | 0.000314238
GUSSET PLATE | PLT10*165.1 | +55.198 | +55.208 | 8 | 2.5 | 0 | 28.5 | 0.1 | 165.1 | 246.8 | pf-106 | 0.0677976 | 0.0407343 | 0.000302775 | 0.000302775
GUSSET PLATE | PLT10*153.7 | +55.198 | +55.208 | 8 | 2.1 | 0 | 28.7 | 0.1 | 153.7 | 219.7 | pf-110 | 0.0592396 | 0.0337879 | 0.000263396 | 0.000263396
GUSSET PLATE | PLT10*153.8 | +55.198 | +55.208 | 8 | 2.1 | 0 | 28.6 | 0.1 | 153.7 | 219.7 | pf-110 | 0.0592649 | 0.0338085 | 0.000263516 | 0.000263516
GUSSET PLATE | PLT10*165.1 | +55.198 | +55.208 | 8 | 2.5 | 0 | 28.5 | 0.1 | 165.1 | 246.8 | pf-106 | 0.0677771 | 0.0407227 | 0.000302683 | 0.000302683
2 x GUSSET PLATE | PLT10*155 | +55.198 | +55.208 | 8 | 2.1 | 0 | 28.6 | 0.1 | 155 | 219.7 | pf-191 | 0.0595967 | 0.0340794 | 0.000265097 | 0.000265097
GUSSET PLATE | PLT10*155.1 | +55.198 | +55.208 | 8 | 2.1 | 0 | 28.6 | 0.1 | 155.2 | 219.7 | pf-191 | 0.0596226 | 0.0341006 | 0.00026522 | 0.00026522
GUSSET PLATE | PLT10*155.1 | +55.198 | +55.208 | 8 | 2.1 | 0 | 28.6 | 0.1 | 155.2 | 219.7 | pf-191 | 0.0596227 | 0.0341006 | 0.00026522 | 0.00026522
GUSSET PLATE | PLT10*140.8 | +55.198 | +55.208 | 8 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 224.7 | pf-92 | 0.0574974 | 0.0316616 | 0.00025491 | 0.00025491
GUSSET PLATE | PLT10*143.7 | +55.198 | +55.208 | 8 | 1.9 | 0 | 28.7 | 0.1 | 143.7 | 224.9 | pf-190 | 0.058161 | 0.0323166 | 0.000258061 | 0.000258061
GUSSET PLATE | PLT10*179.1 | +70.543 | +70.553 | 8 | 2.2 | 0 | 28.5 | 0.1 | 179.1 | 199.3 | pf-188 | 0.0620913 | 0.0356936 | 0.000277415 | 0.000277415
GUSSET PLATE | PLT10*179.1 | +70.543 | +70.553 | 8 | 2.1 | 0 | 28.6 | 0.1 | 179.1 | 199.3 | pf-189 | 0.0598246 | 0.0356936 | 0.000266425 | 0.000266425
2 x GUSSET PLATE | PLT10*174.4 | +70.543 | +70.553 | 8 | 2.2 | 0 | 28.6 | 0.1 | 174.3 | 215.7 | pf-187 | 0.0626665 | 0.0376226 | 0.000279475 | 0.000279475
2 x GUSSET PLATE | PLT10*170.5 | +55.198 | +55.208 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.5 | 228.6 | pf-96 | 0.064809 | 0.0389786 | 0.000289241 | 0.000289241
3 x GUSSET PLATE | PLT10*137.2 | +55.198 | +55.208 | 8 | 1.9 | 0 | 28.7 | 0.1 | 137.2 | 224.9 | pf-86 | 0.0568532 | 0.0308457 | 0.000251913 | 0.000251913
GUSSET PLATE | PLT10*142.5 | +55.198 | +55.208 | 8 | 1.9 | 0 | 28.7 | 0.1 | 142.5 | 219.9 | pf-99 | 0.0570691 | 0.0313561 | 0.000253165 | 0.000253165
GUSSET PLATE | PLT10*137.2 | +55.198 | +55.208 | 8 | 1.9 | 0 | 28.7 | 0.1 | 137.2 | 224.9 | pf-86 | 0.0568668 | 0.0308457 | 0.00025198 | 0.00025198
2 x GUSSET PLATE | PLT10*161.7 | +55.198 | +55.208 | 8 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258.3 | pf-100 | 0.0696695 | 0.0417649 | 0.000311211 | 0.000311211
GUSSET PLATE | PLT10*134.5 | +55.198 | +55.208 | 8 | 2.5 | 0 | 28.5 | 0.1 | 134.5 | 270.7 | pf-114 | 0.0693675 | 0.03641 | 0.000310024 | 0.000310024
2 x GUSSET PLATE | PLT10*154.5 | +55.198 | +55.208 | 8 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 267.3 | pf-115 | 0.0696028 | 0.0412969 | 0.000310369 | 0.000310369
2 x GUSSET PLATE | PLT10*163.5 | +55.198 | +55.208 | 8 | 2.2 | 0 | 28.6 | 0.1 | 163.5 | 234.3 | pf-116 | 0.0640416 | 0.0383117 | 0.000285283 | 0.000285283
GUSSET PLATE | PLT10*163.6 | +55.198 | +55.208 | 8 | 2.2 | 0 | 28.6 | 0.1 | 163.6 | 234.1 | pf-116 | 0.0640219 | 0.0383005 | 0.000285194 | 0.000285194
2 x GUSSET PLATE | PLT10*163.5 | +55.198 | +55.208 | 8 | 2.2 | 0 | 28.6 | 0.1 | 163.5 | 235.1 | pf-116 | 0.0642625 | 0.0384507 | 0.000286306 | 0.000286306
2 x GUSSET PLATE | PLT10*154.5 | +55.198 | +55.208 | 8 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 268.1 | pf-115 | 0.0698163 | 0.0414282 | 0.000311354 | 0.000311354
GUSSET PLATE | PLT10*163.6 | +55.198 | +55.208 | 8 | 2.2 | 0 | 28.6 | 0.1 | 163.6 | 235 | pf-116 | 0.0642428 | 0.0384395 | 0.000286217 | 0.000286217
GUSSET PLATE | PLT10*154.5 | +55.198 | +55.208 | 8 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 267.3 | pf-115 | 0.0696159 | 0.0412969 | 0.000310433 | 0.000310433
2 x GUSSET PLATE | PLT10*170.6 | +55.198 | +55.208 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pf-96 | 0.0647785 | 0.0389599 | 0.000289103 | 0.000289103
2 x GUSSET PLATE | PLT10*170.6 | +55.198 | +55.208 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pf-93 | 0.0658454 | 0.0396423 | 0.000294059 | 0.000294059
GUSSET PLATE | PLT10*147.9 | +55.198 | +55.208 | 8 | 1.9 | 0 | 28.7 | 0.1 | 147.8 | 214.9 | pf-186 | 0.056983 | 0.0317733 | 0.00025281 | 0.00025281
GUSSET PLATE | PLT10*141.2 | +55.198 | +55.208 | 8 | 2.2 | 0 | 28.6 | 0.1 | 141.2 | 245.2 | pf-85 | 0.0637481 | 0.0346233 | 0.000284111 | 0.000284111
GUSSET PLATE | PLT10*136.9 | +55.198 | +55.208 | 8 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pf-86 | 0.0568741 | 0.0308272 | 0.000252002 | 0.000252002
GUSSET PLATE | PLT10*158.2 | +55.198 | +55.208 | 8 | 2.6 | 0 | 28.5 | 0.1 | 158.2 | 274.9 | pf-88 | 0.0727471 | 0.0434829 | 0.000325168 | 0.000325168
GUSSET PLATE | PLT10*141.1 | +55.198 | +55.208 | 8 | 1.9 | 0 | 28.7 | 0.1 | 141.1 | 217.2 | pf-91 | 0.0555457 | 0.0306329 | 0.000245958 | 0.000245958
GUSSET PLATE | PLT10*157.7 | +55.198 | +55.208 | 8 | 2.6 | 0 | 28.5 | 0.1 | 157.7 | 276.6 | pf-177 | 0.0730228 | 0.0436243 | 0.000326405 | 0.000326405
GUSSET PLATE | PLT10*141.2 | +55.198 | +55.208 | 8 | 1.9 | 0 | 28.7 | 0.1 | 141.2 | 224.4 | pf-92 | 0.0574568 | 0.0316857 | 0.000254735 | 0.000254735
GUSSET PLATE | PLT10*144.4 | +55.198 | +55.208 | 8 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.4 | pf-94 | 0.0560392 | 0.0312583 | 0.00024827 | 0.00024827
GUSSET PLATE | PLT10*170.6 | +55.198 | +55.208 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pf-93 | 0.0658269 | 0.0396316 | 0.000293974 | 0.000293974
GUSSET PLATE | PLT10*170.6 | +55.198 | +55.208 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pf-93 | 0.0658459 | 0.0396423 | 0.000294061 | 0.000294061
GUSSET PLATE | PLT10*144.4 | +55.198 | +55.208 | 8 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.6 | pf-94 | 0.0560827 | 0.0312867 | 0.000248473 | 0.000248473
GUSSET PLATE | PLT10*163 | +55.198 | +55.208 | 8 | 2.1 | 0 | 28.6 | 0.1 | 163 | 209.2 | pf-95 | 0.0590361 | 0.0341005 | 0.000262746 | 0.000262746
2 x GUSSET PLATE | PLT10*160.4 | +55.198 | +55.208 | 8 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.9 | pf-90 | 0.0704233 | 0.0421679 | 0.000314601 | 0.000314601
GUSSET PLATE | PLT10*170.6 | +55.198 | +55.208 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pf-96 | 0.064779 | 0.0389599 | 0.000289105 | 0.000289105
GUSSET PLATE | PLT10*170.6 | +55.198 | +55.208 | 8 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pf-96 | 0.0647598 | 0.038949 | 0.000289018 | 0.000289018
GUSSET PLATE | PLT10*169.5 | +55.198 | +55.208 | 8 | 2.3 | 0 | 28.5 | 0.1 | 169.5 | 232.1 | pf-97 | 0.0654016 | 0.0393392 | 0.000291932 | 0.000291932
GUSSET PLATE | PLT10*160.5 | +55.198 | +55.208 | 8 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pf-90 | 0.0703419 | 0.0421247 | 0.000314235 | 0.000314235
GUSSET PLATE | PLT10*181.9 | +44.468 | +44.478 | 7 | 1.9 | 0 | 28.6 | 0.1 | 181.9 | 185.5 | pe-108 | 0.0574192 | 0.0337444 | 0.000255345 | 0.000255345
GUSSET PLATE | PLT10*181.9 | +44.468 | +44.478 | 7 | 2.2 | 0 | 28.5 | 0.1 | 181.9 | 200.1 | pe-107 | 0.0633156 | 0.0363968 | 0.000283241 | 0.000283241
GUSSET PLATE | PLT10*169 | +44.468 | +44.478 | 7 | 2.3 | 0 | 28.5 | 0.1 | 168.9 | 233.5 | pe-106 | 0.0656237 | 0.0394722 | 0.00029294 | 0.00029294
GUSSET PLATE | PLT10*169 | +44.468 | +44.478 | 7 | 2.3 | 0 | 28.5 | 0.1 | 168.9 | 240.7 | pe-105 | 0.0665783 | 0.0406873 | 0.000297163 | 0.000297163
GUSSET PLATE | PLT10*170.9 | +44.468 | +44.478 | 7 | 2.3 | 0 | 28.5 | 0.1 | 171 | 227.4 | pe-104 | 0.0646208 | 0.038863 | 0.000288386 | 0.000288386
GUSSET PLATE | PLT10*170.9 | +44.468 | +44.478 | 7 | 2.3 | 0 | 28.5 | 0.1 | 171 | 234.3 | pe-103 | 0.0655331 | 0.0400316 | 0.000292429 | 0.000292429
GUSSET PLATE | PLT10*169 | +70.543 | +70.553 | 8 | 2.3 | 0 | 28.5 | 0.1 | 168.9 | 233.5 | pf-178 | 0.0656237 | 0.0394722 | 0.00029294 | 0.00029294
GUSSET PLATE | PLT10*169 | +70.543 | +70.553 | 8 | 2.3 | 0 | 28.5 | 0.1 | 168.9 | 240.7 | pf-179 | 0.0665783 | 0.0406873 | 0.000297163 | 0.000297163
GUSSET PLATE | PLT10*181.9 | +55.198 | +55.208 | 8 | 1.9 | 0 | 28.6 | 0.1 | 181.9 | 185.5 | pf-180 | 0.0574192 | 0.0337444 | 0.000255345 | 0.000255345
GUSSET PLATE | PLT10*181.9 | +55.198 | +55.208 | 8 | 2.2 | 0 | 28.5 | 0.1 | 181.9 | 200.1 | pf-181 | 0.0633156 | 0.0363968 | 0.000283241 | 0.000283241
GUSSET PLATE | PLT10*169 | +55.198 | +55.208 | 8 | 2.3 | 0 | 28.5 | 0.1 | 168.9 | 233.5 | pf-178 | 0.0656237 | 0.0394722 | 0.00029294 | 0.00029294
GUSSET PLATE | PLT10*169 | +55.198 | +55.208 | 8 | 2.3 | 0 | 28.5 | 0.1 | 168.9 | 240.7 | pf-179 | 0.0665783 | 0.0406873 | 0.000297163 | 0.000297163
GUSSET PLATE | PLT10*170.9 | +55.198 | +55.208 | 8 | 2.3 | 0 | 28.5 | 0.1 | 171 | 227.4 | pf-182 | 0.0646208 | 0.038863 | 0.000288386 | 0.000288386
GUSSET PLATE | PLT10*170.9 | +55.198 | +55.208 | 8 | 2.3 | 0 | 28.5 | 0.1 | 171 | 234.3 | pf-183 | 0.0655331 | 0.0400316 | 0.000292429 | 0.000292429
GUSSET PLATE | PLT10*175.9 | +63.343 | +63.353 | 8 | 2.2 | 0 | 28.6 | 0.1 | 175.9 | 210.5 | pf-184 | 0.0617684 | 0.0370287 | 0.000275363 | 0.000275363
GUSSET PLATE | PLT10*175.9 | +63.343 | +63.353 | 8 | 2.1 | 0 | 28.6 | 0.1 | 175.9 | 206.9 | pf-185 | 0.0612643 | 0.0364086 | 0.000273102 | 0.000273102
