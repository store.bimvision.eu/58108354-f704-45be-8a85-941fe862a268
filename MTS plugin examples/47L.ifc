Properties of the parts of a building model (IFC2X3), part 13 of 22

# IfcDiscreteAccessory: PLATE (5205)
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
PLATE | PLT16*350.9 | +31.728 | +32.079 | 6 | 99 | 15.1 | 0 | 17.5 | 0.3 | 350.9 | 16 | 459.9 | pd-135 | 0.26463 | 0.161387 | 0.000256 | 0.00193735 | 0.00193735
2 x PLATE | PLT10*94.5 | +29.203 | +29.397 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +29.105 | +29.490 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*339 | +29.080 | +29.419 | 6 | 99 | 20 | 0 | 17.3 | 0.3 | 339 | 16 | 608.8 | pd-137 | 0.344461 | 0.20641 | 0.000256 | 0.00253848 | 0.00253848
PLATE | PLT16*350.3 | +69.944 | +70.294 | 8 | 99 | 15.5 | 0 | 17.5 | 0.3 | 350.3 | 16 | 469.2 | pf-227 | 0.269697 | 0.164379 | 0.000256 | 0.00197558 | 0.00197558
2 x PLATE | PLT10*94.5 | +65.581 | +65.776 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +65.492 | +65.869 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*336.6 | +65.558 | +65.894 | 8 | 99 | 21 | 0 | 17.3 | 0.3 | 336.6 | 16 | 639.6 | pf-228 | 0.360784 | 0.215315 | 0.000256 | 0.00266122 | 0.00266122
PLATE | PLT16*350.3 | +66.250 | +66.600 | 8 | 99 | 15.5 | 0 | 17.5 | 0.3 | 350.3 | 16 | 469.2 | pf-227 | 0.269697 | 0.164379 | 0.000256 | 0.00197557 | 0.00197557
2 x PLATE | PLT10*94.5 | +63.568 | +63.764 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +63.475 | +63.852 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*336.6 | +63.450 | +63.787 | 8 | 99 | 21 | 0 | 17.3 | 0.3 | 336.6 | 16 | 639.6 | pf-228 | 0.360778 | 0.215312 | 0.000256 | 0.00266118 | 0.00266118
2 x PLATE | PLT10*94.5 | +57.352 | +57.548 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +57.266 | +57.639 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*335.5 | +57.329 | +57.664 | 8 | 99 | 21.4 | 0 | 17.3 | 0.3 | 335.5 | 16 | 656.2 | pf-230 | 0.369641 | 0.220171 | 0.000256 | 0.00272784 | 0.00272784
2 x PLATE | PLT10*94.5 | +55.421 | +55.617 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +55.330 | +55.703 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*335.5 | +55.305 | +55.641 | 8 | 99 | 21.4 | 0 | 17.3 | 0.3 | 335.5 | 16 | 654.8 | pf-231 | 0.368814 | 0.219682 | 0.000256 | 0.00272159 | 0.00272159
PLATE | FL16*250 | +54.571 | +54.924 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*328.7 | +54.621 | +54.949 | 8 | 99 | 24.6 | 0 | 17.2 | 0.3 | 328.8 | 16 | 758 | pf-232 | 0.423279 | 0.249175 | 0.000256 | 0.00313089 | 0.00313089
2 x PLATE | PLT10*94.5 | +53.144 | +53.343 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT16*328.7 | +53.040 | +53.369 | 8 | 99 | 24.6 | 0 | 17.2 | 0.3 | 328.8 | 16 | 758 | pf-232 | 0.423285 | 0.249179 | 0.000256 | 0.00313094 | 0.00313094
2 x PLATE | PLT10*94.5 | +38.369 | +38.565 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +38.282 | +38.657 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*336.2 | +38.346 | +38.682 | 7 | 99 | 21.1 | 0 | 17.3 | 0.3 | 336.2 | 16 | 645 | pe-144 | 0.363661 | 0.21688 | 0.000256 | 0.00268285 | 0.00268285
2 x PLATE | PLT10*94.5 | +36.388 | +36.583 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +36.295 | +36.671 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*336.2 | +36.270 | +36.606 | 6 | 99 | 21.1 | 0 | 17.3 | 0.3 | 336.2 | 16 | 645 | pd-136 | 0.363661 | 0.21688 | 0.000256 | 0.00268285 | 0.00268285
2 x PLATE | PLT10*94.5 | +31.062 | +31.258 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +30.977 | +31.347 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*334.6 | +31.038 | +31.372 | 6 | 99 | 21.8 | 0 | 17.3 | 0.3 | 334.6 | 16 | 667.3 | pd-134 | 0.375439 | 0.223279 | 0.000256 | 0.00277139 | 0.00277139
6 x PLATE | PLT20*140 | +31.373 | +31.393 | 6 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pd-14 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
6 x PLATE | PLT20*140 | +31.708 | +31.728 | 6 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pd-14 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
6 x PLATE | PLT20*140 | +38.683 | +38.703 | 7 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pe-16 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
6 x PLATE | PLT20*140 | +39.018 | +39.038 | 7 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pe-16 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
6 x PLATE | PLT20*140 | +52.685 | +52.705 | 8 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pf-8 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
6 x PLATE | PLT20*140 | +53.020 | +53.040 | 8 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pf-8 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
6 x PLATE | PLT20*140 | +57.665 | +57.685 | 8 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pf-8 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
6 x PLATE | PLT20*140 | +58.000 | +58.020 | 8 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pf-8 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
6 x PLATE | PLT20*140 | +65.895 | +65.915 | 8 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pf-8 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
6 x PLATE | PLT20*140 | +66.230 | +66.250 | 8 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pf-8 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT10*94.5 | +29.194 | +29.391 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +29.105 | +29.476 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*334.6 | +29.080 | +29.415 | 6 | 99 | 21.8 | 0 | 17.3 | 0.3 | 334.6 | 16 | 667.3 | pd-134 | 0.375441 | 0.22328 | 0.000256 | 0.0027714 | 0.0027714
2 x PLATE | PLT20*140 | +70.295 | +70.315 | 8 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pf-8 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +70.630 | +70.650 | 8 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pf-8 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +63.095 | +63.115 | 8 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pf-8 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +63.430 | +63.450 | 8 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pf-8 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +28.725 | +28.745 | 6 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pd-14 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +29.060 | +29.080 | 6 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pd-14 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +35.915 | +35.935 | 6 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pd-14 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +36.250 | +36.270 | 6 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pd-14 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +44.220 | +44.240 | 7 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pe-16 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +44.555 | +44.575 | 7 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pe-16 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +54.950 | +54.970 | 8 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pf-8 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +55.285 | +55.305 | 8 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pf-8 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +48.345 | +48.365 | 7 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pe-16 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +48.680 | +48.700 | 7 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pe-16 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | FL12*100 | +70.350 | +70.450 | 8 | 8 | 0.7 | 0 | 28.3 | 0 | 100 | 12 | 100 | pf-34 | 0.0169775 | 0.01 | 0.000144 | 0.00007665 | 0.00007665
PLATE | FL12*100 | +55.005 | +55.102 | 8 | 8 | 0.7 | 0 | 28.3 | 0 | 96.8 | 12 | 96.8 | pf-35 | 0.0165442 | 0.00937024 | 0.000144 | 0.000074442 | 0.000074442
2 x PLATE | PLT8*74.5 | +63.364 | +63.438 | 8 | 8 | 0.4 | 0 | 38.3 | 0 | 74.5 | 8 | 82.1 | pf-273 | 0.0144432 | 0.00611645 | 0.000064 | 0.0000480316 | 0.0000480316
4 x PLATE | FL12*80 | +48.356 | +48.688 | 7 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pe-45 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
2 x PLATE | PLT16*140 | +45.211 | +45.227 | 7 | 99 | 4.9 | 0 | 18.6 | 0.1 | 140 | 16 | 276 | pe-162 | 0.0888734 | 0.03864 | 0.000256 | 0.00060824 | 0.00060824
2 x PLATE | FL16*80 | +48.356 | +48.688 | 7 | 99 | 3.3 | 0 | 19.8 | 0.1 | 80 | 16 | 331.6 | pe-161 | 0.065496 | 0.026528 | 0.000256 | 0.000420848 | 0.000420848
2 x PLATE | PLT8*74.5 | +28.994 | +29.069 | 6 | 8 | 0.4 | 0 | 38.3 | 0 | 74.5 | 8 | 82.1 | pd-166 | 0.0144432 | 0.00611645 | 0.000064 | 0.0000480316 | 0.0000480316
2 x PLATE | PLT8*166.5 | +44.400 | +44.566 | 7 | 8 | 1.7 | 0 | 34.9 | 0.1 | 166.5 | 8 | 167.2 | pe-198 | 0.0607215 | 0.0278388 | 0.000064 | 0.00022181 | 0.00022181
3 x PLATE | PLT8*152.5 | +44.400 | +44.564 | 7 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pe-197 | 0.0546582 | 0.024948 | 0.000064 | 0.000198684 | 0.000198684
2 x PLATE | FL10*40 | +44.384 | +44.566 | 7 | 99 | 0.7 | 0 | 33.2 | 0 | 40 | 10 | 182 | pe-73 | 0.0183743 | 0.00728 | 0.0001 | 0.00007055 | 0.00007055
2 x PLATE | FL12*100 | +44.275 | +44.375 | 7 | 8 | 0.7 | 0 | 28.3 | 0 | 100 | 12 | 100 | pe-36 | 0.0169775 | 0.01 | 0.000144 | 0.00007665 | 0.00007665
3 x PLATE | FL10*80 | +44.489 | +44.569 | 7 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pe-65 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
PLATE | PLT8*74.5 | +44.489 | +44.563 | 7 | 8 | 0.4 | 0 | 38.3 | 0 | 74.5 | 8 | 82.1 | pe-193 | 0.0144432 | 0.00611645 | 0.000064 | 0.0000480316 | 0.0000480316
PLATE | PLT8*166.5 | +70.475 | +70.641 | 8 | 8 | 1.7 | 0 | 34.9 | 0.1 | 166.5 | 8 | 168.6 | pf-281 | 0.0612078 | 0.0280708 | 0.000064 | 0.000223667 | 0.000223667
2 x PLATE | PLT8*152.5 | +70.475 | +70.639 | 8 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pf-274 | 0.0546582 | 0.024948 | 0.000064 | 0.000198684 | 0.000198684
2 x PLATE | FL10*40 | +70.459 | +70.641 | 8 | 99 | 0.7 | 0 | 33.2 | 0 | 40 | 10 | 182 | pf-72 | 0.0183743 | 0.00728 | 0.0001 | 0.00007055 | 0.00007055
3 x PLATE | PLT8*152.5 | +55.130 | +55.294 | 8 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pf-274 | 0.0546582 | 0.024948 | 0.000064 | 0.000198684 | 0.000198684
2 x PLATE | FL10*40 | +55.114 | +55.296 | 8 | 99 | 0.7 | 0 | 33.2 | 0 | 40 | 10 | 182 | pf-72 | 0.0183743 | 0.00728 | 0.0001 | 0.00007055 | 0.00007055
PLATE | FL12*100 | +55.005 | +55.105 | 8 | 8 | 0.7 | 0 | 28.3 | 0 | 100 | 12 | 100 | pf-34 | 0.0169775 | 0.01 | 0.000144 | 0.00007665 | 0.00007665
3 x PLATE | FL10*80 | +55.219 | +55.299 | 8 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pf-61 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
PLATE | PLT8*74.5 | +55.219 | +55.294 | 8 | 8 | 0.4 | 0 | 38.3 | 0 | 74.5 | 8 | 82.1 | pf-273 | 0.0144432 | 0.00611645 | 0.000064 | 0.0000480316 | 0.0000480316
2 x PLATE | PLT8*152.5 | +63.275 | +63.439 | 8 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pf-274 | 0.0546582 | 0.024948 | 0.000064 | 0.000198684 | 0.000198684
3 x PLATE | FL10*80 | +63.364 | +63.444 | 8 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pf-61 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
2 x PLATE | FL10*40 | +63.259 | +63.441 | 8 | 99 | 0.7 | 0 | 33.2 | 0 | 40 | 10 | 182 | pf-72 | 0.0183743 | 0.00728 | 0.0001 | 0.00007055 | 0.00007055
PLATE | FL12*100 | +63.150 | +63.250 | 8 | 8 | 0.7 | 0 | 28.3 | 0 | 100 | 12 | 100 | pf-34 | 0.0169775 | 0.01 | 0.000144 | 0.00007665 | 0.00007665
2 x PLATE | PLT8*152.5 | +38.863 | +39.027 | 7 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pe-197 | 0.0546582 | 0.024948 | 0.000064 | 0.000198684 | 0.000198684
PLATE | PLT8*74.5 | +38.952 | +39.026 | 7 | 8 | 0.4 | 0 | 38.3 | 0 | 74.5 | 8 | 82.1 | pe-193 | 0.0144432 | 0.00611645 | 0.000064 | 0.0000480316 | 0.0000480316
3 x PLATE | FL10*80 | +38.952 | +39.032 | 7 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pe-65 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
2 x PLATE | FL10*40 | +38.847 | +39.029 | 7 | 99 | 0.7 | 0 | 33.2 | 0 | 40 | 10 | 182 | pe-73 | 0.0183743 | 0.00728 | 0.0001 | 0.00007055 | 0.00007055
PLATE | FL12*100 | +38.738 | +38.838 | 7 | 8 | 0.7 | 0 | 28.3 | 0 | 100 | 12 | 100 | pe-36 | 0.0169775 | 0.01 | 0.000144 | 0.00007665 | 0.00007665
3 x PLATE | PLT8*132.2 | +66.075 | +66.242 | 8 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pf-279 | 0.0485028 | 0.0220095 | 0.000064 | 0.000175176 | 0.000175176
2 x PLATE | PLT8*74.5 | +48.614 | +48.688 | 7 | 8 | 0.4 | 0 | 38.3 | 0 | 74.5 | 8 | 82.1 | pe-193 | 0.0144432 | 0.00611645 | 0.000064 | 0.0000480316 | 0.0000480316
2 x PLATE | PLT8*47.2 | +48.614 | +48.691 | 7 | 8 | 0.2 | 0 | 40.5 | 0 | 47.2 | 8 | 77.5 | pe-192 | 0.00901591 | 0.003658 | 0.000064 | 0.000028364 | 0.000028364
4 x PLATE | FL10*80 | +48.614 | +48.694 | 7 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pe-65 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
4 x PLATE | FL10*80 | +48.614 | +48.694 | 7 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pe-64 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
PLATE | PLT8*132.2 | +48.525 | +48.691 | 7 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pe-195 | 0.0485028 | 0.0220095 | 0.000064 | 0.000175176 | 0.000175176
PLATE | PLT8*132.2 | +48.525 | +48.692 | 7 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pe-195 | 0.0485048 | 0.0220105 | 0.000064 | 0.000175184 | 0.000175184
PLATE | PLT8*132.2 | +66.075 | +66.242 | 8 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pf-279 | 0.0485048 | 0.0220105 | 0.000064 | 0.000175184 | 0.000175184
PLATE | PLT6*52 | +67.367 | +67.420 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
2 x PLATE | FL6*40 | +67.347 | +67.397 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +67.332 | +67.338 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
3 x PLATE | PLT8*152.5 | +36.095 | +36.259 | 6 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pd-168 | 0.0546582 | 0.024948 | 0.000064 | 0.000198684 | 0.000198684
2 x PLATE | FL10*40 | +36.079 | +36.261 | 6 | 99 | 0.7 | 0 | 33.2 | 0 | 40 | 10 | 182 | pd-116 | 0.0183743 | 0.00728 | 0.0001 | 0.00007055 | 0.00007055
2 x PLATE | FL12*100 | +35.970 | +36.070 | 6 | 8 | 0.7 | 0 | 28.3 | 0 | 100 | 12 | 100 | pd-22 | 0.0169775 | 0.01 | 0.000144 | 0.00007665 | 0.00007665
3 x PLATE | FL10*80 | +36.184 | +36.264 | 6 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pd-49 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
PLATE | PLT8*74.5 | +36.184 | +36.258 | 6 | 8 | 0.4 | 0 | 38.3 | 0 | 74.5 | 8 | 82.1 | pd-166 | 0.0144432 | 0.00611645 | 0.000064 | 0.0000480316 | 0.0000480316
2 x PLATE | FL10*80 | +28.830 | +28.910 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
2 x PLATE | PLT8*152.5 | +28.905 | +29.069 | 6 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pd-168 | 0.0546582 | 0.024948 | 0.000064 | 0.000198684 | 0.000198684
2 x PLATE | FL12*100 | +28.780 | +28.880 | 6 | 8 | 0.7 | 0 | 28.3 | 0 | 100 | 12 | 100 | pd-22 | 0.0169775 | 0.01 | 0.000144 | 0.00007665 | 0.00007665
3 x PLATE | FL10*80 | +28.994 | +29.074 | 6 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pd-49 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
2 x PLATE | FL10*40 | +28.889 | +29.071 | 6 | 99 | 0.7 | 0 | 33.2 | 0 | 40 | 10 | 182 | pd-116 | 0.0183743 | 0.00728 | 0.0001 | 0.00007055 | 0.00007055
2 x PLATE | FL10*80 | +70.400 | +70.480 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
2 x PLATE | FL10*80 | +66.110 | +66.190 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
2 x PLATE | FL6*40 | +71.747 | +71.797 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +71.731 | +71.737 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
PLATE | PLT6*52 | +71.767 | +71.820 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
2 x PLATE | FL10*80 | +63.200 | +63.280 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
2 x PLATE | FL10*80 | +57.880 | +57.961 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
2 x PLATE | FL6*40 | +64.547 | +64.597 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +64.531 | +64.537 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
PLATE | PLT6*52 | +64.567 | +64.620 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
2 x PLATE | FL10*80 | +52.900 | +52.980 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
2 x PLATE | FL10*90 | +55.050 | +55.140 | 1 | 3 | 1 | 0 | 30.1 | 0 | 90 | 10 | 140 | p010020 | 0.0298 | 0.0298 | 0.0009 | 0.000126 | 0.000126
2 x PLATE | FL6*40 | +56.402 | +56.452 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +56.386 | +56.392 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
PLATE | PLT6*52 | +56.422 | +56.475 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
2 x PLATE | FL10*80 | +48.560 | +48.640 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
2 x PLATE | FL6*40 | +49.797 | +49.847 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +49.781 | +49.787 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
PLATE | PLT6*52 | +49.817 | +49.870 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
2 x PLATE | FL10*80 | +44.325 | +44.405 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
2 x PLATE | FL6*40 | +45.672 | +45.722 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +45.656 | +45.662 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
PLATE | PLT6*52 | +45.692 | +45.745 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
2 x PLATE | FL10*80 | +38.788 | +38.868 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
2 x PLATE | FL6*40 | +40.135 | +40.185 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +40.119 | +40.125 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
PLATE | PLT6*52 | +40.155 | +40.208 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
2 x PLATE | FL10*80 | +36.020 | +36.100 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
2 x PLATE | FL10*80 | +31.588 | +31.668 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
2 x PLATE | FL6*40 | +37.367 | +37.417 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +37.351 | +37.357 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
PLATE | PLT6*52 | +37.387 | +37.440 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
28 x PLATE | FL10*70 | +5.199 | +5.337 | 5 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pc-200 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
12 x PLATE | PLT8*163 | +2.575 | +2.738 | 5 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.9 | pc-422 | 0.0764755 | 0.0353466 | 0.000064 | 0.000281873 | 0.000281873
5 x PLATE | PLT8*132.2 | +2.575 | +2.742 | 5 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pc-423 | 0.0485077 | 0.0220119 | 0.000064 | 0.000175195 | 0.000175195
12 x PLATE | PLT8*163 | +2.575 | +2.738 | 5 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.9 | pc-424 | 0.0593755 | 0.0271966 | 0.000064 | 0.000216673 | 0.000216673
2 x PLATE | PLT10*94.5 | +2.956 | +3.093 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +2.775 | +3.262 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*344.6 | +2.750 | +3.095 | 5 | 99 | 13.7 | 0 | 17.5 | 0.2 | 344.6 | 16 | 491.9 | pc-323 | 0.242078 | 0.169501 | 0.000256 | 0.00175823 | 0.00175823
2 x PLATE | PLT10*94.5 | +2.052 | +2.189 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +1.882 | +2.369 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*344.6 | +2.050 | +2.394 | 5 | 99 | 13.7 | 0 | 17.5 | 0.2 | 344.6 | 16 | 491.9 | pc-323 | 0.242078 | 0.169501 | 0.000256 | 0.00175823 | 0.00175823
2 x PLATE | PLT10*94.5 | +2.053 | +2.221 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +1.913 | +2.369 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353 | +2.041 | +2.394 | 5 | 99 | 16.8 | 0 | 17.5 | 0.3 | 353 | 16 | 626.5 | pc-324 | 0.293181 | 0.221177 | 0.000256 | 0.00213578 | 0.00213578
2 x PLATE | PLT10*94.5 | +2.924 | +3.092 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +2.775 | +3.232 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353 | +2.750 | +3.103 | 5 | 99 | 16.8 | 0 | 17.5 | 0.3 | 353 | 16 | 626.5 | pc-324 | 0.293181 | 0.221177 | 0.000256 | 0.00213578 | 0.00213578
PLATE | PLT10*94.5 | +2.961 | +3.091 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | PLT10*94.5 | +2.961 | +3.091 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +2.775 | +3.265 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*340.8 | +2.750 | +3.091 | 5 | 99 | 13.3 | 0 | 17.7 | 0.2 | 340.8 | 16 | 470.9 | pc-325 | 0.233699 | 0.160488 | 0.000256 | 0.00169594 | 0.00169594
2 x PLATE | PLT10*94.5 | +2.053 | +2.183 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +1.879 | +2.369 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*340.8 | +2.054 | +2.394 | 5 | 99 | 13.3 | 0 | 17.7 | 0.2 | 340.8 | 16 | 470.9 | pc-325 | 0.233699 | 0.160488 | 0.000256 | 0.00169594 | 0.00169594
2 x PLATE | PLT10*94.5 | +4.948 | +5.078 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +4.774 | +5.264 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*343.5 | +4.949 | +5.344 | 5 | 99 | 13.7 | 0 | 17.5 | 0.2 | 343.5 | 16 | 395.8 | pc-326 | 0.236455 | 0.135951 | 0.000256 | 0.00172694 | 0.00172694
2 x PLATE | PLT10*94.5 | +5.003 | +5.171 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +4.863 | +5.319 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353 | +4.991 | +5.344 | 5 | 99 | 13.7 | 0 | 17.5 | 0.2 | 353 | 16 | 403.9 | pc-327 | 0.241495 | 0.142601 | 0.000256 | 0.001764 | 0.001764
2 x PLATE | PLT10*94.5 | +4.967 | +5.104 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +4.797 | +5.284 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*345.9 | +4.965 | +5.344 | 5 | 99 | 12.9 | 0 | 17.5 | 0.2 | 346 | 16 | 379.6 | pc-328 | 0.226404 | 0.131297 | 0.000256 | 0.00165033 | 0.00165033
4 x PLATE | PLT10*94.5 | +5.000 | +5.159 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +4.850 | +5.319 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.2 | +4.992 | +5.344 | 5 | 99 | 12.6 | 0 | 17.5 | 0.2 | 352.2 | 16 | 372 | pc-318 | 0.22233 | 0.131021 | 0.000256 | 0.00161857 | 0.00161857
4 x PLATE | PLT10*94.5 | +0.202 | +0.360 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +0.041 | +0.511 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*343.4 | +0.025 | +0.368 | 5 | 99 | 12.4 | 0 | 17.5 | 0.2 | 343.5 | 16 | 357.3 | pc-319 | 0.217221 | 0.122703 | 0.000256 | 0.00158031 | 0.00158031
2 x PLATE | PLT10*94.5 | +0.311 | +0.440 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +0.124 | +0.614 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353 | +0.025 | +0.440 | 5 | 99 | 14.9 | 0 | 17.5 | 0.3 | 353 | 16 | 415.2 | pc-320 | 0.260207 | 0.146565 | 0.000256 | 0.00190728 | 0.00190728
2 x PLATE | PLT10*94.5 | +0.190 | +0.357 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +0.041 | +0.497 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*343.6 | +0.025 | +0.369 | 5 | 99 | 13.7 | 0 | 17.5 | 0.2 | 343.6 | 16 | 386.7 | pc-321 | 0.236744 | 0.132892 | 0.000256 | 0.00172983 | 0.00172983
2 x PLATE | PLT10*94.5 | +0.280 | +0.417 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +0.100 | +0.587 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.9 | +0.025 | +0.419 | 5 | 99 | 14.1 | 0 | 17.5 | 0.2 | 353 | 16 | 394.1 | pc-322 | 0.246152 | 0.139064 | 0.000256 | 0.00180034 | 0.00180034
4 x PLATE | PLT8*155 | +2.575 | +2.738 | 5 | 8 | 1.6 | 0 | 35 | 0.1 | 155 | 8 | 163 | pc-427 | 0.0553228 | 0.025265 | 0.000064 | 0.00020122 | 0.00020122
4 x PLATE | PLT8*132.2 | +8.429 | +8.596 | 5 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pc-423 | 0.0485064 | 0.0220113 | 0.000064 | 0.00017519 | 0.00017519
8 x PLATE | PLT8*155.4 | +8.429 | +8.595 | 5 | 8 | 1.6 | 0 | 35 | 0.1 | 155.4 | 8 | 166 | pc-428 | 0.0564573 | 0.0258047 | 0.000064 | 0.000205538 | 0.000205538
PLATE | PLT16*336.3 | +5.514 | +5.530 | 5 | 99 | 11.9 | 0.1 | 17.7 | 0.2 | 336.2 | 16 | 390.4 | pc-329 | 0.207689 | 0.13131 | 0.000256 | 0.00150366 | 0.00150366
2 x PLATE | PLT16*336.3 | +5.514 | +5.530 | 5 | 99 | 11.9 | 0.1 | 17.7 | 0.2 | 336.2 | 16 | 390.4 | pc-329 | 0.20769 | 0.13131 | 0.000256 | 0.00150366 | 0.00150366
2 x PLATE | PLT16*379.2 | +5.514 | +5.530 | 5 | 99 | 28.1 | 0.2 | 16.9 | 0.5 | 379.2 | 16 | 678.9 | pc-398 | 0.477778 | 0.257455 | 0.000256 | 0.00357819 | 0.00357819
PLATE | PLT16*336.3 | +5.514 | +5.530 | 5 | 99 | 11.9 | 0.1 | 17.7 | 0.2 | 336.2 | 16 | 390.4 | pc-329 | 0.207554 | 0.13131 | 0.000256 | 0.00150259 | 0.00150259
2 x PLATE | PLT8*132.2 | +3.075 | +3.241 | 5 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pc-423 | 0.0485065 | 0.0220113 | 0.000064 | 0.00017519 | 0.00017519
6 x PLATE | PLT8*132.2 | +3.075 | +3.241 | 5 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pc-423 | 0.0485064 | 0.0220112 | 0.000064 | 0.00017519 | 0.00017519
2 x PLATE | PLT8*132.2 | +3.075 | +3.242 | 5 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pc-423 | 0.0485064 | 0.0220112 | 0.000064 | 0.00017519 | 0.00017519
3 x PLATE | PLT8*163 | +11.026 | +11.189 | 5 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.4 | pc-424 | 0.0592044 | 0.0271151 | 0.000064 | 0.00021602 | 0.00021602
6 x PLATE | PLT8*132.2 | +11.025 | +11.192 | 5 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pc-423 | 0.0485066 | 0.0220113 | 0.000064 | 0.000175191 | 0.000175191
6 x PLATE | PLT8*132.2 | +5.325 | +5.492 | 5 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pc-423 | 0.0485066 | 0.0220113 | 0.000064 | 0.000175191 | 0.000175191
2 x PLATE | PLT8*163 | +5.325 | +5.488 | 5 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.9 | pc-424 | 0.0593754 | 0.0271966 | 0.000064 | 0.000216672 | 0.000216672
PLATE | PLT8*166.5 | +5.325 | +5.492 | 5 | 8 | 1.7 | 0 | 34.9 | 0.1 | 166.5 | 8 | 167.2 | pc-426 | 0.0607215 | 0.0278388 | 0.000064 | 0.00022181 | 0.00022181
PLATE | PLT8*163.5 | +5.325 | +5.489 | 5 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163.5 | 8 | 166.4 | pc-424 | 0.0593788 | 0.0271982 | 0.000064 | 0.000216686 | 0.000216686
PLATE | PLT8*82.1 | +5.306 | +5.489 | 5 | 8 | 1 | 0 | 36.4 | 0 | 82.1 | 8 | 182.5 | pc-420 | 0.0339048 | 0.0149833 | 0.000064 | 0.000118966 | 0.000118966
2 x PLATE | PLT10*160 | +5.306 | +5.494 | 5 | 8 | 2.5 | 0 | 28.5 | 0.1 | 159.9 | 10 | 188 | pc-129 | 0.06712 | 0.03008 | 0.0001 | 0.0003008 | 0.0003008
PLATE | PLT8*47.1 | +5.414 | +5.492 | 5 | 8 | 0.2 | 0 | 40.5 | 0 | 47.1 | 8 | 77.5 | pc-418 | 0.00899881 | 0.00365025 | 0.000064 | 0.000028302 | 0.000028302
2 x PLATE | PLT8*74.5 | +5.414 | +5.489 | 5 | 8 | 0.4 | 0 | 38.3 | 0 | 74.5 | 8 | 82.1 | pc-419 | 0.0144432 | 0.00611645 | 0.000064 | 0.0000480316 | 0.0000480316
PLATE | PLT8*47.2 | +5.414 | +5.492 | 5 | 8 | 0.2 | 0 | 40.5 | 0 | 47.2 | 8 | 77.5 | pc-418 | 0.00901591 | 0.003658 | 0.000064 | 0.000028364 | 0.000028364
4 x PLATE | FL10*80 | +5.414 | +5.494 | 5 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pc-150 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
4 x PLATE | FL10*80 | +5.414 | +5.494 | 5 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pc-149 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
2 x PLATE | PLT10*82.1 | +5.156 | +5.489 | 5 | 8 | 2.1 | 0 | 29.2 | 0.1 | 82.1 | 10 | 332.6 | pc-199 | 0.0622812 | 0.0273065 | 0.0001 | 0.000270815 | 0.000270815
4 x PLATE | FL12*70 | +9.850 | +9.862 | 5 | 99 | 1 | 0 | 26.6 | 0 | 70 | 12 | 137.8 | pc-93 | 0.0236183 | 0.009646 | 0.000144 | 0.000113052 | 0.000113052
4 x PLATE | FL12*70 | +10.182 | +10.194 | 5 | 99 | 1 | 0 | 26.6 | 0 | 70 | 12 | 137.8 | pc-93 | 0.0236183 | 0.009646 | 0.000144 | 0.000113052 | 0.000113052
4 x PLATE | FL12*70 | +11.850 | +11.862 | 5 | 99 | 1 | 0 | 26.6 | 0 | 70 | 12 | 137.8 | pc-93 | 0.0236183 | 0.009646 | 0.000144 | 0.000113052 | 0.000113052
4 x PLATE | FL12*70 | +12.182 | +12.194 | 5 | 99 | 1 | 0 | 26.6 | 0 | 70 | 12 | 137.8 | pc-93 | 0.0236183 | 0.009646 | 0.000144 | 0.000113052 | 0.000113052
4 x PLATE | PLT12*82.1 | +10.856 | +11.188 | 5 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pc-88 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
2 x PLATE | PLT12*82.1 | +10.856 | +11.189 | 5 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pc-88 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
PLATE | PLT8*85 | +12.325 | +12.489 | 5 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163.6 | pc-415 | 0.0317862 | 0.0139044 | 0.000064 | 0.000111235 | 0.000111235
2 x PLATE | PLT8*163.6 | +12.325 | +12.489 | 5 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163.6 | 8 | 166.4 | pc-424 | 0.0594136 | 0.0272149 | 0.000064 | 0.000216819 | 0.000216819
6 x PLATE | PLT8*163 | +10.415 | +10.578 | 5 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.4 | pc-424 | 0.0592044 | 0.0271151 | 0.000064 | 0.00021602 | 0.00021602
2 x PLATE | FL10*90 | +12.510 | +12.618 | 5 | 8 | 0.7 | 0 | 30.8 | 0 | 90 | 10 | 108 | pc-131 | 0.0234 | 0.00971999 | 0.0001 | 0.0000971999 | 0.0000971999
2 x PLATE | FL10*90 | +12.500 | +12.510 | 5 | 8 | 1.3 | 0 | 29.7 | 0 | 90 | 10 | 184.9 | pc-126 | 0.0387993 | 0.0166497 | 0.0001 | 0.000166497 | 0.000166497
4 x PLATE | PLT10*94.5 | +5.000 | +5.160 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +4.851 | +5.319 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.3 | +4.992 | +5.344 | 5 | 99 | 11.6 | 0 | 17.7 | 0.2 | 352.2 | 16 | 353.5 | pc-339 | 0.205561 | 0.124525 | 0.000256 | 0.00149023 | 0.00149023
PLATE | PLT16*352.3 | +4.992 | +5.344 | 5 | 99 | 11.9 | 0 | 17.7 | 0.2 | 352.2 | 16 | 358.3 | pc-330 | 0.208373 | 0.126226 | 0.000256 | 0.00151163 | 0.00151163
2 x PLATE | PLT10*94.5 | +5.004 | +5.132 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +4.829 | +5.319 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*339.7 | +5.005 | +5.344 | 5 | 99 | 11.6 | 0 | 17.7 | 0.2 | 339.8 | 16 | 348.6 | pc-331 | 0.203021 | 0.118438 | 0.000256 | 0.00147178 | 0.00147178
2 x PLATE | PLT10*94.5 | +5.003 | +5.172 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +4.864 | +5.319 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353 | +4.991 | +5.344 | 5 | 99 | 12.1 | 0 | 17.5 | 0.2 | 353 | 16 | 367.1 | pc-332 | 0.212477 | 0.129574 | 0.000256 | 0.00154239 | 0.00154239
2 x PLATE | PLT10*94.5 | +5.002 | +5.138 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +4.832 | +5.319 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*344.1 | +5.000 | +5.344 | 5 | 99 | 11.6 | 0 | 17.7 | 0.2 | 344.1 | 16 | 350 | pc-333 | 0.204073 | 0.120409 | 0.000256 | 0.00147962 | 0.00147962
4 x PLATE | PLT10*94.5 | +0.213 | +0.372 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +0.053 | +0.522 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*347 | +0.025 | +0.380 | 5 | 99 | 12.4 | 0 | 17.5 | 0.2 | 347 | 16 | 355.3 | pc-334 | 0.219255 | 0.123322 | 0.000256 | 0.00159561 | 0.00159561
PLATE | PLT16*347.1 | +0.025 | +0.381 | 5 | 99 | 12.4 | 0 | 17.5 | 0.2 | 347.1 | 16 | 355.5 | pc-334 | 0.219366 | 0.123387 | 0.000256 | 0.00159645 | 0.00159645
2 x PLATE | PLT10*94.5 | +0.250 | +0.378 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +0.063 | +0.553 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.4 | +0.025 | +0.377 | 5 | 99 | 12.4 | 0 | 17.5 | 0.2 | 352.5 | 16 | 352.9 | pc-335 | 0.218827 | 0.124365 | 0.000256 | 0.00159181 | 0.00159181
2 x PLATE | PLT10*94.5 | +0.197 | +0.366 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +0.049 | +0.505 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*341.1 | +0.025 | +0.377 | 5 | 99 | 12.4 | 0 | 17.5 | 0.2 | 341.1 | 16 | 352.3 | pc-336 | 0.21593 | 0.12016 | 0.000256 | 0.00157029 | 0.00157029
2 x PLATE | PLT10*94.5 | +0.254 | +0.390 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +0.072 | +0.560 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.9 | +0.025 | +0.391 | 5 | 99 | 12.9 | 0 | 17.5 | 0.2 | 353 | 16 | 366.2 | pc-337 | 0.227806 | 0.129248 | 0.000256 | 0.00166046 | 0.00166046
2 x PLATE | PLT10*94.5 | +5.928 | +6.048 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +5.735 | +6.227 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*344.8 | +5.700 | +6.045 | 5 | 99 | 11.9 | 0 | 17.5 | 0.2 | 344.7 | 16 | 350.5 | pc-338 | 0.209548 | 0.120851 | 0.000256 | 0.00152171 | 0.00152171
PLATE | PLT16*351.7 | +5.700 | +6.052 | 5 | 99 | 12.1 | 0 | 17.5 | 0.2 | 351.8 | 16 | 364.6 | pc-292 | 0.21218 | 0.128202 | 0.000256 | 0.00154073 | 0.00154073
2 x PLATE | PLT10*94.5 | +5.932 | +6.044 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +5.735 | +6.228 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*339.2 | +5.700 | +6.039 | 5 | 99 | 12.1 | 0 | 17.5 | 0.2 | 339.2 | 16 | 355.6 | pc-340 | 0.211726 | 0.12064 | 0.000256 | 0.00153846 | 0.00153846
2 x PLATE | PLT16*348.2 | +5.700 | +6.048 | 5 | 99 | 11.6 | 0 | 17.7 | 0.2 | 348.2 | 16 | 350.5 | pc-341 | 0.204393 | 0.122004 | 0.000256 | 0.00148181 | 0.00148181
4 x PLATE | PLT10*94.5 | +11.800 | +11.945 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +11.637 | +12.119 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*345.4 | +11.796 | +12.144 | 5 | 99 | 11.5 | 0 | 17.7 | 0.2 | 345.4 | 16 | 348.3 | pc-342 | 0.201515 | 0.120263 | 0.000256 | 0.00145988 | 0.00145988
2 x PLATE | PLT10*94.5 | +11.810 | +11.922 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +11.626 | +12.119 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*329.2 | +11.815 | +12.144 | 5 | 99 | 11.3 | 0 | 17.7 | 0.2 | 329.2 | 16 | 344.8 | pc-343 | 0.199514 | 0.113501 | 0.000256 | 0.00144531 | 0.00144531
PLATE | PLT16*349.6 | +11.793 | +12.144 | 5 | 99 | 11.6 | 0 | 17.7 | 0.2 | 349.6 | 16 | 351.8 | pc-344 | 0.203485 | 0.122927 | 0.000256 | 0.00147453 | 0.00147453
2 x PLATE | PLT10*94.5 | +11.807 | +11.927 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
5 x PLATE | FL16*250 | +11.627 | +12.119 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*334.8 | +11.810 | +12.144 | 5 | 99 | 11.3 | 0 | 17.7 | 0.2 | 334.8 | 16 | 344 | pc-345 | 0.199824 | 0.115151 | 0.000256 | 0.00144756 | 0.00144756
2 x PLATE | FL12*130 | +5.370 | +5.500 | 5 | 8 | 1.3 | 0 | 25.9 | 0 | 130 | 12 | 150 | pc-83 | 0.0329549 | 0.0195003 | 0.000144 | 0.000162002 | 0.000162002
2 x PLATE | FL10*90 | -0.260 | -0.150 | 5 | 8 | 0.7 | 0 | 30.6 | 0 | 90 | 10 | 110 | pc-130 | 0.0238 | 0.00989999 | 0.0001 | 0.0000989999 | 0.0000989999
2 x PLATE | FL10*90 | -0.270 | -0.260 | 5 | 8 | 1.3 | 0 | 29.7 | 0 | 90 | 10 | 184.9 | pc-125 | 0.0387993 | 0.0166497 | 0.0001 | 0.000166497 | 0.000166497
2 x PLATE | PLT10*121.5 | +20.781 | +20.935 | 4 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pb-165 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
PLATE | FL16*300 | +20.563 | +21.207 | 4 | 99 | 21.8 | 0 | 17.2 | 0.3 | 300 | 16 | 575 | pb-236 | 0.373 | 0.373 | 0.0048 | 0.00276 | 0.00276
PLATE | PLT16*525.3 | +20.784 | +21.731 | 4 | 99 | 37.8 | 0 | 16.9 | 0.6 | 525.3 | 16 | 947 | pb-195 | 0.642135 | 0.497497 | 0.000256 | 0.0048181 | 0.0048181
2 x PLATE | PLT10*121.5 | +23.640 | +23.794 | 4 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pb-165 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
PLATE | FL16*300 | +23.421 | +24.065 | 4 | 99 | 21.8 | 0 | 17.2 | 0.3 | 300 | 16 | 575 | pb-236 | 0.373 | 0.373 | 0.0048 | 0.00276 | 0.00276
PLATE | PLT16*525.3 | +23.643 | +24.589 | 4 | 99 | 37.8 | 0 | 16.9 | 0.6 | 525.3 | 16 | 946.8 | pb-195 | 0.642022 | 0.497391 | 0.000256 | 0.00481724 | 0.00481724
2 x PLATE | PLT10*121.5 | +16.087 | +16.241 | 4 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pb-165 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
PLATE | FL16*300 | +15.815 | +16.459 | 4 | 99 | 21.8 | 0 | 17.2 | 0.3 | 300 | 16 | 575 | pb-236 | 0.373 | 0.373 | 0.0048 | 0.00276 | 0.00276
PLATE | PLT16*458.8 | +15.700 | +16.238 | 4 | 99 | 25.1 | 0 | 16.9 | 0.3 | 458.8 | 16 | 537.7 | pb-194 | 0.427227 | 0.246718 | 0.000256 | 0.00319471 | 0.00319471
2 x PLATE | PLT10*121.5 | +18.372 | +18.526 | 4 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pb-165 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
PLATE | FL16*300 | +18.100 | +18.744 | 4 | 99 | 21.8 | 0 | 17.2 | 0.3 | 300 | 16 | 575 | pb-236 | 0.373 | 0.373 | 0.0048 | 0.00276 | 0.00276
PLATE | PLT16*464.3 | +18.050 | +18.523 | 4 | 99 | 23 | 0 | 17.2 | 0.3 | 464.3 | 16 | 472.8 | pb-193 | 0.393213 | 0.219504 | 0.000256 | 0.00293309 | 0.00293309
2 x PLATE | PLT10*94.5 | +20.747 | +20.933 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +20.636 | +21.052 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*321.4 | +20.729 | +21.086 | 4 | 99 | 11.9 | 0 | 17.5 | 0.2 | 321.4 | 16 | 357.3 | pb-232 | 0.209217 | 0.114794 | 0.000256 | 0.00151939 | 0.00151939
2 x PLATE | PLT10*94.5 | +18.193 | +18.379 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +18.075 | +18.491 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*347.5 | +18.050 | +18.398 | 4 | 99 | 16.7 | 0 | 17.5 | 0.3 | 347.5 | 16 | 506.5 | pb-231 | 0.289835 | 0.176026 | 0.000256 | 0.00212736 | 0.00212736
2 x PLATE | PLT10*94.5 | +15.814 | +16.011 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +15.814 | +16.011 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +15.725 | +16.095 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*334.5 | +15.700 | +16.035 | 4 | 99 | 21.8 | 0 | 17.3 | 0.3 | 334.5 | 16 | 668.3 | pb-177 | 0.375983 | 0.223574 | 0.000256 | 0.00277548 | 0.00277548
4 x PLATE | PLT10*94.5 | +17.376 | +17.573 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +17.292 | +17.662 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*323.7 | +17.353 | +17.676 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 323.7 | 16 | 381.3 | pb-176 | 0.23425 | 0.123448 | 0.000256 | 0.00170957 | 0.00170957
8 x PLATE | FL16*80 | +17.706 | +17.830 | 4 | 99 | 1.3 | 0 | 21.1 | 0 | 80 | 16 | 123.6 | pb-234 | 0.02556 | 0.009888 | 0.000256 | 0.000154608 | 0.000154608
8 x PLATE | FL16*80 | +17.850 | +18.038 | 4 | 99 | 1.9 | 0 | 20.4 | 0 | 80 | 16 | 188 | pb-233 | 0.0379248 | 0.01504 | 0.000256 | 0.00023704 | 0.00023704
2 x PLATE | PLT20*172 | +17.830 | +17.850 | 4 | 8 | 39.1 | 0.2 | 14.4 | 0.6 | 172 | 20 | 1449.2 | pb-39 | 0.563315 | 0.563315 | 0.00344 | 0.00498473 | 0.00498473
6 x PLATE | PLT10*94.5 | +24.478 | +24.655 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +10.799 | +10.944 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +14.990 | +15.135 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
6 x PLATE | PLT10*94.5 | +10.756 | +10.929 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
6 x PLATE | PLT10*94.5 | +15.005 | +15.179 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +15.836 | +16.025 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +17.369 | +17.559 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +15.807 | +16.005 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +17.389 | +17.588 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | PLT10*94.5 | +18.183 | +18.373 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | PLT10*94.5 | +20.781 | +20.972 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | PLT10*94.5 | +21.580 | +21.775 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | PLT10*94.5 | +23.648 | +23.843 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | PLT10*94.5 | +15.531 | +15.626 | 4 | 8 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | PLT10*94.5 | +15.419 | +15.513 | 4 | 8 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +15.514 | +15.530 | 4 | 8 | 13.3 | 0.1 | 17.5 | 0.2 | 250 | 16 | 425 | pb-206 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*318.3 | +15.498 | +15.514 | 4 | 8 | 10.6 | 0.1 | 17.7 | 0.2 | 318.3 | 16 | 348.7 | pb-204 | 0.188929 | 0.111022 | 0.000256 | 0.00136269 | 0.00136269
PLATE | PLT16*352.5 | +15.498 | +15.514 | 4 | 8 | 15.1 | 0.1 | 17.5 | 0.3 | 352.5 | 16 | 524.6 | pb-203 | 0.264838 | 0.184925 | 0.000256 | 0.00193011 | 0.00193011
PLATE | PLT16*352.5 | +15.498 | +15.514 | 4 | 8 | 15.1 | 0.1 | 17.5 | 0.3 | 352.5 | 16 | 524.6 | pb-203 | 0.264838 | 0.184925 | 0.000256 | 0.00193012 | 0.00193012
2 x PLATE | PLT10*94.5 | +17.711 | +17.806 | 4 | 8 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +17.599 | +17.693 | 4 | 8 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +17.694 | +17.710 | 4 | 8 | 13.3 | 0.1 | 17.5 | 0.2 | 250 | 16 | 425 | pb-206 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*533.2 | +17.678 | +17.694 | 4 | 8 | 30.8 | 0.2 | 16.9 | 0.5 | 533.2 | 16 | 649 | pb-202 | 0.522172 | 0.346048 | 0.000256 | 0.00391819 | 0.00391819
PLATE | PLT16*524 | +17.678 | +17.694 | 4 | 8 | 29.9 | 0.2 | 16.9 | 0.5 | 524 | 16 | 645 | pb-201 | 0.508281 | 0.337949 | 0.000256 | 0.00381022 | 0.00381022
PLATE | PLT10*81.8 | +17.711 | +17.793 | 4 | 8 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pb-166 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
2 x PLATE | PLT10*81.8 | +17.612 | +17.693 | 4 | 8 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pb-166 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
2 x PLATE | PLT16*210 | +17.694 | +17.710 | 4 | 8 | 11.1 | 0.1 | 17.7 | 0.2 | 210 | 16 | 425 | pb-205 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*363.9 | +17.678 | +17.694 | 4 | 8 | 17.6 | 0.1 | 17.3 | 0.3 | 363.9 | 16 | 476.6 | pb-200 | 0.304977 | 0.173441 | 0.000256 | 0.00224947 | 0.00224947
PLATE | PLT10*81.9 | +17.711 | +17.793 | 4 | 8 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pb-166 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
PLATE | PLT16*363.9 | +17.678 | +17.694 | 4 | 8 | 12.9 | 0.1 | 17.5 | 0.2 | 363.9 | 16 | 373.6 | pb-199 | 0.226715 | 0.135959 | 0.000256 | 0.00164975 | 0.00164975
8 x PLATE | FL12*80 | +21.116 | +21.448 | 4 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pb-48 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
2 x PLATE | PLT12*113.3 | +21.116 | +21.448 | 4 | 99 | 3.3 | 0 | 24.3 | 0.1 | 113.3 | 12 | 331.6 | pb-46 | 0.0803695 | 0.0375869 | 0.000144 | 0.000421417 | 0.000421417
4 x PLATE | PLT12*113.3 | +21.260 | +21.448 | 4 | 8 | 1.9 | 0 | 24.9 | 0 | 113.3 | 12 | 188.5 | pb-47 | 0.0483049 | 0.0213665 | 0.000144 | 0.000246996 | 0.000255048
PLATE | FL12*200 | +21.260 | +21.460 | 4 | 8 | 21.2 | 0 | 22.8 | 0.5 | 200 | 12 | 1126 | pb-45 | 0.482224 | 0.2252 | 0.000144 | 0.0027024 | 0.0027024
PLATE | FL10*60 | +21.438 | +21.448 | 4 | 8 | 5.1 | 0.1 | 30 | 0.2 | 60 | 10 | 1114 | pb-163 | 0.15716 | 0.06684 | 0.0001 | 0.0006684 | 0.0006684
2 x PLATE | PLT12*82.1 | +21.266 | +21.448 | 4 | 8 | 1.5 | 0 | 25.8 | 0 | 82.1 | 12 | 182.5 | pb-43 | 0.0359865 | 0.0149832 | 0.000144 | 0.000178449 | 0.000178449
2 x PLATE | FL10*70 | +26.070 | +26.208 | 6 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pd-115 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
2 x PLATE | FL10*70 | +19.410 | +19.548 | 4 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pb-76 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
2 x PLATE | FL12*70 | +17.905 | +18.043 | 4 | 99 | 1 | 0 | 26.6 | 0 | 70 | 12 | 137.8 | pb-50 | 0.0236183 | 0.009646 | 0.000144 | 0.000113052 | 0.000113052
2 x PLATE | FL10*70 | +23.973 | +24.111 | 4 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pb-76 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
2 x PLATE | FL12*100 | +17.750 | +17.850 | 4 | 8 | 0.7 | 0 | 28.3 | 0 | 100 | 12 | 100 | pb-42 | 0.0169775 | 0.01 | 0.000144 | 0.00007665 | 0.00007665
2 x PLATE | FL12*100 | +21.160 | +21.260 | 4 | 8 | 0.7 | 0 | 28.3 | 0 | 100 | 12 | 100 | pb-42 | 0.0169775 | 0.01 | 0.000144 | 0.00007665 | 0.00007665
4 x PLATE | FL10*70 | +21.115 | +21.253 | 4 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pb-76 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
28 x PLATE | FL10*70 | +20.959 | +21.097 | 4 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pb-76 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
4 x PLATE | PLT20*140 | +12.145 | +12.165 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
4 x PLATE | PLT20*140 | +12.480 | +12.500 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
4 x PLATE | PLT20*140 | +5.345 | +5.365 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
4 x PLATE | PLT20*140 | +5.680 | +5.700 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
4 x PLATE | PLT20*140 | +17.695 | +17.715 | 4 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pb-38 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
4 x PLATE | PLT20*140 | +18.030 | +18.050 | 4 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pb-38 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
2 x PLATE | PLT8*85 | +24.143 | +24.306 | 4 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pb-245 | 0.031678 | 0.013855 | 0.000064 | 0.00011084 | 0.00011084
2 x PLATE | PLT8*163 | +24.143 | +24.306 | 4 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pb-240 | 0.0763242 | 0.0352745 | 0.000064 | 0.000281296 | 0.000281296
19 x PLATE | PLT8*163 | +21.285 | +21.448 | 4 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pb-240 | 0.0763009 | 0.0352634 | 0.000064 | 0.000281207 | 0.000281207
12 x PLATE | FL10*70 | +17.549 | +17.687 | 4 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pb-76 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
10 x PLATE | FL10*70 | +17.705 | +17.843 | 4 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pb-76 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
PLATE | PLT8*85 | +21.285 | +21.448 | 4 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pb-245 | 0.031678 | 0.013855 | 0.000064 | 0.00011084 | 0.00011084
PLATE | PLT8*163 | +21.285 | +21.448 | 4 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pb-242 | 0.0594608 | 0.0272372 | 0.000064 | 0.000216998 | 0.000216998
4 x PLATE | PLT8*132.2 | +21.285 | +21.451 | 4 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pb-239 | 0.0485065 | 0.0220113 | 0.000064 | 0.00017519 | 0.00017519
10 x PLATE | PLT8*163 | +17.875 | +18.038 | 4 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pb-240 | 0.0763009 | 0.0352634 | 0.000064 | 0.000281207 | 0.000281207
4 x PLATE | FL10*70 | +15.199 | +15.337 | 4 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pb-76 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
15 x PLATE | PLT8*132.2 | +17.875 | +18.041 | 4 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pb-239 | 0.0485065 | 0.0220113 | 0.000064 | 0.00017519 | 0.00017519
PLATE | PLT8*152.5 | +17.875 | +18.039 | 4 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pb-244 | 0.0546582 | 0.024948 | 0.000064 | 0.000198684 | 0.000198684
3 x PLATE | PLT8*152.5 | +21.285 | +21.449 | 4 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pb-244 | 0.0546582 | 0.024948 | 0.000064 | 0.000198684 | 0.000198684
2 x PLATE | FL10*40 | +21.269 | +21.451 | 4 | 99 | 0.7 | 0 | 33.2 | 0 | 40 | 10 | 182 | pb-75 | 0.0183743 | 0.00728 | 0.0001 | 0.00007055 | 0.00007055
PLATE | PLT8*152.5 | +17.875 | +18.039 | 4 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pb-244 | 0.0546583 | 0.024948 | 0.000064 | 0.000198684 | 0.000198684
2 x PLATE | PLT8*163 | +17.875 | +18.038 | 4 | 8 | 2.5 | 0 | 34.3 | 0.1 | 163 | 8 | 242.2 | pb-243 | 0.085111 | 0.0394624 | 0.000064 | 0.000314799 | 0.000314799
8 x PLATE | PLT8*163 | +17.875 | +18.038 | 4 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pb-242 | 0.0594608 | 0.0272372 | 0.000064 | 0.000216998 | 0.000216998
PLATE | PLT8*85 | +17.875 | +18.038 | 4 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pb-245 | 0.031678 | 0.013855 | 0.000064 | 0.00011084 | 0.00011084
5 x PLATE | PLT8*163 | +17.875 | +18.038 | 4 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pb-240 | 0.0763044 | 0.0352651 | 0.000064 | 0.00028122 | 0.00028122
2 x PLATE | PLT8*163 | +17.875 | +18.038 | 4 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pb-242 | 0.0594609 | 0.0272373 | 0.000064 | 0.000216998 | 0.000216998
5 x PLATE | PLT8*155 | +15.525 | +15.691 | 4 | 8 | 1.6 | 0 | 35 | 0.1 | 155 | 8 | 166.4 | pb-241 | 0.0564311 | 0.025792 | 0.000064 | 0.000205436 | 0.000205436
19 x PLATE | PLT8*163 | +15.525 | +15.688 | 4 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pb-240 | 0.0763044 | 0.0352651 | 0.000064 | 0.00028122 | 0.00028122
2 x PLATE | PLT8*132.2 | +24.143 | +24.309 | 4 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166 | pb-239 | 0.0483663 | 0.0219452 | 0.000064 | 0.000174662 | 0.000174662
2 x PLATE | PLT8*132.2 | +19.580 | +19.746 | 4 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166 | pb-239 | 0.0483663 | 0.0219452 | 0.000064 | 0.000174662 | 0.000174662
2 x PLATE | PLT8*85 | +15.525 | +15.688 | 4 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pb-245 | 0.031678 | 0.013855 | 0.000064 | 0.00011084 | 0.00011084
2 x PLATE | PLT8*132.2 | +12.970 | +13.136 | 4 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166 | pb-239 | 0.0483663 | 0.0219452 | 0.000064 | 0.000174662 | 0.000174662
3 x PLATE | FL10*80 | +21.374 | +21.454 | 4 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pb-73 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
PLATE | PLT8*74.5 | +21.374 | +21.448 | 4 | 8 | 0.4 | 0 | 38.3 | 0 | 74.5 | 8 | 82.1 | pb-238 | 0.0144432 | 0.00611645 | 0.000064 | 0.0000480316 | 0.0000480316
2 x PLATE | FL10*40 | +17.859 | +18.041 | 4 | 99 | 0.7 | 0 | 33.2 | 0 | 40 | 10 | 182 | pb-75 | 0.0183743 | 0.00728 | 0.0001 | 0.00007055 | 0.00007055
5 x PLATE | PLT20*140 | +23.963 | +23.983 | 4 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pb-38 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
5 x PLATE | PLT20*140 | +24.298 | +24.318 | 4 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pb-38 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
3 x PLATE | PLT20*140 | +21.105 | +21.125 | 4 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pb-38 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
3 x PLATE | PLT20*140 | +21.440 | +21.460 | 4 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pb-38 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
3 x PLATE | PLT16*210 | +15.344 | +15.360 | 5 | 99 | 11.1 | 0.1 | 17.7 | 0.2 | 210 | 16 | 425 | pc-384 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*485.5 | +15.328 | +15.344 | 5 | 99 | 25.8 | 0.2 | 17.2 | 0.3 | 485.5 | 16 | 594.3 | pc-314 | 0.440206 | 0.28857 | 0.000256 | 0.003284 | 0.003284
PLATE | PLT16*494.8 | +15.328 | +15.344 | 5 | 99 | 26.4 | 0.2 | 17.2 | 0.5 | 494.8 | 16 | 594.2 | pc-315 | 0.451413 | 0.294009 | 0.000256 | 0.00337131 | 0.00337131
PLATE | PLT16*469.3 | +15.328 | +15.344 | 5 | 99 | 22.6 | 0.2 | 17.2 | 0.3 | 469.3 | 16 | 510.7 | pc-258 | 0.38676 | 0.239665 | 0.000256 | 0.00287824 | 0.00287824
