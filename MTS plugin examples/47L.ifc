Properties of the parts of a building model (IFC2X3), part 2 of 22

# IfcBeam: L70*70*6 (1033)
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
H/RAIL POST | +60.560 | +61.840 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F309 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +60.560 | +61.840 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F310 | 1280 | 0.348511 | 0.00101859 | 7.99593
26 x H/RAIL POST | +5.525 | +6.805 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C342 | 1280 | 0.348511 | 0.00101859 | 7.99593
13 x H/RAIL POST | +15.525 | +16.805 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C343 | 1280 | 0.348511 | 0.00101859 | 7.99593
4 x H/RAIL POST | +31.553 | +32.833 | 6 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-E-D153 | 1280 | 0.348511 | 0.00101859 | 7.99593
2 x H/RAIL POST | +31.553 | +32.833 | 6 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-E-D152 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +31.553 | +32.833 | 6 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-E-D151 | 1280 | 0.348511 | 0.00102912 | 8.07859
16 x H/RAIL POST | +36.095 | +37.375 | 6 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-E-D152 | 1280 | 0.348511 | 0.00101859 | 7.99593
20 x H/RAIL POST | +28.905 | +30.185 | 6 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-E-D152 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +48.710 | +49.805 | 7 | 14 | 7 | 0 | 0.3 | 1095 | me-155 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +53.050 | +54.145 | 8 | 14 | 7 | 0 | 0.3 | 1095 | mf-242 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +53.050 | +54.145 | 8 | 14 | 7 | 0 | 0.3 | 1095 | mf-241 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +52.865 | +54.145 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F309 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +52.865 | +54.145 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F310 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +58.030 | +59.125 | 8 | 14 | 7 | 0 | 0.3 | 1095 | mf-242 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +58.030 | +59.125 | 8 | 14 | 7 | 0 | 0.3 | 1095 | mf-241 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +57.845 | +59.125 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F309 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +57.845 | +59.125 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F310 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +68.460 | +69.555 | 8 | 14 | 7 | 0 | 0.3 | 1095 | mf-242 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +68.460 | +69.555 | 8 | 14 | 7 | 0 | 0.3 | 1095 | mf-241 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +68.275 | +69.555 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F309 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +68.275 | +69.555 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F310 | 1280 | 0.348511 | 0.00101859 | 7.99593
19 x H/RAIL POST | +70.475 | +71.755 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F309 | 1280 | 0.348511 | 0.00101859 | 7.99593
13 x H/RAIL POST | +70.475 | +71.755 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F310 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +12.325 | +13.605 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C341 | 1280 | 0.348511 | 0.00102912 | 8.07859
27 x H/RAIL POST | +12.325 | +13.605 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C342 | 1280 | 0.348511 | 0.00101859 | 7.99593
32 x H/RAIL POST | +12.325 | +13.605 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C343 | 1280 | 0.348511 | 0.00101859 | 7.99593
20 x H/RAIL POST | +5.525 | +6.805 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C343 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +5.525 | +6.830 | 5 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-D-C340 | 1305 | 0.355318 | 0.00103962 | 8.16101
H/RAIL POST | +12.325 | +13.630 | 5 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-D-C340 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +5.525 | +6.830 | 5 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-D-C339 | 1305 | 0.355318 | 0.00103962 | 8.16102
9 x H/RAIL POST | +5.725 | +7.005 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C343 | 1280 | 0.348511 | 0.00101859 | 7.99593
9 x H/RAIL POST | +5.725 | +7.005 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C342 | 1280 | 0.348511 | 0.00101859 | 7.99593
4 x H/RAIL POST | +56.625 | +57.905 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F309 | 1280 | 0.348511 | 0.00101859 | 7.99593
4 x H/RAIL POST | +56.625 | +57.905 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F310 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +56.655 | +57.935 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F298 | 1280 | 0.348511 | 0.00102297 | 8.03034
H/RAIL POST | +56.655 | +57.935 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F297 | 1280 | 0.348511 | 0.00102297 | 8.03034
3 x H/RAIL POST | +37.925 | +39.205 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E204 | 1280 | 0.348511 | 0.00101859 | 7.99593
3 x H/RAIL POST | +37.925 | +39.205 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E203 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +37.955 | +39.235 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E195 | 1280 | 0.348511 | 0.00102297 | 8.03034
H/RAIL POST | +37.955 | +39.235 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E194 | 1280 | 0.348511 | 0.00102297 | 8.03034
FLOOR BRACE | +70.470 | +70.540 | 8 | 6 | 10.9 | 0.1 | 0.5 | 1687.7 | 471-G-F296 | 1687.73 | 0.459526 | 0.00135694 | 10.652
FLOOR BRACE | +70.470 | +70.540 | 8 | 6 | 9.3 | 0.1 | 0.3 | 1471.9 | 471-G-F295 | 1471.91 | 0.400764 | 0.00118342 | 9.28983
FLOOR BRACE | +68.270 | +68.340 | 8 | 6 | 12.9 | 0.1 | 0.6 | 2004.9 | 471-G-F294 | 2004.9 | 0.545881 | 0.00161194 | 12.6537
FLOOR BRACE | +66.070 | +66.140 | 8 | 6 | 13.7 | 0.2 | 0.6 | 2160.1 | 471-G-F293 | 2160.07 | 0.588131 | 0.00173669 | 13.6331
FLOOR BRACE | +60.555 | +60.625 | 8 | 6 | 12.9 | 0.1 | 0.6 | 2006.3 | 471-G-F290 | 2006.28 | 0.546257 | 0.00161305 | 12.6624
FLOOR BRACE | +57.840 | +57.910 | 8 | 6 | 11.6 | 0.1 | 0.5 | 1818 | 471-G-F291 | 1817.99 | 0.494991 | 0.00146166 | 11.474
FLOOR BRACE | +55.125 | +55.195 | 8 | 6 | 15.8 | 0.2 | 0.6 | 2482.5 | 471-G-F292 | 2482.46 | 0.675909 | 0.00199589 | 15.6678
FLOOR BRACE | +52.860 | +52.930 | 8 | 6 | 11.6 | 0.1 | 0.5 | 1818 | 471-G-F291 | 1817.99 | 0.494991 | 0.00146166 | 11.474
H/RAIL POST | +51.163 | +52.258 | 8 | 14 | 7 | 0 | 0.3 | 1095 | mf-242 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +51.163 | +52.258 | 8 | 14 | 7 | 0 | 0.3 | 1095 | mf-241 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +50.978 | +52.258 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F309 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +50.978 | +52.258 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F310 | 1280 | 0.348511 | 0.00101859 | 7.99593
FLOOR BRACE | +50.973 | +51.043 | 8 | 6 | 12.9 | 0.1 | 0.6 | 2006.3 | 471-G-F290 | 2006.28 | 0.546258 | 0.00161305 | 12.6624
FLOOR BRACE | +48.520 | +48.590 | 7 | 6 | 14.1 | 0.2 | 0.6 | 2204.4 | 471-F-E193 | 2204.36 | 0.600189 | 0.0017723 | 13.9126
H/RAIL POST | +47.023 | +48.118 | 7 | 14 | 7 | 0 | 0.3 | 1095 | me-156 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +47.023 | +48.118 | 7 | 14 | 7 | 0 | 0.3 | 1095 | me-155 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +46.838 | +48.118 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E203 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +46.838 | +48.118 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E204 | 1280 | 0.348511 | 0.00101859 | 7.99593
FLOOR BRACE | +46.833 | +46.903 | 7 | 6 | 12.9 | 0.1 | 0.6 | 2006.3 | 471-F-E192 | 2006.28 | 0.546258 | 0.00161305 | 12.6624
FLOOR BRACE | +44.395 | +44.465 | 7 | 6 | 14.9 | 0.2 | 0.6 | 2343.6 | 471-F-E191 | 2343.57 | 0.638095 | 0.00188423 | 14.7912
H/RAIL POST | +41.816 | +42.911 | 7 | 14 | 7 | 0 | 0.3 | 1095 | me-156 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +41.816 | +42.911 | 7 | 14 | 7 | 0 | 0.3 | 1095 | me-155 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +41.631 | +42.911 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E203 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +41.631 | +42.911 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E204 | 1280 | 0.348511 | 0.00101859 | 7.99593
FLOOR BRACE | +41.626 | +41.696 | 7 | 6 | 12.9 | 0.1 | 0.6 | 2006.3 | 471-F-E192 | 2006.28 | 0.546258 | 0.00161305 | 12.6624
FLOOR BRACE | +38.858 | +38.928 | 7 | 6 | 14.9 | 0.2 | 0.6 | 2343.6 | 471-F-E191 | 2343.57 | 0.638095 | 0.00188423 | 14.7912
H/RAIL POST | +33.824 | +35.104 | 6 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-E-D153 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +33.824 | +35.104 | 6 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-E-D152 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +34.009 | +35.104 | 6 | 14 | 7 | 0 | 0.3 | 1095 | md-122 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +34.009 | +35.104 | 6 | 14 | 7 | 0 | 0.3 | 1095 | md-121 | 1095 | 0.29814 | 0.00086985 | 6.82832
FLOOR BRACE | +33.819 | +33.889 | 6 | 6 | 12.6 | 0.1 | 0.6 | 1967.5 | 471-E-D146 | 1967.48 | 0.535695 | 0.00158186 | 12.4176
FLOOR BRACE | +31.548 | +31.618 | 6 | 6 | 15.6 | 0.2 | 0.6 | 2448.1 | 471-E-D145 | 2448.14 | 0.666565 | 0.0019683 | 15.4512
FLOOR BRACE | +28.900 | +28.970 | 6 | 6 | 14.9 | 0.2 | 0.6 | 2343.6 | 471-E-D144 | 2343.57 | 0.638095 | 0.00188423 | 14.7912
H/RAIL POST | +26.425 | +27.520 | 6 | 14 | 7 | 0 | 0.3 | 1095 | md-122 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +26.425 | +27.520 | 6 | 14 | 7 | 0 | 0.3 | 1095 | md-121 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +26.240 | +27.520 | 6 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-E-D152 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +26.240 | +27.520 | 6 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-E-D153 | 1280 | 0.348511 | 0.00101859 | 7.99593
FLOOR BRACE | +26.235 | +26.305 | 6 | 6 | 12.9 | 0.1 | 0.6 | 2006.3 | 471-E-D143 | 2006.28 | 0.546258 | 0.00161305 | 12.6624
H/RAIL POST | +44.400 | +45.705 | 7 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-F-E190 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +44.400 | +45.705 | 7 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-F-E189 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +70.475 | +71.780 | 8 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-G-F286 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +55.130 | +56.435 | 8 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-G-F286 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +55.130 | +56.435 | 8 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-G-F287 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +63.275 | +64.580 | 8 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-G-F286 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +63.275 | +64.580 | 8 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-G-F287 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +38.863 | +40.168 | 7 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-F-E190 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +38.863 | +40.168 | 7 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-F-E189 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +48.525 | +49.830 | 7 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-F-E189 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +66.075 | +67.380 | 8 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-G-F286 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +36.095 | +37.400 | 6 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-E-D140 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +36.095 | +37.400 | 6 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-E-D139 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +28.905 | +30.210 | 6 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-E-D140 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +28.905 | +30.210 | 6 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-E-D139 | 1305 | 0.355318 | 0.00103962 | 8.16102
8 x H/RAIL POST | +15.525 | +16.805 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C342 | 1280 | 0.348511 | 0.00101859 | 7.99593
21 x H/RAIL POST | +2.575 | +3.855 | 5 | 5 | 8.2 | 0 | 0.3 | 1280 | 471-D-C343 | 1280 | 0.348511 | 0.00101859 | 7.99593
7 x H/RAIL POST | +2.575 | +3.855 | 5 | 5 | 8.2 | 0 | 0.3 | 1280 | 471-D-C342 | 1280 | 0.348511 | 0.00101859 | 7.99593
4 x H/RAIL POST | +2.575 | +3.855 | 5 | 5 | 8.2 | 0 | 0.3 | 1280 | 471-D-C342 | 1280 | 0.348511 | 0.00101859 | 7.99597
H/RAIL POST | +2.575 | +3.855 | 5 | 5 | 8.2 | 0 | 0.3 | 1280 | 471-D-C343 | 1280 | 0.348511 | 0.00101859 | 7.99597
6 x H/RAIL POST | +8.429 | +9.709 | 5 | 5 | 8.2 | 0 | 0.3 | 1280 | 471-D-C342 | 1280 | 0.348511 | 0.00101859 | 7.99593
6 x H/RAIL POST | +8.429 | +9.709 | 5 | 5 | 8.2 | 0 | 0.3 | 1280 | 471-D-C343 | 1280 | 0.348511 | 0.00101859 | 7.99593
5 x H/RAIL POST | +3.075 | +4.355 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C343 | 1280 | 0.348511 | 0.00101859 | 7.99593
5 x H/RAIL POST | +3.075 | +4.355 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C342 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +11.025 | +12.306 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C343 | 1280 | 0.348511 | 0.00101859 | 7.99593
2 x H/RAIL POST | +11.025 | +12.306 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C342 | 1280 | 0.348511 | 0.00101859 | 7.99593
3 x H/RAIL POST | +11.025 | +12.305 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C343 | 1280 | 0.348511 | 0.00101859 | 7.99593
3 x H/RAIL POST | +11.025 | +12.305 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C342 | 1280 | 0.348511 | 0.00101859 | 7.99593
3 x H/RAIL POST | +5.325 | +6.605 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C343 | 1280 | 0.348511 | 0.00101859 | 7.99593
5 x H/RAIL POST | +5.325 | +6.605 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C342 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +5.325 | +6.605 | 5 | 5 | 8.2 | 0 | 0.3 | 1280 | 471-D-C343 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +12.325 | +13.605 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C342 | 1280 | 0.348511 | 0.00101856 | 7.99568
3 x H/RAIL POST | +10.415 | +11.695 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C342 | 1280 | 0.348511 | 0.00101859 | 7.99593
3 x H/RAIL POST | +10.415 | +11.695 | 5 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-D-C343 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +11.619 | +12.680 | 5 | 14 | 6.8 | 0 | 0.3 | 1060.9 | mc-315 | 1060.9 | 0.288855 | 0.000798799 | 6.27057
H/RAIL POST | +11.619 | +12.680 | 5 | 14 | 6.8 | 0 | 0.3 | 1060.9 | mc-314 | 1060.9 | 0.288855 | 0.000798801 | 6.27059
H/RAIL POST | +12.352 | +13.412 | 5 | 14 | 6.8 | 0 | 0.3 | 1060.9 | mc-315 | 1060.9 | 0.288855 | 0.000798799 | 6.27057
H/RAIL POST | +12.352 | +13.412 | 5 | 14 | 6.8 | 0 | 0.3 | 1060.9 | mc-314 | 1060.9 | 0.288855 | 0.000798801 | 6.27059
H/RAIL POST | +10.886 | +11.947 | 5 | 14 | 6.8 | 0 | 0.3 | 1060.9 | mc-315 | 1060.9 | 0.288855 | 0.000798799 | 6.27057
H/RAIL POST | +10.886 | +11.947 | 5 | 14 | 6.8 | 0 | 0.3 | 1060.9 | mc-314 | 1060.9 | 0.288855 | 0.000798801 | 6.27059
H/RAIL POST | +14.110 | +15.205 | 5 | 14 | 7 | 0 | 0.3 | 1095 | mc-313 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +14.110 | +15.205 | 5 | 14 | 7 | 0 | 0.3 | 1095 | mc-312 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +14.471 | +15.534 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +14.471 | +15.534 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +15.543 | +16.606 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +15.543 | +16.606 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +13.943 | +15.006 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +13.943 | +15.006 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +12.799 | +13.862 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +12.799 | +13.862 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +12.510 | +13.605 | 5 | 14 | 7 | 0 | 0.3 | 1095 | mc-313 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +10.110 | +11.205 | 5 | 14 | 7 | 0 | 0.3 | 1095 | mc-313 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +10.110 | +11.205 | 5 | 14 | 7 | 0 | 0.3 | 1095 | mc-312 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +7.910 | +9.005 | 5 | 14 | 7 | 0 | 0.3 | 1095 | mc-313 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +7.910 | +9.005 | 5 | 14 | 7 | 0 | 0.3 | 1095 | mc-312 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +5.710 | +6.805 | 5 | 14 | 7 | 0 | 0.3 | 1095 | mc-313 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +2.710 | +3.805 | 5 | 14 | 7 | 0 | 0.3 | 1095 | mc-313 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +2.710 | +3.805 | 5 | 14 | 7 | 0 | 0.3 | 1095 | mc-312 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +4.306 | +5.370 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +4.306 | +5.370 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +6.907 | +7.970 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +6.907 | +7.970 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +9.107 | +10.170 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +9.107 | +10.170 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +11.407 | +12.470 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +11.407 | +12.470 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +10.471 | +11.534 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +10.471 | +11.534 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +8.271 | +9.334 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +8.271 | +9.334 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +6.071 | +7.134 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +6.071 | +7.134 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +3.071 | +4.134 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +3.071 | +4.134 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +12.343 | +13.406 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +12.343 | +13.406 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +9.943 | +11.006 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +9.943 | +11.006 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +7.743 | +8.806 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +7.743 | +8.806 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +5.543 | +6.606 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +5.543 | +6.606 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +1.694 | +2.758 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +1.694 | +2.758 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +0.847 | +1.910 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +0.847 | +1.910 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +2.543 | +3.606 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +2.543 | +3.606 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | -0.001 | +1.062 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-311 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | -0.001 | +1.062 | 5 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mc-310 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
3 x H/RAIL POST | +24.143 | +25.423 | 4 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-C-B203 | 1280 | 0.348511 | 0.00101859 | 7.99593
3 x H/RAIL POST | +24.143 | +25.423 | 4 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-C-B204 | 1280 | 0.348511 | 0.00101859 | 7.99593
16 x H/RAIL POST | +21.285 | +22.565 | 4 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-C-B203 | 1280 | 0.348511 | 0.00101859 | 7.99593
10 x H/RAIL POST | +21.285 | +22.565 | 4 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-C-B204 | 1280 | 0.348511 | 0.00101859 | 7.99593
22 x H/RAIL POST | +17.875 | +19.155 | 4 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-C-B203 | 1280 | 0.348511 | 0.00101859 | 7.99593
22 x H/RAIL POST | +17.875 | +19.155 | 4 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-C-B204 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +21.285 | +22.590 | 4 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-C-B201 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +21.285 | +22.590 | 4 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-C-B202 | 1305 | 0.355318 | 0.00103962 | 8.16102
H/RAIL POST | +17.875 | +19.180 | 4 | 14 | 8.2 | 0 | 0.3 | 1305 | 471-C-B201 | 1305 | 0.355318 | 0.00103962 | 8.16102
9 x H/RAIL POST | +15.525 | +16.805 | 4 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-C-B203 | 1280 | 0.348511 | 0.00101859 | 7.99593
15 x H/RAIL POST | +15.525 | +16.805 | 4 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-C-B204 | 1280 | 0.348511 | 0.00101859 | 7.99593
2 x H/RAIL POST | +15.525 | +16.805 | 4 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-C-B203 | 1280 | 0.348511 | 0.00101859 | 7.99589
FLOOR BRACE | +24.138 | +24.208 | 4 | 6 | 15.6 | 0.2 | 0.6 | 2448.1 | 471-C-B200 | 2448.14 | 0.666565 | 0.0019683 | 15.4512
FLOOR BRACE | +21.280 | +21.350 | 4 | 6 | 15.8 | 0.2 | 0.6 | 2477 | 471-C-B199 | 2476.99 | 0.67442 | 0.0019915 | 15.6333
H/RAIL POST | +19.765 | +20.860 | 4 | 14 | 7 | 0 | 0.3 | 1095 | mb-153 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +19.765 | +20.860 | 4 | 14 | 7 | 0 | 0.3 | 1095 | mb-152 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +19.580 | +20.860 | 4 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-C-B204 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +19.580 | +20.860 | 4 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-C-B203 | 1280 | 0.348511 | 0.00101859 | 7.99593
FLOOR BRACE | +19.575 | +19.645 | 4 | 6 | 12.9 | 0.1 | 0.6 | 2006.3 | 471-C-B196 | 2006.28 | 0.546257 | 0.00161305 | 12.6624
FLOOR BRACE | +17.870 | +17.940 | 4 | 6 | 15.8 | 0.2 | 0.6 | 2477 | 471-C-B199 | 2476.99 | 0.67442 | 0.0019915 | 15.6333
FLOOR BRACE | +15.520 | +15.590 | 4 | 6 | 15.5 | 0.2 | 0.6 | 2422.3 | 471-C-B198 | 2422.28 | 0.659525 | 0.00194751 | 15.288
FLOOR BRACE | +15.520 | +15.590 | 4 | 6 | 16.4 | 0.2 | 0.6 | 2563.7 | 471-C-B197 | 2563.72 | 0.698036 | 0.00206123 | 16.1807
H/RAIL POST | +13.155 | +14.250 | 4 | 14 | 7 | 0 | 0.3 | 1095 | mb-153 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +13.155 | +14.250 | 4 | 14 | 7 | 0 | 0.3 | 1095 | mb-152 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +12.970 | +14.250 | 4 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-C-B204 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +12.970 | +14.250 | 4 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-C-B203 | 1280 | 0.348511 | 0.00101859 | 7.99593
FLOOR BRACE | +12.965 | +13.035 | 4 | 6 | 12.9 | 0.1 | 0.6 | 2006.3 | 471-C-B196 | 2006.28 | 0.546257 | 0.00161305 | 12.6624
H/RAIL POST | +69.657 | +70.720 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-239 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +69.657 | +70.720 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-240 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +67.457 | +68.520 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-240 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +67.457 | +68.520 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-239 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +64.957 | +66.020 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-239 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +64.957 | +66.020 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-240 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +62.197 | +63.259 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-238 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +62.197 | +63.259 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-237 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +59.482 | +60.544 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-237 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +59.482 | +60.544 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-238 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +56.767 | +57.829 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-238 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +56.767 | +57.829 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-237 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +54.275 | +55.336 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-235 | 1060.32 | 0.288698 | 0.000798852 | 6.27099
H/RAIL POST | +54.275 | +55.336 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-236 | 1060.32 | 0.288698 | 0.000798852 | 6.27099
H/RAIL POST | +52.199 | +53.260 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-236 | 1060.31 | 0.288694 | 0.000798854 | 6.271
H/RAIL POST | +52.199 | +53.260 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-235 | 1060.31 | 0.288694 | 0.000798854 | 6.271
H/RAIL POST | +50.031 | +51.092 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-235 | 1060.31 | 0.288694 | 0.000798854 | 6.271
H/RAIL POST | +50.031 | +51.092 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-236 | 1060.31 | 0.288694 | 0.000798854 | 6.271
H/RAIL POST | +45.896 | +46.956 | 7 | 14 | 6.8 | 0 | 0.3 | 1060 | me-153 | 1060.01 | 0.288613 | 0.00079888 | 6.27121
H/RAIL POST | +45.896 | +46.956 | 7 | 14 | 6.8 | 0 | 0.3 | 1060 | me-154 | 1060.01 | 0.288613 | 0.00079888 | 6.27121
H/RAIL POST | +43.296 | +44.359 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-152 | 1062.63 | 0.289327 | 0.000798644 | 6.26936
H/RAIL POST | +43.296 | +44.359 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-151 | 1062.63 | 0.289327 | 0.000798644 | 6.26936
H/RAIL POST | +40.528 | +41.591 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-151 | 1062.61 | 0.289322 | 0.000798646 | 6.26937
H/RAIL POST | +40.528 | +41.591 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-152 | 1062.61 | 0.289322 | 0.000798646 | 6.26937
H/RAIL POST | +37.760 | +38.822 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-152 | 1062.61 | 0.289322 | 0.000798646 | 6.26937
H/RAIL POST | +37.760 | +38.822 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-151 | 1062.61 | 0.289322 | 0.000798646 | 6.26937
H/RAIL POST | +35.238 | +36.298 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-119 | 1060.45 | 0.288733 | 0.000798841 | 6.2709
H/RAIL POST | +35.238 | +36.298 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-120 | 1060.45 | 0.288733 | 0.000798841 | 6.2709
H/RAIL POST | +34.352 | +35.412 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-119 | 1060.45 | 0.288733 | 0.000798841 | 6.2709
H/RAIL POST | +34.352 | +35.412 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-120 | 1060.45 | 0.288733 | 0.000798841 | 6.2709
H/RAIL POST | +32.967 | +34.027 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-120 | 1060.45 | 0.288733 | 0.000798841 | 6.2709
H/RAIL POST | +32.967 | +34.027 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-119 | 1060.45 | 0.288733 | 0.000798841 | 6.2709
H/RAIL POST | +27.851 | +28.912 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.7 | md-120 | 1060.73 | 0.28881 | 0.000798816 | 6.2707
H/RAIL POST | +27.851 | +28.912 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.7 | md-119 | 1060.73 | 0.28881 | 0.000798816 | 6.2707
H/RAIL POST | +25.470 | +26.531 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.7 | md-119 | 1060.8 | 0.288829 | 0.000798809 | 6.27065
H/RAIL POST | +25.470 | +26.531 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.7 | md-120 | 1060.8 | 0.288829 | 0.000798809 | 6.27065
H/RAIL POST | +22.992 | +24.053 | 4 | 14 | 6.8 | 0 | 0.3 | 1060.7 | mb-151 | 1060.78 | 0.288822 | 0.000798812 | 6.27067
H/RAIL POST | +22.992 | +24.053 | 4 | 14 | 6.8 | 0 | 0.3 | 1060.7 | mb-150 | 1060.78 | 0.288822 | 0.000798812 | 6.27067
H/RAIL POST | +16.980 | +18.042 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.1 | mb-149 | 1062.13 | 0.289191 | 0.00079869 | 6.26971
H/RAIL POST | +16.980 | +18.042 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.1 | mb-148 | 1062.13 | 0.289191 | 0.00079869 | 6.26971
H/RAIL POST | +14.528 | +15.591 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.3 | mb-148 | 1062.31 | 0.28924 | 0.000798673 | 6.26959
H/RAIL POST | +14.528 | +15.591 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.3 | mb-149 | 1062.31 | 0.28924 | 0.000798673 | 6.26959
H/RAIL POST | +11.973 | +13.035 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.3 | mb-149 | 1062.31 | 0.28924 | 0.000798673 | 6.26959
H/RAIL POST | +11.973 | +13.035 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.3 | mb-148 | 1062.31 | 0.28924 | 0.000798673 | 6.26959
H/RAIL POST | +10.955 | +12.017 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.3 | mb-149 | 1062.31 | 0.28924 | 0.000798673 | 6.26959
H/RAIL POST | +10.955 | +12.017 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.3 | mb-148 | 1062.31 | 0.28924 | 0.000798673 | 6.26959
H/RAIL POST | +13.510 | +14.572 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.3 | mb-148 | 1062.31 | 0.28924 | 0.000798673 | 6.26959
H/RAIL POST | +13.510 | +14.572 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.3 | mb-149 | 1062.31 | 0.28924 | 0.000798673 | 6.26959
H/RAIL POST | +16.064 | +17.126 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.1 | mb-149 | 1062.13 | 0.289191 | 0.00079869 | 6.26971
H/RAIL POST | +16.064 | +17.126 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.1 | mb-148 | 1062.13 | 0.289191 | 0.00079869 | 6.26971
H/RAIL POST | +18.403 | +19.464 | 4 | 14 | 6.8 | 0 | 0.3 | 1060.4 | mb-151 | 1060.5 | 0.288746 | 0.000798837 | 6.27087
H/RAIL POST | +18.403 | +19.464 | 4 | 14 | 6.8 | 0 | 0.3 | 1060.4 | mb-150 | 1060.5 | 0.288746 | 0.000798837 | 6.27087
H/RAIL POST | +21.815 | +22.876 | 4 | 14 | 6.8 | 0 | 0.3 | 1060.7 | mb-151 | 1060.78 | 0.288822 | 0.000798812 | 6.27067
H/RAIL POST | +21.815 | +22.876 | 4 | 14 | 6.8 | 0 | 0.3 | 1060.7 | mb-150 | 1060.78 | 0.288822 | 0.000798812 | 6.27067
H/RAIL POST | +24.673 | +25.734 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.7 | md-119 | 1060.8 | 0.288829 | 0.000798809 | 6.27065
H/RAIL POST | +24.673 | +25.734 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.7 | md-120 | 1060.8 | 0.288829 | 0.000798809 | 6.27065
H/RAIL POST | +26.770 | +27.830 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.7 | md-120 | 1060.73 | 0.28881 | 0.000798816 | 6.2707
H/RAIL POST | +26.770 | +27.830 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.7 | md-119 | 1060.73 | 0.28881 | 0.000798816 | 6.2707
H/RAIL POST | +32.081 | +33.141 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-120 | 1060.45 | 0.288733 | 0.000798841 | 6.2709
H/RAIL POST | +32.081 | +33.141 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-119 | 1060.45 | 0.288733 | 0.000798841 | 6.2709
H/RAIL POST | +36.636 | +37.699 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-152 | 1062.61 | 0.289322 | 0.000798646 | 6.26937
H/RAIL POST | +36.636 | +37.699 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-151 | 1062.61 | 0.289322 | 0.000798646 | 6.26937
H/RAIL POST | +39.406 | +40.468 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-151 | 1062.61 | 0.289322 | 0.000798646 | 6.26937
H/RAIL POST | +39.406 | +40.468 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-152 | 1062.61 | 0.289322 | 0.000798646 | 6.26937
H/RAIL POST | +42.172 | +43.235 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-152 | 1062.63 | 0.289327 | 0.000798644 | 6.26936
H/RAIL POST | +42.172 | +43.235 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-151 | 1062.63 | 0.289327 | 0.000798644 | 6.26936
H/RAIL POST | +44.925 | +45.985 | 7 | 14 | 6.8 | 0 | 0.3 | 1060 | me-153 | 1060.01 | 0.288613 | 0.00079888 | 6.27121
H/RAIL POST | +44.925 | +45.985 | 7 | 14 | 6.8 | 0 | 0.3 | 1060 | me-154 | 1060.01 | 0.288613 | 0.00079888 | 6.27121
H/RAIL POST | +47.363 | +48.423 | 7 | 14 | 6.8 | 0 | 0.3 | 1060 | me-154 | 1059.99 | 0.288607 | 0.000798882 | 6.27122
H/RAIL POST | +47.363 | +48.423 | 7 | 14 | 6.8 | 0 | 0.3 | 1060 | me-153 | 1059.99 | 0.288607 | 0.000798882 | 6.27122
H/RAIL POST | +49.052 | +50.112 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-235 | 1060.31 | 0.288694 | 0.000798854 | 6.271
H/RAIL POST | +49.052 | +50.112 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-236 | 1060.31 | 0.288694 | 0.000798854 | 6.271
H/RAIL POST | +51.505 | +52.565 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-236 | 1060.31 | 0.288694 | 0.000798854 | 6.271
H/RAIL POST | +51.505 | +52.565 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-235 | 1060.31 | 0.288694 | 0.000798854 | 6.271
H/RAIL POST | +53.392 | +54.452 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-235 | 1060.32 | 0.288698 | 0.000798852 | 6.27099
H/RAIL POST | +53.392 | +54.452 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-236 | 1060.32 | 0.288698 | 0.000798852 | 6.27099
H/RAIL POST | +55.667 | +56.729 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-238 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +55.667 | +56.729 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-237 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +58.381 | +59.442 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-237 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +58.381 | +59.442 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-238 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +61.097 | +62.159 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-238 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +61.097 | +62.159 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-237 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +63.821 | +64.884 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-239 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +63.821 | +64.884 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-240 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +66.621 | +67.684 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-240 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +66.621 | +67.684 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-239 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +68.821 | +69.884 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-239 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +68.821 | +69.884 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-240 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +30.507 | +31.567 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-119 | 1060.42 | 0.288725 | 0.000798843 | 6.27092
H/RAIL POST | +30.507 | +31.567 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-120 | 1060.42 | 0.288725 | 0.000798843 | 6.27092
H/RAIL POST | +29.433 | +30.493 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-119 | 1060.42 | 0.288725 | 0.000798843 | 6.27092
H/RAIL POST | +29.433 | +30.493 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-120 | 1060.42 | 0.288725 | 0.000798843 | 6.27092
H/RAIL POST | +20.108 | +21.169 | 4 | 14 | 6.8 | 0 | 0.3 | 1060.4 | mb-150 | 1060.5 | 0.288746 | 0.000798837 | 6.27087
H/RAIL POST | +20.108 | +21.169 | 4 | 14 | 6.8 | 0 | 0.3 | 1060.4 | mb-151 | 1060.5 | 0.288746 | 0.000798837 | 6.27087
H/RAIL POST | +70.493 | +71.556 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-239 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +70.493 | +71.556 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-240 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +66.093 | +67.156 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-239 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +66.093 | +67.156 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-240 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +60.584 | +61.645 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-237 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +60.584 | +61.645 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-238 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +55.159 | +56.219 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-235 | 1060.32 | 0.288698 | 0.000798852 | 6.27099
H/RAIL POST | +55.159 | +56.219 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-236 | 1060.32 | 0.288698 | 0.000798852 | 6.27099
H/RAIL POST | +51.007 | +52.067 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-235 | 1060.31 | 0.288694 | 0.000798854 | 6.271
H/RAIL POST | +51.007 | +52.067 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-236 | 1060.31 | 0.288694 | 0.000798854 | 6.271
H/RAIL POST | +46.868 | +47.928 | 7 | 14 | 6.8 | 0 | 0.3 | 1060 | me-153 | 1060.01 | 0.288613 | 0.00079888 | 6.27121
H/RAIL POST | +46.868 | +47.928 | 7 | 14 | 6.8 | 0 | 0.3 | 1060 | me-154 | 1060.01 | 0.288613 | 0.00079888 | 6.27121
H/RAIL POST | +41.651 | +42.714 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-151 | 1062.61 | 0.289322 | 0.000798646 | 6.26937
H/RAIL POST | +41.651 | +42.714 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-152 | 1062.61 | 0.289322 | 0.000798646 | 6.26937
H/RAIL POST | +36.123 | +37.184 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-119 | 1060.45 | 0.288733 | 0.000798841 | 6.2709
H/RAIL POST | +36.123 | +37.184 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-120 | 1060.45 | 0.288733 | 0.000798841 | 6.2709
H/RAIL POST | +31.581 | +32.642 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-119 | 1060.42 | 0.288725 | 0.000798843 | 6.27092
H/RAIL POST | +31.581 | +32.642 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-120 | 1060.42 | 0.288725 | 0.000798843 | 6.27092
H/RAIL POST | +26.267 | +27.328 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.7 | md-119 | 1060.8 | 0.288829 | 0.000798809 | 6.27065
H/RAIL POST | +26.267 | +27.328 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.7 | md-120 | 1060.8 | 0.288829 | 0.000798809 | 6.27065
H/RAIL POST | +21.313 | +22.374 | 4 | 14 | 6.8 | 0 | 0.3 | 1060.4 | mb-150 | 1060.5 | 0.288746 | 0.000798837 | 6.27087
H/RAIL POST | +21.313 | +22.374 | 4 | 14 | 6.8 | 0 | 0.3 | 1060.4 | mb-151 | 1060.5 | 0.288746 | 0.000798837 | 6.27087
H/RAIL POST | +68.293 | +69.356 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-240 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +68.293 | +69.356 | 8 | 14 | 6.8 | 0 | 0.3 | 1063.2 | mf-239 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +63.299 | +64.360 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-238 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +63.299 | +64.360 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-237 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +57.869 | +58.930 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-238 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +57.869 | +58.930 | 8 | 14 | 6.8 | 0 | 0.3 | 1061.6 | mf-237 | 1061.64 | 0.289058 | 0.000798734 | 6.27006
H/RAIL POST | +52.894 | +53.954 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-236 | 1060.31 | 0.288694 | 0.000798854 | 6.271
H/RAIL POST | +52.894 | +53.954 | 8 | 14 | 6.8 | 0 | 0.3 | 1060.3 | mf-235 | 1060.31 | 0.288694 | 0.000798854 | 6.271
H/RAIL POST | +48.555 | +49.615 | 7 | 14 | 6.8 | 0 | 0.3 | 1060 | me-154 | 1059.99 | 0.288607 | 0.000798882 | 6.27122
H/RAIL POST | +48.555 | +49.615 | 7 | 14 | 6.8 | 0 | 0.3 | 1060 | me-153 | 1059.99 | 0.288607 | 0.000798882 | 6.27122
H/RAIL POST | +44.420 | +45.483 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-152 | 1062.63 | 0.289327 | 0.000798644 | 6.26936
H/RAIL POST | +44.420 | +45.483 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-151 | 1062.63 | 0.289327 | 0.000798644 | 6.26936
H/RAIL POST | +38.883 | +39.946 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-152 | 1062.61 | 0.289322 | 0.000798646 | 6.26937
H/RAIL POST | +38.883 | +39.946 | 7 | 14 | 6.8 | 0 | 0.3 | 1062.6 | me-151 | 1062.61 | 0.289322 | 0.000798646 | 6.26937
H/RAIL POST | +33.852 | +34.913 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-120 | 1060.45 | 0.288733 | 0.000798841 | 6.2709
H/RAIL POST | +33.852 | +34.913 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.4 | md-119 | 1060.45 | 0.288733 | 0.000798841 | 6.2709
H/RAIL POST | +28.932 | +29.993 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.7 | md-120 | 1060.73 | 0.28881 | 0.000798816 | 6.2707
H/RAIL POST | +28.932 | +29.993 | 6 | 14 | 6.8 | 0 | 0.3 | 1060.7 | md-119 | 1060.73 | 0.28881 | 0.000798816 | 6.2707
H/RAIL POST | +24.170 | +25.231 | 4 | 14 | 6.8 | 0 | 0.3 | 1060.7 | mb-151 | 1060.78 | 0.288822 | 0.000798812 | 6.27067
H/RAIL POST | +24.170 | +25.231 | 4 | 14 | 6.8 | 0 | 0.3 | 1060.7 | mb-150 | 1060.78 | 0.288822 | 0.000798812 | 6.27067
H/RAIL POST | +19.608 | +20.669 | 4 | 14 | 6.8 | 0 | 0.3 | 1060.4 | mb-151 | 1060.5 | 0.288746 | 0.000798837 | 6.27087
H/RAIL POST | +19.608 | +20.669 | 4 | 14 | 6.8 | 0 | 0.3 | 1060.4 | mb-150 | 1060.5 | 0.288746 | 0.000798837 | 6.27087
H/RAIL POST | +15.546 | +16.608 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.3 | mb-148 | 1062.31 | 0.28924 | 0.000798673 | 6.26959
H/RAIL POST | +15.546 | +16.608 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.3 | mb-149 | 1062.31 | 0.28924 | 0.000798673 | 6.26959
H/RAIL POST | +17.897 | +18.959 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.1 | mb-149 | 1062.13 | 0.289191 | 0.00079869 | 6.26971
H/RAIL POST | +17.897 | +18.959 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.1 | mb-148 | 1062.13 | 0.289191 | 0.00079869 | 6.26971
9 x H/RAIL POST | +10.415 | +11.695 | 3 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-B-A178 | 1280 | 0.348511 | 0.00101859 | 7.99593
24 x H/RAIL POST | +10.415 | +11.695 | 3 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-B-A177 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +8.155 | +9.250 | 3 | 14 | 7 | 0 | 0.3 | 1095 | ma-153 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +8.155 | +9.250 | 3 | 14 | 7 | 0 | 0.3 | 1095 | ma-152 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +7.970 | +9.250 | 3 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-B-A177 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +7.970 | +9.250 | 3 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-B-A178 | 1280 | 0.348511 | 0.00101859 | 7.99593
3 x H/RAIL POST | +2.525 | +3.805 | 3 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-B-A177 | 1280 | 0.348511 | 0.00101859 | 7.99593
4 x H/RAIL POST | +10.415 | +11.695 | 3 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-B-A178 | 1280 | 0.348511 | 0.00101859 | 7.99589
2 x H/RAIL POST | +2.525 | +3.805 | 3 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-B-A178 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +8.497 | +9.557 | 3 | 14 | 6.8 | 0 | 0.3 | 1060.1 | ma-149 | 1060.14 | 0.28865 | 0.000798864 | 6.27108
H/RAIL POST | +8.497 | +9.557 | 3 | 14 | 6.8 | 0 | 0.3 | 1060.1 | ma-148 | 1060.14 | 0.28865 | 0.000798864 | 6.27108
H/RAIL POST | +9.471 | +10.531 | 3 | 14 | 6.8 | 0 | 0.3 | 1060.1 | ma-149 | 1060.15 | 0.28865 | 0.000798866 | 6.2711
H/RAIL POST | +9.471 | +10.531 | 3 | 14 | 6.8 | 0 | 0.3 | 1060.1 | ma-148 | 1060.15 | 0.28865 | 0.000798866 | 6.2711
H/RAIL POST | +6.051 | +7.111 | 3 | 14 | 6.8 | 0 | 0.3 | 1060.1 | ma-148 | 1060.14 | 0.28865 | 0.000798864 | 6.27108
H/RAIL POST | +6.051 | +7.111 | 3 | 14 | 6.8 | 0 | 0.3 | 1060.1 | ma-149 | 1060.14 | 0.28865 | 0.000798864 | 6.27108
H/RAIL POST | +7.025 | +8.085 | 3 | 14 | 6.8 | 0 | 0.3 | 1060.1 | ma-148 | 1060.15 | 0.28865 | 0.000798866 | 6.2711
H/RAIL POST | +7.025 | +8.085 | 3 | 14 | 6.8 | 0 | 0.3 | 1060.1 | ma-149 | 1060.15 | 0.28865 | 0.000798866 | 6.2711
H/RAIL POST | +3.069 | +4.132 | 3 | 14 | 6.8 | 0 | 0.3 | 1063.5 | ma-150 | 1063.48 | 0.289558 | 0.00079873 | 6.27003
H/RAIL POST | +3.069 | +4.132 | 3 | 14 | 6.8 | 0 | 0.3 | 1063.5 | ma-151 | 1063.48 | 0.289558 | 0.000798821 | 6.27075
H/RAIL POST | +4.306 | +5.369 | 3 | 14 | 6.8 | 0 | 0.3 | 1063.5 | ma-150 | 1063.48 | 0.289559 | 0.000798733 | 6.27006
H/RAIL POST | +4.306 | +5.369 | 3 | 14 | 6.8 | 0 | 0.3 | 1063.5 | ma-151 | 1063.48 | 0.289559 | 0.000798824 | 6.27077
H/RAIL POST | +1.371 | +2.434 | 3 | 14 | 6.8 | 0 | 0.3 | 1063.2 | ma-151 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +1.371 | +2.434 | 3 | 14 | 6.8 | 0 | 0.3 | 1063.2 | ma-150 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +2.543 | +3.606 | 3 | 14 | 6.8 | 0 | 0.3 | 1063.2 | ma-151 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +2.543 | +3.606 | 3 | 14 | 6.8 | 0 | 0.3 | 1063.2 | ma-150 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +5.543 | +6.606 | 3 | 14 | 6.8 | 0 | 0.3 | 1063.5 | ma-150 | 1063.49 | 0.28956 | 0.000798736 | 6.27008
H/RAIL POST | +5.543 | +6.606 | 3 | 14 | 6.8 | 0 | 0.3 | 1063.5 | ma-151 | 1063.49 | 0.28956 | 0.000798828 | 6.2708
H/RAIL POST | +0.199 | +1.262 | 3 | 14 | 6.8 | 0 | 0.3 | 1063.2 | ma-151 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +0.199 | +1.262 | 3 | 14 | 6.8 | 0 | 0.3 | 1063.2 | ma-150 | 1063.19 | 0.28948 | 0.000798592 | 6.26895
H/RAIL POST | +7.999 | +9.059 | 3 | 14 | 6.8 | 0 | 0.3 | 1060.1 | ma-148 | 1060.15 | 0.288651 | 0.000798868 | 6.27111
H/RAIL POST | +7.999 | +9.059 | 3 | 14 | 6.8 | 0 | 0.3 | 1060.1 | ma-149 | 1060.15 | 0.288651 | 0.000798868 | 6.27111
H/RAIL POST | +12.991 | +14.053 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.3 | mb-149 | 1062.31 | 0.28924 | 0.000798673 | 6.26959
H/RAIL POST | +12.991 | +14.053 | 4 | 14 | 6.8 | 0 | 0.3 | 1062.3 | mb-148 | 1062.31 | 0.28924 | 0.000798673 | 6.26959
H/RAIL POST | +10.444 | +11.505 | 3 | 14 | 6.8 | 0 | 0.3 | 1060.1 | ma-149 | 1060.15 | 0.288651 | 0.000798868 | 6.27111
H/RAIL POST | +10.444 | +11.505 | 3 | 14 | 6.8 | 0 | 0.3 | 1060.1 | ma-148 | 1060.15 | 0.288651 | 0.000798868 | 6.27111
FLOOR BRACE | +7.965 | +8.035 | 3 | 6 | 12.9 | 0.1 | 0.6 | 2006.3 | 471-B-A170 | 2006.28 | 0.546258 | 0.00161305 | 12.6624
FLOOR BRACE | +2.520 | +2.590 | 3 | 6 | 13.5 | 0.1 | 0.6 | 2110.3 | 471-B-A169 | 2110.33 | 0.574588 | 0.0016967 | 13.3191
FLOOR BRACE | +63.270 | +63.340 | 8 | 6 | 15.6 | 0.2 | 0.6 | 2462.1 | 471-G-F289 | 2462.12 | 0.670372 | 0.00197954 | 15.5394
FLOOR BRACE | +63.270 | +63.340 | 8 | 6 | 16.4 | 0.2 | 0.6 | 2581.4 | 471-G-F288 | 2581.42 | 0.702855 | 0.00207546 | 16.2924
FLOOR BRACE | +36.090 | +36.160 | 6 | 6 | 17 | 0.2 | 0.6 | 2665.9 | 471-E-D142 | 2665.76 | 0.725818 | 0.00214327 | 16.8247
FLOOR BRACE | +36.090 | +36.160 | 6 | 6 | 16.2 | 0.2 | 0.6 | 2531.6 | 471-E-D141 | 2531.56 | 0.689278 | 0.00203537 | 15.9777
FLOOR BRACE | +10.410 | +10.480 | 3 | 6 | 15.5 | 0.2 | 0.6 | 2422.3 | 471-B-A168 | 2422.28 | 0.659525 | 0.00194751 | 15.288
FLOOR BRACE | +10.410 | +10.480 | 3 | 6 | 16.4 | 0.2 | 0.6 | 2563.7 | 471-B-A167 | 2563.72 | 0.698036 | 0.00206123 | 16.1807
FLOOR BRACE | +5.520 | +5.590 | 3 | 6 | 15.6 | 0.2 | 0.6 | 2453 | 471-B-A166 | 2452.98 | 0.667883 | 0.0019722 | 15.4817
FLOOR BRACE | +5.520 | +5.590 | 3 | 6 | 16.4 | 0.2 | 0.6 | 2578.2 | 471-B-A165 | 2578.2 | 0.701978 | 0.00207287 | 16.2721
7 x H/RAIL POST | +10.415 | +11.695 | 3 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-B-A177 | 1280 | 0.348511 | 0.00101859 | 7.99589
21 x H/RAIL POST | +5.525 | +6.805 | 3 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-B-A177 | 1280 | 0.348511 | 0.00101859 | 7.99593
6 x H/RAIL POST | +5.525 | +6.805 | 3 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-B-A178 | 1280 | 0.348511 | 0.00101859 | 7.99593
2 x H/RAIL POST | +5.525 | +6.805 | 3 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-B-A178 | 1280 | 0.348511 | 0.00101859 | 7.99589
H/RAIL POST | +5.325 | +6.605 | 5 | 5 | 8.2 | 0 | 0.3 | 1280 | 471-D-C342 | 1280 | 0.348511 | 0.00101859 | 7.99593

# IfcBeam: L80*80*8 (469)
In: Undefined
Description: L80*80*8; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 32.3 m2; Height: 80 mm; Width: 80 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 9.1 | 0.1 | 0.3 | 941.9 | 471-G-F285 | 941.899 | 0.293322 | 0.00114535 | 8.991
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 7.8 | 0.1 | 0.3 | 804.9 | 471-G-F284 | 804.883 | 0.250653 | 0.000978738 | 7.6831
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 7.7 | 0.1 | 0.3 | 801.5 | 471-G-F283 | 801.534 | 0.24961 | 0.000974665 | 7.65112
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 9.3 | 0.1 | 0.3 | 957.9 | 471-G-F282 | 957.926 | 0.298313 | 0.00116484 | 9.14397
2 x FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 14.4 | 0.1 | 0.5 | 1499.3 | 471-G-F270 | 1499.32 | 0.466911 | 0.00182317 | 14.3119
FLOOR BRACE | +63.263 | +63.343 | 8 | 6 | 9.3 | 0.1 | 0.3 | 965.7 | 471-G-F281 | 965.673 | 0.300726 | 0.00117426 | 9.21793
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 14.9 | 0.1 | 0.5 | 1545.6 | 471-F-E188 | 1545.59 | 0.48132 | 0.00187943 | 14.7536
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 15.3 | 0.1 | 0.5 | 1594 | 471-F-E187 | 1593.96 | 0.496383 | 0.00193825 | 15.2153
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 12.1 | 0.1 | 0.3 | 1259.7 | 471-F-E186 | 1259.71 | 0.392293 | 0.0015318 | 12.0247
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 14.9 | 0.1 | 0.5 | 1540.4 | 471-F-E185 | 1540.39 | 0.479701 | 0.00187311 | 14.7039
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 11.3 | 0.1 | 0.3 | 1168.4 | 471-F-E184 | 1168.36 | 0.363845 | 0.00142072 | 11.1527
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 14.4 | 0.1 | 0.5 | 1480.8 | 471-F-E183 | 1480.84 | 0.461159 | 0.00180071 | 14.1356
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 12.1 | 0.1 | 0.3 | 1262.5 | 471-F-E170 | 1262.48 | 0.393158 | 0.00153518 | 12.0512
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 11.9 | 0.1 | 0.3 | 1231.4 | 471-F-E182 | 1231.41 | 0.383482 | 0.0014974 | 11.7546
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 14.9 | 0.1 | 0.5 | 1542.2 | 471-F-E181 | 1542.23 | 0.480276 | 0.00187536 | 14.7216
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 11.9 | 0.1 | 0.3 | 1234.7 | 471-F-E180 | 1234.65 | 0.38449 | 0.00150134 | 11.7855
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 9.1 | 0.1 | 0.3 | 945.4 | 471-F-E179 | 945.362 | 0.294401 | 0.00114956 | 9.02404
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 9.7 | 0.1 | 0.3 | 1006 | 471-F-E178 | 1006.01 | 0.313288 | 0.00122331 | 9.60299
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 9.5 | 0.1 | 0.3 | 991.6 | 471-F-E177 | 991.636 | 0.308811 | 0.00120583 | 9.46576
FLOOR BRACE | +48.513 | +48.593 | 7 | 6 | 12.6 | 0.1 | 0.3 | 1303.9 | 471-F-E176 | 1303.9 | 0.406055 | 0.00158554 | 12.4465
2 x FLOOR BRACE | +15.513 | +15.593 | 5 | 6 | 14.9 | 0.1 | 0.5 | 1537.3 | 471-D-C332 | 1537.3 | 0.47874 | 0.00186936 | 14.6745
2 x FLOOR BRACE | +15.513 | +15.593 | 5 | 6 | 14 | 0.1 | 0.5 | 1449.2 | 471-D-C331 | 1449.22 | 0.451309 | 0.00176225 | 13.8336
2 x FLOOR BRACE | +15.513 | +15.593 | 5 | 6 | 13.5 | 0.1 | 0.5 | 1407 | 471-D-C330 | 1406.99 | 0.438158 | 0.0017109 | 13.4305
2 x FLOOR BRACE | +15.513 | +15.593 | 5 | 6 | 14.4 | 0.1 | 0.5 | 1504.1 | 471-D-C329 | 1504.14 | 0.468412 | 0.00182903 | 14.3579
FLOOR BRACE | +15.513 | +15.593 | 5 | 6 | 14.1 | 0.1 | 0.5 | 1463.4 | 471-D-C328 | 1463.39 | 0.455722 | 0.00177948 | 13.9689
FLOOR BRACE | +15.513 | +15.593 | 5 | 6 | 12.9 | 0.1 | 0.3 | 1337.4 | 471-D-C327 | 1337.45 | 0.416503 | 0.00162634 | 12.7668
FLOOR BRACE | +15.513 | +15.593 | 5 | 6 | 12.6 | 0.1 | 0.3 | 1308.5 | 471-D-C326 | 1308.45 | 0.407473 | 0.00159108 | 12.49
2 x FLOOR BRACE | +15.513 | +15.593 | 5 | 6 | 13.7 | 0.1 | 0.5 | 1427.4 | 471-D-C325 | 1427.45 | 0.444529 | 0.00173577 | 13.6258
FLOOR BRACE | +15.513 | +15.593 | 5 | 6 | 12.9 | 0.1 | 0.3 | 1351.1 | 471-D-C324 | 1351.08 | 0.420746 | 0.00164291 | 12.8968
FLOOR BRACE | +15.513 | +15.593 | 5 | 6 | 13.5 | 0.1 | 0.5 | 1400.2 | 471-D-C323 | 1400.21 | 0.436048 | 0.00170266 | 13.3658
SUPPORT | +5.620 | +5.700 | 5 | 3 | 9.7 | 0.1 | 0.3 | 993 | mc-276 | 993 | 0.309236 | 0.00120749 | 9.47878
FLOOR BRACE | +5.513 | +5.593 | 5 | 6 | 14.7 | 0.1 | 0.5 | 1538.7 | 471-D-C322 | 1538.66 | 0.479162 | 0.00187101 | 14.6874
FLOOR BRACE | +5.713 | +5.793 | 5 | 12 | 18 | 0.1 | 0.6 | 1874.3 | 471-D-C321 | 1874.29 | 0.583684 | 0.00227914 | 17.8912
FLOOR BRACE | +5.713 | +5.793 | 5 | 12 | 18.3 | 0.2 | 0.6 | 1897.2 | 471-D-C320 | 1897.18 | 0.590813 | 0.00230698 | 18.1098
FLOOR BRACE | +5.713 | +5.793 | 5 | 12 | 18.5 | 0.2 | 0.6 | 1914.9 | 471-D-C317 | 1914.95 | 0.596345 | 0.00232858 | 18.2793
3 x FLOOR BRACE | +5.713 | +5.793 | 5 | 12 | 9.3 | 0.1 | 0.3 | 954.4 | 471-D-C316 | 954.4 | 0.297215 | 0.00116055 | 9.11032
FLOOR BRACE | +5.713 | +5.793 | 5 | 12 | 9.3 | 0.1 | 0.3 | 954.4 | 471-D-C316 | 954.399 | 0.297215 | 0.00116055 | 9.11032
FLOOR BRACE | +5.713 | +5.793 | 5 | 12 | 9.3 | 0.1 | 0.3 | 954.9 | 471-D-C316 | 954.895 | 0.29737 | 0.00116115 | 9.11505
FLOOR BRACE | +5.713 | +5.793 | 5 | 12 | 18.1 | 0.2 | 0.6 | 1889.5 | 471-D-C319 | 1889.54 | 0.588434 | 0.00229768 | 18.0368
FLOOR BRACE | +5.713 | +5.793 | 5 | 12 | 18.1 | 0.2 | 0.6 | 1885.7 | 471-D-C318 | 1885.73 | 0.587245 | 0.00229304 | 18.0004
FLOOR BRACE | +5.713 | +5.793 | 5 | 12 | 18.5 | 0.2 | 0.6 | 1914.2 | 471-D-C317 | 1914.15 | 0.596097 | 0.00232761 | 18.2717
FLOOR BRACE | +5.713 | +5.793 | 5 | 12 | 9.3 | 0.1 | 0.3 | 954.4 | 471-D-C316 | 954.402 | 0.297216 | 0.00116055 | 9.11034
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 10.9 | 0.1 | 0.3 | 1118.6 | 471-G-F278 | 1118.57 | 0.348341 | 0.00136018 | 10.6774
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 10.9 | 0.1 | 0.3 | 1116.5 | 471-G-F277 | 1116.46 | 0.347683 | 0.00135761 | 10.6573
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1693.7 | 471-G-F248 | 1693.74 | 0.527457 | 0.00205959 | 16.1678
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1694.2 | 471-G-F248 | 1694.21 | 0.527605 | 0.00206016 | 16.1723
2 x FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1693.7 | 471-G-F248 | 1693.74 | 0.527458 | 0.00205959 | 16.1678
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 17.5 | 0.1 | 0.6 | 1816.4 | 471-G-F256 | 1816.42 | 0.565663 | 0.00220877 | 17.3389
2 x FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 17.6 | 0.1 | 0.6 | 1830.6 | 471-G-F255 | 1830.55 | 0.570063 | 0.00222595 | 17.4737
2 x FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 15.8 | 0.1 | 0.5 | 1649.2 | 471-G-F254 | 1649.19 | 0.513585 | 0.00200542 | 15.7425
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 18.6 | 0.2 | 0.6 | 1934 | 471-G-F268 | 1934.04 | 0.602292 | 0.0023518 | 18.4616
2 x FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 18.3 | 0.2 | 0.6 | 1904.3 | 471-G-F250 | 1904.27 | 0.593021 | 0.0023156 | 18.1774
2 x FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 20 | 0.2 | 0.6 | 2064.9 | 471-G-F251 | 2064.9 | 0.643042 | 0.00251091 | 19.7107
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 20 | 0.2 | 0.6 | 2065.6 | 471-G-F251 | 2065.58 | 0.643253 | 0.00251174 | 19.7172
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 18.5 | 0.2 | 0.6 | 1916.8 | 471-G-F249 | 1916.82 | 0.596928 | 0.00233085 | 18.2972
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 12.4 | 0.1 | 0.3 | 1283.2 | 471-G-F280 | 1283.17 | 0.399599 | 0.00156033 | 12.2486
2 x FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 17.5 | 0.1 | 0.6 | 1812.8 | 471-G-F240 | 1812.82 | 0.56454 | 0.00220439 | 17.3044
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-G-F245 | 1695.8 | 0.5281 | 0.0020621 | 16.1875
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1696.9 | 471-G-F245 | 1696.92 | 0.528449 | 0.00206346 | 16.1982
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 17.5 | 0.1 | 0.6 | 1809.6 | 471-G-F246 | 1809.63 | 0.563549 | 0.00220052 | 17.274
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 17.6 | 0.1 | 0.6 | 1826.5 | 471-G-F276 | 1826.45 | 0.568786 | 0.00222097 | 17.4346
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 17.2 | 0.1 | 0.6 | 1770.7 | 471-G-F275 | 1770.72 | 0.551429 | 0.00215319 | 16.9025
2 x FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 17.6 | 0.1 | 0.6 | 1828.4 | 471-G-F243 | 1828.42 | 0.5694 | 0.00222336 | 17.4534
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 17.6 | 0.1 | 0.6 | 1837.2 | 471-G-F241 | 1837.15 | 0.572118 | 0.00223398 | 17.5367
FLOOR BRACE | +70.463 | +70.543 | 8 | 6 | 17.5 | 0.1 | 0.6 | 1813.5 | 471-G-F240 | 1813.53 | 0.564763 | 0.00220526 | 17.3113
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 4.9 | 0 | 0.2 | 522.7 | 471-G-F279 | 522.672 | 0.162768 | 0.000635569 | 4.98922
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 10.9 | 0.1 | 0.3 | 1118.6 | 471-G-F278 | 1118.57 | 0.348341 | 0.00136018 | 10.6774
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 10.9 | 0.1 | 0.3 | 1116.5 | 471-G-F277 | 1116.46 | 0.347683 | 0.00135761 | 10.6573
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1693.7 | 471-G-F248 | 1693.74 | 0.527457 | 0.00205959 | 16.1678
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1694.2 | 471-G-F248 | 1694.21 | 0.527605 | 0.00206016 | 16.1723
2 x FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1693.7 | 471-G-F248 | 1693.74 | 0.527458 | 0.00205959 | 16.1678
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 17.5 | 0.1 | 0.6 | 1816.4 | 471-G-F256 | 1816.42 | 0.565663 | 0.00220877 | 17.3389
2 x FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 17.6 | 0.1 | 0.6 | 1830.6 | 471-G-F255 | 1830.55 | 0.570063 | 0.00222595 | 17.4737
2 x FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 15.8 | 0.1 | 0.5 | 1649.2 | 471-G-F254 | 1649.19 | 0.513585 | 0.00200542 | 15.7425
3 x FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 17.5 | 0.1 | 0.6 | 1812.8 | 471-G-F240 | 1812.82 | 0.56454 | 0.00220439 | 17.3044
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1695.8 | 471-G-F245 | 1695.8 | 0.5281 | 0.0020621 | 16.1875
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1696.9 | 471-G-F245 | 1696.92 | 0.528449 | 0.00206346 | 16.1982
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 17.5 | 0.1 | 0.6 | 1809.6 | 471-G-F246 | 1809.63 | 0.563549 | 0.00220052 | 17.274
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 17.6 | 0.1 | 0.6 | 1826.5 | 471-G-F276 | 1826.45 | 0.568786 | 0.00222097 | 17.4346
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 17.2 | 0.1 | 0.6 | 1770.7 | 471-G-F275 | 1770.72 | 0.551429 | 0.00215319 | 16.9025
2 x FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 17.6 | 0.1 | 0.6 | 1828.4 | 471-G-F243 | 1828.42 | 0.5694 | 0.00222336 | 17.4534
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 17.6 | 0.1 | 0.6 | 1837.2 | 471-G-F241 | 1837.15 | 0.572118 | 0.00223398 | 17.5367
FLOOR BRACE | +66.063 | +66.143 | 8 | 6 | 17.5 | 0.1 | 0.6 | 1813.5 | 471-G-F240 | 1813.53 | 0.564763 | 0.00220526 | 17.3113
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 16.2 | 0.1 | 0.5 | 1679 | 471-G-F264 | 1678.98 | 0.522863 | 0.00204165 | 16.0269
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 15.6 | 0.1 | 0.5 | 1615.5 | 471-G-F274 | 1615.46 | 0.503079 | 0.0019644 | 15.4205
2 x FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 13.7 | 0.1 | 0.5 | 1422.2 | 471-G-F273 | 1422.2 | 0.442896 | 0.0017294 | 13.5758
2 x FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 16.2 | 0.1 | 0.5 | 1679 | 471-G-F264 | 1678.88 | 0.52283 | 0.00204152 | 16.0259
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 14.4 | 0.1 | 0.5 | 1502.3 | 471-G-F272 | 1502.29 | 0.467836 | 0.00182678 | 14.3402
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 14.4 | 0.1 | 0.5 | 1502.3 | 471-G-F272 | 1502.29 | 0.467837 | 0.00182678 | 14.3402
2 x FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 14.9 | 0.1 | 0.5 | 1553.9 | 471-G-F271 | 1553.95 | 0.483924 | 0.0018896 | 14.8334
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 18.6 | 0.2 | 0.6 | 1934 | 471-G-F268 | 1934.04 | 0.602292 | 0.0023518 | 18.4616
2 x FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 16.8 | 0.1 | 0.6 | 1747 | 471-G-F269 | 1746.97 | 0.544034 | 0.00212432 | 16.6759
2 x FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 14.4 | 0.1 | 0.5 | 1500 | 471-G-F270 | 1500.02 | 0.467129 | 0.00182402 | 14.3186
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 16.3 | 0.1 | 0.5 | 1694.7 | 471-G-F248 | 1694.73 | 0.527767 | 0.00206079 | 16.1772
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 18.6 | 0.2 | 0.6 | 1934.1 | 471-G-F268 | 1934.09 | 0.602305 | 0.00235185 | 18.462
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 15.6 | 0.1 | 0.5 | 1619 | 471-G-F267 | 1618.98 | 0.504178 | 0.00196869 | 15.4542
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 18.9 | 0.2 | 0.6 | 1960.9 | 471-G-F261 | 1960.85 | 0.610641 | 0.0023844 | 18.7175
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 16 | 0.1 | 0.5 | 1662.2 | 471-G-F266 | 1662.15 | 0.517621 | 0.00202118 | 15.8662
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 15.8 | 0.1 | 0.5 | 1636.4 | 471-G-F265 | 1636.42 | 0.509607 | 0.00198988 | 15.6206
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 12.9 | 0.1 | 0.3 | 1345.6 | 471-G-F263 | 1345.65 | 0.419057 | 0.00163631 | 12.845
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 13.7 | 0.1 | 0.5 | 1407.1 | 471-G-F262 | 1407.15 | 0.438208 | 0.00171109 | 13.4321
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 18.9 | 0.2 | 0.6 | 1960.9 | 471-G-F261 | 1960.97 | 0.610677 | 0.00238454 | 18.7186
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 12.9 | 0.1 | 0.3 | 1343.5 | 471-G-F260 | 1343.51 | 0.418389 | 0.0016337 | 12.8246
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 12.9 | 0.1 | 0.3 | 1343.6 | 471-G-F260 | 1343.55 | 0.418404 | 0.00163376 | 12.825
FLOOR BRACE | +63.260 | +63.340 | 8 | 6 | 14.1 | 0.1 | 0.5 | 1477.9 | 471-G-F259 | 1477.97 | 0.460263 | 0.00179721 | 14.1081
