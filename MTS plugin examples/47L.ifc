Properties of the parts of a building model (IFC2X3), part 11 of 22

# IfcDiscreteAccessory: PLATE (5205)
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
PLATE | PLT16*270 | +54.955 | +55.648 | 8 | 99 | 23.5 | 0 | 17.2 | 0.3 | 270 | 16 | 692.4 | pf-223 | 0.404716 | 0.186959 | 0.000256 | 0.00299134 | 0.00299134
2 x PLATE | PLT10*94.5 | +53.406 | +53.416 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +53.191 | +53.616 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT10*94.5 | +52.665 | +52.675 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +52.465 | +52.890 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*270 | +52.690 | +53.391 | 8 | 99 | 23.8 | 0 | 17.2 | 0.3 | 270 | 16 | 700.4 | pf-222 | 0.409275 | 0.189111 | 0.000256 | 0.00302577 | 0.00302577
2 x PLATE | PLT10*94.5 | +49.027 | +49.037 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +48.812 | +49.237 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*270 | +48.700 | +49.012 | 7 | 99 | 10.6 | 0 | 17.7 | 0.2 | 270 | 16 | 311.7 | pe-166 | 0.186932 | 0.084159 | 0.000256 | 0.00134654 | 0.00134654
4 x PLATE | PLT10*81.8 | +44.308 | +44.486 | 7 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pe-71 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
2 x PLATE | PLT16*210 | +44.292 | +44.502 | 7 | 99 | 11.3 | 0 | 17.7 | 0.2 | 210 | 16 | 425 | pe-175 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*211.8 | +44.232 | +44.563 | 7 | 99 | 8.1 | 0 | 17.9 | 0.1 | 211.8 | 16 | 331 | pe-171 | 0.145211 | 0.0700913 | 0.000256 | 0.00103586 | 0.00103586
PLATE | PLT16*222.2 | +44.232 | +44.563 | 7 | 99 | 8.5 | 0 | 17.8 | 0.2 | 222.2 | 16 | 331 | pe-170 | 0.150774 | 0.073561 | 0.000256 | 0.00107818 | 0.00107818
4 x PLATE | PLT10*81.8 | +38.771 | +38.949 | 7 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pe-71 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
2 x PLATE | PLT16*210 | +38.755 | +38.965 | 7 | 99 | 11.3 | 0 | 17.7 | 0.2 | 210 | 16 | 425 | pe-175 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*211.8 | +38.695 | +39.026 | 7 | 99 | 8.1 | 0 | 17.9 | 0.1 | 211.8 | 16 | 331 | pe-171 | 0.145211 | 0.0700913 | 0.000256 | 0.00103586 | 0.00103586
PLATE | PLT16*222.2 | +38.695 | +39.026 | 7 | 99 | 8.5 | 0 | 17.8 | 0.2 | 222.2 | 16 | 331 | pe-170 | 0.150774 | 0.073561 | 0.000256 | 0.00107818 | 0.00107818
4 x PLATE | PLT10*81.8 | +36.003 | +36.181 | 6 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pd-54 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
2 x PLATE | PLT16*210 | +35.987 | +36.197 | 6 | 99 | 11.3 | 0 | 17.7 | 0.2 | 210 | 16 | 425 | pd-165 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*211.8 | +35.927 | +36.258 | 6 | 99 | 8.1 | 0 | 17.9 | 0.1 | 211.8 | 16 | 331 | pd-131 | 0.145211 | 0.0700913 | 0.000256 | 0.00103586 | 0.00103586
PLATE | PLT16*222.2 | +35.927 | +36.258 | 6 | 99 | 8.5 | 0 | 17.8 | 0.2 | 222.2 | 16 | 331 | pd-130 | 0.150774 | 0.073561 | 0.000256 | 0.00107818 | 0.00107818
4 x PLATE | PLT10*81.8 | +31.461 | +31.639 | 6 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pd-54 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
2 x PLATE | PLT16*210 | +31.445 | +31.655 | 6 | 99 | 11.3 | 0 | 17.7 | 0.2 | 210 | 16 | 425 | pd-165 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*211.8 | +31.385 | +31.716 | 6 | 99 | 8.1 | 0 | 17.9 | 0.1 | 211.8 | 16 | 331 | pd-131 | 0.145211 | 0.0700913 | 0.000256 | 0.00103586 | 0.00103586
PLATE | PLT16*222.2 | +31.385 | +31.716 | 6 | 99 | 8.5 | 0 | 17.8 | 0.2 | 222.2 | 16 | 331 | pd-130 | 0.150774 | 0.073561 | 0.000256 | 0.00107818 | 0.00107818
4 x PLATE | PLT10*81.8 | +28.813 | +28.991 | 6 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pd-54 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
2 x PLATE | PLT16*210 | +28.797 | +29.007 | 6 | 99 | 11.3 | 0 | 17.7 | 0.2 | 210 | 16 | 425 | pd-165 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*211.8 | +28.737 | +29.068 | 6 | 99 | 8.1 | 0 | 17.9 | 0.1 | 211.8 | 16 | 331 | pd-131 | 0.145211 | 0.0700913 | 0.000256 | 0.00103586 | 0.00103586
PLATE | PLT16*222.2 | +28.737 | +29.068 | 6 | 99 | 8.5 | 0 | 17.8 | 0.2 | 222.2 | 16 | 331 | pd-130 | 0.150774 | 0.073561 | 0.000256 | 0.00107818 | 0.00107818
2 x PLATE | PLT10*94.5 | +44.813 | +44.878 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +44.600 | +45.125 | 7 | 99 | 14.9 | 0 | 17.5 | 0.3 | 250 | 16 | 475 | pe-142 | 0.2607 | 0.2607 | 0.004 | 0.0019 | 0.0019
PLATE | PLT16*288.3 | +44.575 | +44.863 | 7 | 99 | 10.2 | 0 | 17.7 | 0.2 | 288.3 | 16 | 318.1 | pe-179 | 0.182662 | 0.0916892 | 0.000256 | 0.00131418 | 0.00131418
2 x PLATE | PLT10*94.5 | +48.043 | +48.108 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +47.796 | +48.321 | 7 | 99 | 14.9 | 0 | 17.5 | 0.3 | 250 | 16 | 475 | pe-142 | 0.2607 | 0.2607 | 0.004 | 0.0019 | 0.0019
2 x PLATE | PLT10*94.5 | +48.020 | +48.114 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +47.829 | +48.319 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*315.6 | +48.029 | +48.344 | 7 | 99 | 21.2 | 0 | 17.2 | 0.3 | 315.6 | 16 | 642.5 | pe-176 | 0.367528 | 0.202775 | 0.000256 | 0.00271767 | 0.00271767
2 x PLATE | PLT10*94.5 | +44.805 | +44.899 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +44.600 | +45.091 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*315.4 | +44.575 | +44.890 | 7 | 99 | 11.3 | 0 | 17.7 | 0.2 | 315.4 | 16 | 344.9 | pe-160 | 0.197088 | 0.108786 | 0.000256 | 0.00142696 | 0.00142696
2 x PLATE | PLT10*94.5 | +39.260 | +39.372 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +39.063 | +39.556 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-174 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*329.7 | +39.038 | +39.368 | 7 | 99 | 12.4 | 0 | 17.5 | 0.2 | 329.7 | 16 | 347.8 | pe-182 | 0.21739 | 0.114649 | 0.000256 | 0.00157849 | 0.00157849
2 x PLATE | PLT10*94.5 | +43.885 | +43.998 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +43.701 | +44.194 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-174 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*329.7 | +43.890 | +44.219 | 7 | 99 | 11.3 | 0 | 17.7 | 0.2 | 329.7 | 16 | 343.8 | pe-181 | 0.199038 | 0.11333 | 0.000256 | 0.00144168 | 0.00144168
2 x PLATE | PLT10*94.5 | +44.200 | +44.210 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +43.950 | +44.425 | 7 | 99 | 14.9 | 0 | 17.5 | 0.3 | 250 | 16 | 475 | pe-142 | 0.2607 | 0.2607 | 0.004 | 0.0019 | 0.0019
PLATE | PLT16*270 | +44.225 | +44.863 | 7 | 99 | 17 | 0 | 17.5 | 0.3 | 270 | 16 | 637.9 | pe-184 | 0.296597 | 0.17222 | 0.000256 | 0.00216004 | 0.00275551
2 x PLATE | PLT10*94.5 | +39.383 | +39.393 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +39.168 | +39.643 | 7 | 99 | 14.9 | 0 | 17.5 | 0.3 | 250 | 16 | 475 | pe-142 | 0.2607 | 0.2607 | 0.004 | 0.0019 | 0.0019
4 x PLATE | PLT10*94.5 | +36.440 | +36.611 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +36.295 | +36.747 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-174 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353 | +36.270 | +36.623 | 6 | 99 | 14.1 | 0 | 17.5 | 0.2 | 353 | 16 | 367.3 | pd-159 | 0.245928 | 0.129638 | 0.000256 | 0.00179675 | 0.00179675
2 x PLATE | PLT10*94.5 | +31.935 | +32.064 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +31.748 | +32.238 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-164 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*336.7 | +31.728 | +32.065 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 336.7 | 16 | 369.1 | pd-158 | 0.233773 | 0.124287 | 0.000256 | 0.00170344 | 0.00170344
PLATE | PLT16*95 | +28.629 | +28.724 | 6 | 99 | 1 | 0 | 22.2 | 0 | 95 | 16 | 95 | pd-160 | 0.0192958 | 0.009025 | 0.000256 | 0.0001106 | 0.0001106
2 x PLATE | PLT10*94.5 | +35.895 | +35.905 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +35.645 | +36.220 | 6 | 99 | 18.1 | 0 | 17.5 | 0.3 | 250 | 16 | 575 | pd-153 | 0.3139 | 0.3139 | 0.004 | 0.0023 | 0.0023
PLATE | PLT16*270 | +35.920 | +36.623 | 6 | 99 | 23.8 | 0 | 17.2 | 0.3 | 270 | 16 | 702.6 | pd-150 | 0.41051 | 0.189694 | 0.000256 | 0.0030351 | 0.0030351
2 x PLATE | PLT10*94.5 | +32.080 | +32.090 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +31.765 | +32.340 | 6 | 99 | 18.1 | 0 | 17.5 | 0.3 | 250 | 16 | 575 | pd-153 | 0.3139 | 0.3139 | 0.004 | 0.0023 | 0.0023
PLATE | PLT10*94.6 | +31.353 | +31.363 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.6 | 10 | 203.5 | pd-52 | 0.0342153 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT10*94.5 | +31.353 | +31.363 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +31.103 | +31.678 | 6 | 99 | 18.1 | 0 | 17.5 | 0.3 | 250 | 16 | 575 | pd-153 | 0.3139 | 0.3139 | 0.004 | 0.0023 | 0.0023
PLATE | PLT16*270 | +31.378 | +32.065 | 6 | 99 | 23.3 | 0 | 17.2 | 0.3 | 270 | 16 | 686.3 | pd-123 | 0.401221 | 0.185309 | 0.000256 | 0.00296495 | 0.00296495
2 x PLATE | PLT10*94.5 | +29.445 | +29.455 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +29.130 | +29.705 | 6 | 99 | 18.1 | 0 | 17.5 | 0.3 | 250 | 16 | 575 | pd-153 | 0.3139 | 0.3139 | 0.004 | 0.0023 | 0.0023
PLATE | PLT10*94.6 | +38.663 | +38.673 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.6 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT10*94.5 | +38.663 | +38.673 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +38.413 | +38.888 | 7 | 99 | 14.9 | 0 | 17.5 | 0.3 | 250 | 16 | 475 | pe-142 | 0.2607 | 0.2607 | 0.004 | 0.0019 | 0.0019
PLATE | PLT16*270 | +38.688 | +39.368 | 7 | 99 | 23 | 0 | 17.2 | 0.3 | 270 | 16 | 679.3 | pe-168 | 0.397171 | 0.183398 | 0.000256 | 0.00293436 | 0.00293436
2 x PLATE | PLT10*94.5 | +36.638 | +36.648 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +36.423 | +36.898 | 7 | 99 | 14.9 | 0 | 17.5 | 0.3 | 250 | 16 | 475 | pe-142 | 0.2607 | 0.2607 | 0.004 | 0.0019 | 0.0019
6 x PLATE | PLT10*94.5 | +38.342 | +38.512 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +38.206 | +38.657 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-174 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.9 | +38.330 | +38.682 | 7 | 99 | 11.9 | 0 | 17.7 | 0.2 | 353 | 16 | 358.3 | pe-180 | 0.209288 | 0.126433 | 0.000256 | 0.00151834 | 0.00151834
2 x PLATE | PLT10*94.5 | +35.564 | +35.693 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +35.389 | +35.879 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-164 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*350.4 | +35.564 | +35.914 | 6 | 99 | 12.1 | 0 | 17.5 | 0.2 | 350.4 | 16 | 356.2 | pd-157 | 0.213374 | 0.124794 | 0.000256 | 0.00155071 | 0.00155071
2 x PLATE | PLT10*94.5 | +29.246 | +29.417 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT16*349.8 | +29.080 | +29.430 | 6 | 99 | 17 | 0 | 17.3 | 0.3 | 349.8 | 16 | 436.6 | pd-149 | 0.294406 | 0.152707 | 0.000256 | 0.00216759 | 0.00216759
PLATE | FL16*250 | +29.102 | +29.552 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT10*94.5 | +31.032 | +31.204 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | PLT10*94.5 | +31.032 | +31.204 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +30.897 | +31.347 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.8 | +31.020 | +31.372 | 6 | 99 | 13.1 | 0 | 17.5 | 0.2 | 352.8 | 16 | 396.9 | pd-148 | 0.229462 | 0.140033 | 0.000256 | 0.00167127 | 0.00167127
10 x PLATE | PLT8*163 | +48.525 | +48.688 | 7 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pe-196 | 0.0763009 | 0.0352634 | 0.000064 | 0.000281207 | 0.000281207
4 x PLATE | PLT8*163 | +44.400 | +44.563 | 7 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pe-196 | 0.0763009 | 0.0352634 | 0.000064 | 0.000281207 | 0.000281207
5 x PLATE | PLT8*163 | +44.400 | +44.563 | 7 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pe-196 | 0.0763242 | 0.0352745 | 0.000064 | 0.000281296 | 0.000281296
14 x PLATE | PLT8*163 | +36.095 | +36.258 | 6 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pd-171 | 0.0763242 | 0.0352745 | 0.000064 | 0.000281296 | 0.000281296
2 x PLATE | PLT8*163 | +28.905 | +29.068 | 6 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.4 | pd-170 | 0.0592272 | 0.0271259 | 0.000064 | 0.000216107 | 0.000216107
2 x PLATE | PLT8*163 | +44.400 | +44.563 | 7 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.4 | pe-200 | 0.0592272 | 0.0271259 | 0.000064 | 0.000216107 | 0.000216107
2 x PLATE | PLT8*85 | +55.130 | +55.293 | 8 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pf-282 | 0.031678 | 0.013855 | 0.000064 | 0.00011084 | 0.00011084
2 x PLATE | PLT8*132.2 | +60.560 | +60.726 | 8 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pf-279 | 0.0485059 | 0.022011 | 0.000064 | 0.000175188 | 0.000175188
32 x PLATE | PLT10*81.8 | +5.361 | +5.443 | 5 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pc-203 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
36 x PLATE | PLT10*81.8 | +5.262 | +5.343 | 5 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pc-203 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
PLATE | PLT16*210 | +5.344 | +5.360 | 5 | 99 | 11.3 | 0.1 | 17.7 | 0.2 | 210 | 16 | 425 | pc-384 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*567.8 | +5.328 | +5.344 | 5 | 99 | 35.4 | 0.3 | 16.9 | 0.6 | 567.8 | 16 | 668.5 | pc-405 | 0.597616 | 0.379529 | 0.000256 | 0.00451157 | 0.00451157
4 x PLATE | PLT10*47.2 | +5.509 | +5.691 | 5 | 8 | 0.7 | 0 | 32.2 | 0 | 47.2 | 10 | 182 | pc-201 | 0.0211524 | 0.008597 | 0.0001 | 0.0000837171 | 0.0000837171
27 x PLATE | PLT8*163 | +5.525 | +5.688 | 5 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.4 | pc-424 | 0.0592044 | 0.0271151 | 0.000064 | 0.00021602 | 0.00021602
2 x PLATE | PLT10*94.5 | +5.249 | +5.343 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +5.361 | +5.456 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +5.344 | +5.360 | 5 | 99 | 13.3 | 0.1 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*532.5 | +5.328 | +5.344 | 5 | 99 | 26.3 | 0.2 | 16.9 | 0.3 | 532.5 | 16 | 536.5 | pc-347 | 0.44846 | 0.2857 | 0.000256 | 0.00335383 | 0.00335383
PLATE | PLT16*527.3 | +5.328 | +5.344 | 5 | 99 | 26.1 | 0.2 | 16.9 | 0.3 | 527.3 | 16 | 534 | pc-348 | 0.444105 | 0.28153 | 0.000256 | 0.00332052 | 0.00332052
4 x PLATE | PLT10*81.8 | +15.361 | +15.443 | 5 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pc-203 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
6 x PLATE | PLT10*81.8 | +15.262 | +15.343 | 5 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pc-203 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
3 x PLATE | PLT16*210 | +15.344 | +15.360 | 5 | 99 | 11.3 | 0.1 | 17.7 | 0.2 | 210 | 16 | 425 | pc-384 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*497.6 | +15.328 | +15.344 | 5 | 99 | 50.4 | 0.3 | 16.7 | 0.8 | 497.6 | 16 | 862.5 | pc-404 | 0.843717 | 0.429183 | 0.000256 | 0.00642566 | 0.00642566
2 x PLATE | PLT10*81.9 | +15.361 | +15.443 | 5 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pc-203 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
PLATE | PLT16*356.8 | +15.328 | +15.344 | 5 | 99 | 17.6 | 0.1 | 17.3 | 0.3 | 356.8 | 16 | 486.7 | pc-346 | 0.304472 | 0.173636 | 0.000256 | 0.00224516 | 0.00224516
5 x PLATE | PLT8*163 | +15.525 | +15.688 | 5 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pc-422 | 0.0763044 | 0.0352651 | 0.000064 | 0.00028122 | 0.00028122
16 x PLATE | PLT8*163 | +15.525 | +15.688 | 5 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.4 | pc-424 | 0.0592044 | 0.0271151 | 0.000064 | 0.00021602 | 0.00021602
3 x PLATE | PLT8*132.2 | +31.553 | +31.719 | 6 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pd-169 | 0.0485065 | 0.0220113 | 0.000064 | 0.00017519 | 0.00017519
2 x PLATE | PLT8*163 | +31.553 | +31.716 | 6 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.4 | pd-170 | 0.0592242 | 0.0271245 | 0.000064 | 0.000216096 | 0.000216096
2 x PLATE | PLT8*85 | +31.553 | +31.716 | 6 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pd-167 | 0.031678 | 0.013855 | 0.000064 | 0.00011084 | 0.00011084
4 x PLATE | PLT8*163 | +36.095 | +36.258 | 6 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pd-171 | 0.0763009 | 0.0352634 | 0.000064 | 0.000281207 | 0.000281207
2 x PLATE | PLT8*85 | +36.095 | +36.258 | 6 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pd-167 | 0.031678 | 0.013855 | 0.000064 | 0.00011084 | 0.00011084
3 x PLATE | PLT8*163 | +38.863 | +39.026 | 7 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pe-196 | 0.0763044 | 0.0352651 | 0.000064 | 0.00028122 | 0.00028122
PLATE | PLT8*152.4 | +28.905 | +29.069 | 6 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pd-168 | 0.0546411 | 0.0249398 | 0.000064 | 0.000198619 | 0.000198619
PLATE | PLT8*163.6 | +28.905 | +29.069 | 6 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163.6 | 8 | 217.5 | pd-172 | 0.0769682 | 0.0355829 | 0.000064 | 0.000283764 | 0.000283764
4 x PLATE | PLT8*163 | +28.905 | +29.068 | 6 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pd-171 | 0.0763009 | 0.0352634 | 0.000064 | 0.000281207 | 0.000281207
4 x PLATE | PLT8*163 | +28.905 | +29.068 | 6 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pd-170 | 0.059461 | 0.0272374 | 0.000064 | 0.000216999 | 0.000216999
PLATE | PLT8*85 | +48.525 | +48.688 | 7 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pe-194 | 0.031678 | 0.013855 | 0.000064 | 0.00011084 | 0.00011084
2 x PLATE | PLT8*85 | +63.275 | +63.438 | 8 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pf-282 | 0.031678 | 0.013855 | 0.000064 | 0.00011084 | 0.00011084
2 x PLATE | PLT8*85 | +44.400 | +44.563 | 7 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pe-194 | 0.031678 | 0.013855 | 0.000064 | 0.00011084 | 0.00011084
2 x PLATE | PLT8*85 | +38.863 | +39.026 | 7 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pe-194 | 0.031678 | 0.013855 | 0.000064 | 0.00011084 | 0.00011084
2 x PLATE | PLT8*132.2 | +48.525 | +48.691 | 7 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166 | pe-195 | 0.0483663 | 0.0219452 | 0.000064 | 0.000174662 | 0.000174662
2 x PLATE | PLT8*132.2 | +52.865 | +53.031 | 8 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166 | pf-279 | 0.0483663 | 0.0219452 | 0.000064 | 0.000174662 | 0.000174662
2 x PLATE | PLT8*132.2 | +57.845 | +58.011 | 8 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166 | pf-279 | 0.0483663 | 0.0219452 | 0.000064 | 0.000174662 | 0.000174662
2 x PLATE | PLT8*132.2 | +68.275 | +68.441 | 8 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166 | pf-279 | 0.0483663 | 0.0219452 | 0.000064 | 0.000174662 | 0.000174662
PLATE | PLT12*82.1 | +21.116 | +21.449 | 4 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pb-49 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
3 x PLATE | PLT12*82.1 | +21.116 | +21.448 | 4 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pb-49 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
PLATE | PLT12*82.1 | +21.116 | +21.449 | 5 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pc-88 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
PLATE | PLT12*82.1 | +21.116 | +21.448 | 5 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pc-88 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
4 x PLATE | PLT10*94.5 | +21.180 | +21.384 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +21.157 | +21.407 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*265 | +21.117 | +21.447 | 5 | 99 | 10.6 | 0 | 17.7 | 0.2 | 265 | 16 | 330 | pc-407 | 0.186553 | 0.0874464 | 0.000256 | 0.00134954 | 0.00134954
PLATE | PLT16*245.3 | +21.117 | +21.447 | 4 | 8 | 9.7 | 0 | 17.7 | 0.2 | 245.3 | 16 | 330 | pb-182 | 0.169253 | 0.080942 | 0.000256 | 0.00121667 | 0.00121667
15 x PLATE | PLT8*163 | +70.475 | +70.638 | 8 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pf-277 | 0.059461 | 0.0272374 | 0.000064 | 0.000216999 | 0.000216999
3 x PLATE | PLT8*85 | +70.475 | +70.638 | 8 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pf-282 | 0.031678 | 0.013855 | 0.000064 | 0.00011084 | 0.00011084
6 x PLATE | PLT8*163 | +70.475 | +70.638 | 8 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pf-277 | 0.0594608 | 0.0272372 | 0.000064 | 0.000216998 | 0.000216998
PLATE | PLT8*163 | +70.475 | +70.638 | 8 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 165.1 | pf-278 | 0.0587702 | 0.0269081 | 0.000064 | 0.000214365 | 0.000214365
5 x PLATE | PLT8*132.2 | +70.475 | +70.641 | 8 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pf-279 | 0.0485065 | 0.0220113 | 0.000064 | 0.00017519 | 0.00017519
5 x PLATE | PLT8*132.2 | +63.275 | +63.441 | 8 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pf-279 | 0.0485065 | 0.0220113 | 0.000064 | 0.00017519 | 0.00017519
2 x PLATE | PLT8*163 | +63.275 | +63.438 | 8 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pf-277 | 0.0594608 | 0.0272372 | 0.000064 | 0.000216998 | 0.000216998
7 x PLATE | PLT8*132.2 | +55.130 | +55.296 | 8 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pf-279 | 0.0485065 | 0.0220113 | 0.000064 | 0.00017519 | 0.00017519
2 x PLATE | PLT8*163 | +55.130 | +55.293 | 8 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pf-277 | 0.059461 | 0.0272374 | 0.000064 | 0.000216999 | 0.000216999
2 x PLATE | PLT8*163 | +55.130 | +55.293 | 8 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pf-277 | 0.0594608 | 0.0272372 | 0.000064 | 0.000216998 | 0.000216998
5 x PLATE | PLT8*132.2 | +44.400 | +44.566 | 7 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pe-195 | 0.0485065 | 0.0220113 | 0.000064 | 0.00017519 | 0.00017519
2 x PLATE | PLT8*163 | +44.400 | +44.563 | 7 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pe-200 | 0.059461 | 0.0272374 | 0.000064 | 0.000216999 | 0.000216999
2 x PLATE | PLT8*163 | +44.400 | +44.563 | 7 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pe-200 | 0.0594608 | 0.0272372 | 0.000064 | 0.000216998 | 0.000216998
7 x PLATE | PLT8*132.2 | +36.095 | +36.261 | 6 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pd-169 | 0.0485065 | 0.0220113 | 0.000064 | 0.00017519 | 0.00017519
2 x PLATE | PLT8*163 | +36.095 | +36.258 | 6 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pd-170 | 0.059461 | 0.0272374 | 0.000064 | 0.000216999 | 0.000216999
2 x PLATE | PLT8*163 | +36.095 | +36.258 | 6 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pd-170 | 0.0594608 | 0.0272372 | 0.000064 | 0.000216998 | 0.000216998
4 x PLATE | PLT10*81.8 | +24.051 | +24.229 | 5 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pc-203 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
2 x PLATE | PLT16*210 | +24.035 | +24.245 | 5 | 99 | 11.3 | 0 | 17.7 | 0.2 | 210 | 16 | 425 | pc-384 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*211.8 | +23.975 | +24.306 | 4 | 99 | 8.1 | 0 | 17.9 | 0.1 | 211.8 | 16 | 331 | pb-181 | 0.145211 | 0.0700913 | 0.000256 | 0.00103586 | 0.00103586
PLATE | PLT16*222.2 | +23.975 | +24.306 | 5 | 99 | 8.5 | 0 | 17.8 | 0.2 | 222.2 | 16 | 331 | pc-406 | 0.150774 | 0.073561 | 0.000256 | 0.00107818 | 0.00107818
5 x PLATE | PLT8*132.2 | +28.905 | +29.071 | 6 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pd-169 | 0.0485065 | 0.0220113 | 0.000064 | 0.00017519 | 0.00017519
2 x PLATE | PLT8*163 | +28.905 | +29.068 | 6 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pd-170 | 0.0594608 | 0.0272372 | 0.000064 | 0.000216998 | 0.000216998
4 x PLATE | PLT8*163 | +28.905 | +29.068 | 6 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pd-171 | 0.0763242 | 0.0352745 | 0.000064 | 0.000281296 | 0.000281296
8 x PLATE | PLT8*163 | +28.905 | +29.068 | 6 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pd-171 | 0.0763044 | 0.0352651 | 0.000064 | 0.00028122 | 0.00028122
2 x PLATE | PLT8*85 | +28.905 | +29.068 | 6 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pd-167 | 0.031678 | 0.013855 | 0.000064 | 0.00011084 | 0.00011084
PLATE | PLT12*135 | +0.025 | +0.384 | 5 | 1 | 4.1 | 0 | 24 | 0.1 | 135 | 12 | 367 | pc-87 | 0.098831 | 0.111138 | 0.00162 | 0.000525217 | 0.00059454
2 x PLATE | PLT10*94.5 | +0.373 | +0.431 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +0.159 | +0.631 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*325.3 | +0.025 | +0.415 | 5 | 99 | 13.1 | 0 | 17.5 | 0.2 | 325.3 | 16 | 390 | pc-309 | 0.231605 | 0.126865 | 0.000256 | 0.00168599 | 0.00168599
2 x PLATE | PLT10*94.5 | +5.047 | +5.105 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +4.847 | +5.319 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*281.4 | +5.063 | +5.344 | 5 | 99 | 9.7 | 0 | 17.7 | 0.2 | 281.4 | 16 | 322.4 | pc-310 | 0.17426 | 0.0907211 | 0.000256 | 0.0012528 | 0.0012528
PLATE | PLT16*119.1 | +0.009 | +0.025 | 5 | 1 | 3.1 | 0 | 19.6 | 0.1 | 119.1 | 16 | 290 | pc-392 | 0.0603093 | 0.0345459 | 0.000256 | 0.000392735 | 0.000392735
PLATE | PLT12*135 | +0.025 | +0.280 | 5 | 1 | 3.7 | 0 | 24.1 | 0.1 | 135 | 12 | 331 | pc-86 | 0.0883028 | 0.100554 | 0.00162 | 0.00046722 | 0.00053622
PLATE | PLT12*135 | +0.258 | +0.614 | 5 | 1 | 4.5 | 0 | 24 | 0.1 | 135 | 12 | 414 | pc-85 | 0.107529 | 0.124956 | 0.00162 | 0.000571492 | 0.00067068
PLATE | PLT16*162.4 | +0.009 | +0.025 | 5 | 1 | 4.1 | 0 | 18.9 | 0.1 | 162.4 | 16 | 290 | pc-391 | 0.0785145 | 0.0471056 | 0.000256 | 0.000529689 | 0.000529689
PLATE | PLT16*190 | +5.098 | +5.979 | 5 | 1 | 18 | 0 | 17.7 | 0.3 | 190 | 16 | 880.7 | pc-257 | 0.317667 | 0.16734 | 0.000256 | 0.00229344 | 0.00229344
PLATE | PLT16*260 | +12.474 | +12.490 | 5 | 1 | 7.5 | 0.1 | 17.9 | 0.1 | 260 | 16 | 290 | pc-390 | 0.134118 | 0.0754 | 0.000256 | 0.0009504 | 0.0009504
2 x PLATE | PLT10*94.5 | +12.083 | +12.139 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +11.883 | +12.353 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*323.5 | +12.100 | +12.474 | 5 | 99 | 12.9 | 0 | 17.5 | 0.2 | 323.5 | 16 | 374.3 | pc-311 | 0.226794 | 0.121105 | 0.000256 | 0.00164994 | 0.00164994
2 x PLATE | PLT10*94.5 | +5.940 | +5.995 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +5.725 | +6.196 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*278.7 | +5.700 | +5.979 | 5 | 99 | 16.3 | 0 | 17.5 | 0.3 | 278.7 | 16 | 495.1 | pc-308 | 0.283772 | 0.137975 | 0.000256 | 0.00207901 | 0.00207901
PLATE | PLT10*94.5 | +5.026 | +5.069 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT10*94.5 | +5.026 | +5.069 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +4.825 | +5.285 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT10*94.5 | +5.019 | +5.033 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +4.818 | +5.249 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*301.4 | +5.043 | +5.344 | 5 | 99 | 21 | 0 | 17.2 | 0.3 | 301.4 | 16 | 578.6 | pc-238 | 0.361226 | 0.174395 | 0.000256 | 0.00267071 | 0.00267071
PLATE | PLT16*220 | +2.300 | +2.965 | 5 | 8 | 13.7 | 0 | 17.7 | 0.2 | 220 | 16 | 664.6 | pc-226 | 0.244261 | 0.146219 | 0.000256 | 0.00176078 | 0.00233951
2 x PLATE | PLT10*94.5 | +2.940 | +2.955 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +2.725 | +3.155 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT10*94.5 | +2.163 | +2.281 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +1.982 | +2.475 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*484.1 | +2.167 | +2.931 | 5 | 99 | 30.8 | 0 | 16.9 | 0.5 | 484.1 | 16 | 764.1 | pc-256 | 0.522383 | 0.369952 | 0.000256 | 0.00391762 | 0.00391762
2 x PLATE | PLT10*94.5 | +2.941 | +2.984 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +2.725 | +3.185 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT10*94.5 | +2.156 | +2.299 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +1.992 | +2.475 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*391.8 | +2.153 | +2.965 | 5 | 99 | 33.7 | 0 | 16.9 | 0.6 | 391.8 | 16 | 812 | pc-389 | 0.56934 | 0.318128 | 0.000256 | 0.00428688 | 0.00428688
2 x PLATE | PLT10*94.5 | +0.569 | +0.686 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +0.375 | +0.868 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT10*94.5 | +0.219 | +0.362 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +0.043 | +0.527 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*432.4 | +0.025 | +0.683 | 5 | 99 | 25.1 | 0 | 17.2 | 0.3 | 432.4 | 16 | 658.2 | pc-388 | 0.431846 | 0.284595 | 0.000256 | 0.00319658 | 0.00319658
2 x PLATE | PLT16*97 | +2.400 | +2.800 | 5 | 8 | 4.9 | 0 | 19.2 | 0.1 | 97 | 16 | 400 | pc-365 | 0.093504 | 0.0388 | 0.000256 | 0.0006208 | 0.0006208
PLATE | PLT16*220 | +2.400 | +2.800 | 5 | 8 | 11.1 | 0 | 17.7 | 0.2 | 220 | 16 | 400 | pc-387 | 0.19584 | 0.088 | 0.000256 | 0.001408 | 0.001408
2 x PLATE | FL12*80 | +21.116 | +21.448 | 5 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pc-90 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
2 x PLATE | FL12*90 | +21.448 | +21.460 | 5 | 99 | 1 | 0 | 26.1 | 0 | 90 | 12 | 150 | pc-94 | 0.0272907 | 0.0135 | 0.000144 | 0.0001332 | 0.0001332
PLATE | PLT16*172.1 | +21.116 | +21.448 | 5 | 99 | 5.4 | 0 | 18.6 | 0.1 | 172.1 | 16 | 331.6 | pc-210 | 0.10297 | 0.0570684 | 0.000256 | 0.000706781 | 0.000909494
PLATE | PLT16*172.1 | +21.116 | +21.448 | 5 | 99 | 5.4 | 0 | 18.6 | 0.1 | 172.1 | 16 | 331.6 | pc-210 | 0.102955 | 0.0570684 | 0.000256 | 0.000706671 | 0.000909494
2 x PLATE | PLT10*94.5 | +23.882 | +24.034 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT16*426 | +23.876 | +24.302 | 5 | 99 | 19.7 | 0 | 17.2 | 0.3 | 426 | 16 | 436.8 | pc-367 | 0.339026 | 0.186069 | 0.000256 | 0.00251483 | 0.00251483
PLATE | FL16*250 | +23.690 | +24.272 | 5 | 99 | 18.1 | 0 | 17.5 | 0.3 | 250 | 16 | 575 | pc-217 | 0.3139 | 0.3139 | 0.004 | 0.0023 | 0.0023
PLATE | FL16*300 | +24.302 | +24.318 | 5 | 99 | 14 | 0.1 | 17.5 | 0.2 | 300 | 16 | 436.8 | pc-219 | 0.243186 | 0.131027 | 0.000256 | 0.00177643 | 0.00177643
PLATE | PLT10*94.5 | +21.723 | +21.875 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT10*94.5 | +21.723 | +21.875 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +21.485 | +22.067 | 5 | 99 | 18.1 | 0 | 17.5 | 0.3 | 250 | 16 | 575 | pc-217 | 0.3139 | 0.3139 | 0.004 | 0.0023 | 0.0023
PLATE | PLT16*420.8 | +21.460 | +21.881 | 5 | 99 | 19.7 | 0 | 17.2 | 0.3 | 420.8 | 16 | 451.3 | pc-366 | 0.340494 | 0.189926 | 0.000256 | 0.00252591 | 0.00252591
PLATE | PLT16*393.5 | +23.537 | +23.962 | 5 | 99 | 16.3 | 0 | 17.5 | 0.3 | 393.5 | 16 | 425 | pc-220 | 0.283872 | 0.167233 | 0.000256 | 0.00208169 | 0.00208169
2 x PLATE | PLT20*140 | +21.105 | +21.125 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +21.440 | +21.460 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +21.755 | +21.775 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT10*94.5 | +24.537 | +24.662 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +24.348 | +24.880 | 6 | 99 | 14.9 | 0 | 17.5 | 0.3 | 250 | 16 | 475 | pd-128 | 0.2607 | 0.2607 | 0.004 | 0.0019 | 0.0019
PLATE | PLT16*368.8 | +24.318 | +24.743 | 5 | 99 | 14.7 | 0 | 17.5 | 0.3 | 368.8 | 16 | 425 | pc-209 | 0.256207 | 0.156737 | 0.000256 | 0.0018672 | 0.0018672
2 x PLATE | PLT10*94.5 | +28.375 | +28.500 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +28.157 | +28.689 | 6 | 99 | 14.9 | 0 | 17.5 | 0.3 | 250 | 16 | 475 | pd-128 | 0.2607 | 0.2607 | 0.004 | 0.0019 | 0.0019
PLATE | PLT16*348 | +28.376 | +28.724 | 6 | 99 | 11.9 | 0 | 17.5 | 0.2 | 348 | 16 | 350.2 | pd-156 | 0.209788 | 0.121922 | 0.000256 | 0.00152345 | 0.00152345
2 x PLATE | PLT10*94.5 | +21.635 | +21.802 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +21.485 | +21.943 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*393.5 | +21.460 | +21.885 | 5 | 99 | 17 | 0 | 17.3 | 0.3 | 393.5 | 16 | 425 | pc-306 | 0.295337 | 0.167233 | 0.000256 | 0.00217176 | 0.00217176
2 x PLATE | PLT10*94.5 | +23.620 | +23.788 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +23.480 | +23.937 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353 | +23.609 | +23.962 | 5 | 99 | 12.6 | 0 | 17.5 | 0.2 | 353 | 16 | 379.5 | pc-307 | 0.219885 | 0.133969 | 0.000256 | 0.00159879 | 0.00159879
2 x PLATE | PLT10*121.5 | +28.604 | +28.614 | 6 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pd-53 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
PLATE | FL16*300 | +28.304 | +29.029 | 6 | 99 | 27.2 | 0 | 17.2 | 0.5 | 300 | 16 | 725 | pd-162 | 0.4678 | 0.4678 | 0.0048 | 0.00348 | 0.00348
PLATE | PLT16*320 | +28.629 | +29.430 | 6 | 99 | 30.9 | 0 | 17.2 | 0.5 | 320 | 16 | 800.3 | pd-163 | 0.527291 | 0.256112 | 0.000256 | 0.00393772 | 0.00409779
2 x PLATE | PLT10*121.5 | +24.758 | +24.768 | 6 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pd-53 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
PLATE | FL16*300 | +24.343 | +25.068 | 6 | 99 | 27.2 | 0 | 17.2 | 0.5 | 300 | 16 | 725 | pd-162 | 0.4678 | 0.4678 | 0.0048 | 0.00348 | 0.00348
PLATE | PLT10*121.5 | +23.512 | +23.522 | 5 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pc-204 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
PLATE | PLT10*121.5 | +23.512 | +23.522 | 5 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pc-204 | 0.0539766 | 0.0313015 | 0.0001 | 0.000237549 | 0.000521775
PLATE | FL16*300 | +23.212 | +23.937 | 5 | 99 | 27.2 | 0 | 17.2 | 0.5 | 300 | 16 | 725 | pc-221 | 0.4678 | 0.4678 | 0.0048 | 0.00348 | 0.00348
PLATE | FL16*300 | +23.537 | +24.743 | 5 | 99 | 45.4 | 0 | 16.9 | 0.8 | 300 | 16 | 1205.6 | pc-363 | 0.771539 | 0.36168 | 0.000256 | 0.00578688 | 0.00578688
2 x PLATE | PLT10*121.5 | +21.900 | +21.910 | 5 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pc-204 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
PLATE | FL16*300 | +21.485 | +22.210 | 5 | 99 | 27.2 | 0 | 17.2 | 0.5 | 300 | 16 | 725 | pc-221 | 0.4678 | 0.4678 | 0.0048 | 0.00348 | 0.00348
PLATE | PLT16*320 | +21.460 | +21.885 | 5 | 99 | 17.2 | 0 | 17.3 | 0.3 | 320 | 16 | 425 | pc-222 | 0.29584 | 0.136 | 0.000256 | 0.002176 | 0.002176
2 x PLATE | PLT10*121.5 | +15.923 | +16.058 | 5 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pc-204 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
PLATE | FL16*300 | +15.725 | +16.286 | 5 | 99 | 18 | 0 | 17.3 | 0.3 | 300 | 16 | 475 | pc-224 | 0.3098 | 0.3098 | 0.0048 | 0.00228 | 0.00228
PLATE | PLT16*351.8 | +15.700 | +16.052 | 5 | 99 | 13.7 | 0 | 17.5 | 0.2 | 351.8 | 16 | 393.8 | pc-208 | 0.237048 | 0.138555 | 0.000256 | 0.00173003 | 0.00173003
2 x PLATE | PLT10*121.5 | +20.724 | +20.859 | 5 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pc-204 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
PLATE | FL16*300 | +20.496 | +21.057 | 5 | 99 | 18 | 0 | 17.3 | 0.3 | 300 | 16 | 475 | pc-224 | 0.3098 | 0.3098 | 0.0048 | 0.00228 | 0.00228
2 x PLATE | PLT10*121.5 | +20.574 | +20.699 | 5 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pc-204 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
PLATE | FL16*300 | +20.297 | +21.079 | 5 | 99 | 27.2 | 0 | 17.2 | 0.5 | 300 | 16 | 725 | pc-221 | 0.4678 | 0.4678 | 0.0048 | 0.00348 | 0.00348
PLATE | PLT16*521.8 | +20.583 | +21.104 | 5 | 99 | 41.2 | 0 | 16.8 | 0.6 | 521.8 | 16 | 826.3 | pc-225 | 0.693913 | 0.431154 | 0.000256 | 0.00524905 | 0.00524905
2 x PLATE | PLT10*121.5 | +16.130 | +16.255 | 5 | 99 | 1.9 | 0 | 28.9 | 0.1 | 121.5 | 10 | 257.5 | pc-204 | 0.0539766 | 0.0313015 | 0.0001 | 0.00023755 | 0.000521775
PLATE | FL16*300 | +15.750 | +16.532 | 5 | 99 | 27.2 | 0 | 17.2 | 0.5 | 300 | 16 | 725 | pc-221 | 0.4678 | 0.4678 | 0.0048 | 0.00348 | 0.00348
PLATE | PLT16*482.4 | +15.700 | +16.247 | 5 | 99 | 28.7 | 0 | 16.9 | 0.5 | 482.4 | 16 | 546.8 | pc-410 | 0.488062 | 0.263745 | 0.000256 | 0.00366738 | 0.00366738
45 x PLATE | PLT8*163 | +12.325 | +12.488 | 5 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.4 | pc-424 | 0.0592044 | 0.0271151 | 0.000064 | 0.00021602 | 0.00021602
PLATE | PLT8*132.2 | +12.325 | +12.492 | 5 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pc-423 | 0.0485063 | 0.0220112 | 0.000064 | 0.000175189 | 0.000175189
2 x PLATE | PLT8*132.2 | +5.525 | +5.692 | 5 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pc-423 | 0.0485063 | 0.0220112 | 0.000064 | 0.000175189 | 0.000175189
2 x PLATE | FL8*130 | +5.525 | +5.692 | 5 | 8 | 1.3 | 0 | 36 | 0 | 130 | 8 | 166.6 | pc-421 | 0.0440476 | 0.021658 | 0.000064 | 0.000155839 | 0.000172364
2 x PLATE | FL10*80 | +9.065 | +9.145 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
PLATE | PLT8*47.2 | +5.614 | +5.692 | 5 | 8 | 0.2 | 0 | 40.5 | 0 | 47.2 | 8 | 77.5 | pc-418 | 0.00901591 | 0.003658 | 0.000064 | 0.000028364 | 0.000028364
PLATE | PLT8*47.2 | +5.614 | +5.691 | 5 | 8 | 0.2 | 0 | 40.5 | 0 | 47.2 | 8 | 77.5 | pc-418 | 0.00901591 | 0.003658 | 0.000064 | 0.000028364 | 0.000028364
4 x PLATE | FL10*80 | +5.614 | +5.694 | 5 | 8 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pc-150 | 0.0304 | 0.0128 | 0.0001 | 0.000128 | 0.000128
4 x PLATE | PLT12*82.1 | +5.356 | +5.688 | 5 | 99 | 2.5 | 0 | 25.1 | 0.1 | 82.1 | 12 | 331.6 | pc-88 | 0.0637166 | 0.0272244 | 0.000144 | 0.000323992 | 0.000323992
2 x PLATE | FL10*130 | +5.370 | +5.500 | 5 | 1 | 2.3 | 0 | 29.2 | 0.1 | 130 | 10 | 354.5 | pc-148 | 0.0685658 | 0.0460887 | 0.0001 | 0.000298623 | 0.000298623
PLATE | PLT8*132.2 | +5.525 | +5.691 | 5 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pc-423 | 0.048504 | 0.0220101 | 0.000064 | 0.000175181 | 0.000175181
3 x PLATE | FL10*130 | +12.170 | +12.300 | 5 | 1 | 2.3 | 0 | 29.2 | 0.1 | 130 | 10 | 354.5 | pc-148 | 0.0685658 | 0.0460887 | 0.0001 | 0.000298623 | 0.000298623
2 x PLATE | PLT10*94.5 | +5.715 | +5.725 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +5.500 | +5.925 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*270 | +5.194 | +5.694 | 5 | 99 | 14.4 | 0 | 17.5 | 0.3 | 270 | 16 | 499.6 | pc-414 | 0.251379 | 0.134892 | 0.000256 | 0.00182936 | 0.00215827
2 x PLATE | PLT10*94.5 | +5.941 | +5.987 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +5.725 | +6.188 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*268.5 | +5.700 | +5.968 | 5 | 99 | 9.7 | 0 | 17.7 | 0.2 | 268.5 | 16 | 314.7 | pc-312 | 0.170125 | 0.0844751 | 0.000256 | 0.00122163 | 0.00122163
2 x PLATE | PLT10*94.5 | +11.857 | +11.904 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +11.656 | +12.119 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*268.5 | +11.876 | +12.144 | 5 | 99 | 12.1 | 0 | 17.7 | 0.2 | 268.5 | 16 | 386.2 | pc-313 | 0.214694 | 0.103671 | 0.000256 | 0.00155562 | 0.00155562
2 x PLATE | PLT10*94.5 | +11.851 | +11.861 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +11.651 | +12.076 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*270 | +11.876 | +12.494 | 5 | 99 | 18.9 | 0 | 17.5 | 0.3 | 270 | 16 | 618.1 | pc-413 | 0.328169 | 0.166879 | 0.000256 | 0.00240758 | 0.00267007
2 x PLATE | FL10*80 | +12.415 | +12.495 | 1 | 3 | 1 | 0 | 30.5 | 0 | 80 | 10 | 140 | p010018 | 0.0268 | 0.0268 | 0.0008 | 0.000112 | 0.000112
PLATE | PLT8*132.2 | +12.325 | +12.491 | 5 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pc-423 | 0.048504 | 0.0220101 | 0.000064 | 0.000175181 | 0.000175181
2 x PLATE | FL6*40 | +13.597 | +13.647 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +13.581 | +13.587 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
PLATE | PLT6*52 | +13.617 | +13.670 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
PLATE | PLT8*132.2 | +5.525 | +5.692 | 5 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pc-423 | 0.0485041 | 0.0220126 | 0.000064 | 0.000175181 | 0.000175181
2 x PLATE | FL10*90 | +5.610 | +5.700 | 1 | 3 | 1 | 0 | 30.1 | 0 | 90 | 10 | 140 | p010021 | 0.0298 | 0.0298 | 0.0009 | 0.000126 | 0.000126
2 x PLATE | FL6*40 | +6.797 | +6.847 | 1 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | p010072 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
PLATE | FL6*40 | +6.781 | +6.787 | 1 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | p010070 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
PLATE | PLT6*52 | +6.817 | +6.870 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
12 x PLATE | PLT8*163 | +12.325 | +12.488 | 5 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pc-422 | 0.0763044 | 0.0352651 | 0.000064 | 0.00028122 | 0.00028122
32 x PLATE | FL10*70 | +15.199 | +15.337 | 5 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pc-200 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
18 x PLATE | PLT8*132.2 | +5.725 | +5.892 | 5 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166.4 | pc-423 | 0.0485064 | 0.0220112 | 0.000064 | 0.00017519 | 0.00017519
4 x PLATE | PLT16*170 | +9.835 | +10.165 | 5 | 8 | 7 | 0 | 18.1 | 0.1 | 169.9 | 16 | 330 | pc-385 | 0.1282 | 0.0561 | 0.000256 | 0.0008976 | 0.0008976
4 x PLATE | PLT16*170 | +7.635 | +7.965 | 5 | 8 | 7 | 0 | 18.1 | 0.1 | 169.9 | 16 | 330 | pc-385 | 0.1282 | 0.0561 | 0.000256 | 0.0008976 | 0.0008976
4 x PLATE | PLT16*170 | +2.400 | +2.800 | 5 | 8 | 8.5 | 0 | 18.1 | 0.2 | 169.9 | 16 | 400 | pc-386 | 0.15424 | 0.068 | 0.000256 | 0.001088 | 0.001088
35 x PLATE | PLT16*210 | +5.344 | +5.360 | 5 | 99 | 11.1 | 0.1 | 17.7 | 0.2 | 210 | 16 | 425 | pc-384 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*486.7 | +5.328 | +5.344 | 5 | 99 | 23.1 | 0.2 | 17.2 | 0.3 | 486.7 | 16 | 499.1 | pc-300 | 0.39449 | 0.242917 | 0.000256 | 0.0029376 | 0.0029376
PLATE | PLT16*475.4 | +5.328 | +5.344 | 5 | 99 | 30.8 | 0.2 | 16.9 | 0.5 | 475.4 | 16 | 731.4 | pc-301 | 0.521949 | 0.347662 | 0.000256 | 0.00390573 | 0.00390573
PLATE | PLT16*468.8 | +5.328 | +5.344 | 5 | 99 | 34.1 | 0.3 | 16.9 | 0.6 | 468.8 | 16 | 825.6 | pc-302 | 0.57895 | 0.387034 | 0.000256 | 0.00433883 | 0.00433883
4 x PLATE | PLT10*81.9 | +5.361 | +5.443 | 5 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pc-203 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
PLATE | PLT16*633.2 | +5.328 | +5.344 | 5 | 99 | 52.8 | 0.3 | 16.7 | 0.8 | 633.2 | 16 | 892.5 | pc-368 | 0.880343 | 0.565128 | 0.000256 | 0.00673052 | 0.00673052
13 x PLATE | PLT8*163 | +5.525 | +5.688 | 5 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pc-422 | 0.0763044 | 0.0352651 | 0.000064 | 0.00028122 | 0.00028122
38 x PLATE | PLT12*82.1 | +5.356 | +5.689 | 5 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pc-88 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
12 x PLATE | PLT10*94.5 | +5.547 | +5.642 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
11 x PLATE | PLT10*94.5 | +5.434 | +5.529 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
12 x PLATE | FL16*250 | +5.530 | +5.546 | 5 | 99 | 13.3 | 0.1 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353 | +5.514 | +5.530 | 5 | 99 | 14.9 | 0.1 | 17.5 | 0.3 | 353 | 16 | 516.4 | pc-303 | 0.259806 | 0.182253 | 0.000256 | 0.00189218 | 0.00189218
PLATE | PLT16*336.7 | +5.514 | +5.530 | 5 | 99 | 11.9 | 0.1 | 17.7 | 0.2 | 336.7 | 16 | 391.6 | pc-304 | 0.208193 | 0.131831 | 0.000256 | 0.00150744 | 0.00150744
PLATE | PLT10*94.6 | +5.434 | +5.529 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.6 | 10 | 203.5 | pc-202 | 0.0342153 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT16*361.5 | +5.514 | +5.530 | 5 | 99 | 28.4 | 0.2 | 16.9 | 0.5 | 361.5 | 16 | 724.8 | pc-403 | 0.483772 | 0.261999 | 0.000256 | 0.00361985 | 0.00361985
2 x PLATE | FL10*150 | +56.690 | +56.700 | 8 | 1 | 2.6 | 0 | 28.3 | 0.1 | 149.9 | 10 | 217.5 | pf-66 | 0.0726 | 0.032625 | 0.0001 | 0.00032625 | 0.00032625
4 x PLATE | FL10*150 | +56.690 | +56.700 | 8 | 1 | 1.7 | 0 | 28.9 | 0.1 | 149.9 | 10 | 150 | pf-65 | 0.051 | 0.0225 | 0.0001 | 0.000225 | 0.000225
8 x PLATE | PLT8*152.5 | +56.625 | +56.789 | 8 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pf-274 | 0.0546582 | 0.024948 | 0.000064 | 0.000198684 | 0.000198684
2 x PLATE | PLT8*133.6 | +56.655 | +56.789 | 8 | 8 | 1.3 | 0 | 35.3 | 0 | 133.6 | 8 | 152.5 | pf-275 | 0.0450304 | 0.020374 | 0.000064 | 0.000162092 | 0.000162092
4 x PLATE | FL10*80 | +56.700 | +56.780 | 8 | 3 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pf-194 | 0.0304 | 0.0304 | 0.0008 | 0.000128 | 0.000128
4 x PLATE | FL6*40 | +57.868 | +57.917 | 8 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | pf-286 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
2 x PLATE | FL6*40 | +57.852 | +57.858 | 8 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | pf-285 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
PLATE | PLT6*52 | +22.577 | +22.630 | 1 | 1 | 0.1 | 0 | 62.5 | 0 | 52 | 6 | 52.5 | p010071 | 0.00489496 | 0.00273 | 0.000036 | 0.0000099781 | 0.0000099781
6 x PLATE | PLT8*152.5 | +37.925 | +38.089 | 7 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pe-197 | 0.0546582 | 0.024948 | 0.000064 | 0.000198684 | 0.000198684
2 x PLATE | PLT8*133.6 | +37.955 | +38.089 | 7 | 8 | 1.3 | 0 | 35.3 | 0 | 133.6 | 8 | 152.5 | pe-199 | 0.0450304 | 0.020374 | 0.000064 | 0.000162092 | 0.000162092
4 x PLATE | FL10*80 | +38.000 | +38.080 | 7 | 3 | 1 | 0 | 30.3 | 0 | 80 | 10 | 160 | pe-140 | 0.0304 | 0.0304 | 0.0008 | 0.000128 | 0.000128
4 x PLATE | FL6*40 | +39.167 | +39.218 | 7 | 1 | 0.1 | 0 | 53.8 | 0 | 40 | 6 | 50 | pe-205 | 0.00494485 | 0.002 | 0.000036 | 0.0000117 | 0.0000117
2 x PLATE | FL6*40 | +39.151 | +39.157 | 7 | 8 | 0.1 | 0 | 52.8 | 0 | 40 | 6 | 65 | pe-204 | 0.00646 | 0.00646 | 0.00024 | 0.0000156 | 0.0000156
PLATE | FL10*150 | +37.990 | +38.000 | 7 | 1 | 2.6 | 0 | 28.3 | 0.1 | 149.9 | 10 | 217.5 | pe-67 | 0.0726 | 0.032625 | 0.0001 | 0.00032625 | 0.00032625
3 x PLATE | FL10*150 | +37.990 | +38.000 | 7 | 1 | 1.7 | 0 | 28.9 | 0.1 | 149.9 | 10 | 150 | pe-66 | 0.051 | 0.0225 | 0.0001 | 0.000225 | 0.000225
42 x PLATE | PLT10*81.8 | +12.161 | +12.243 | 5 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pc-203 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
44 x PLATE | PLT10*81.8 | +12.062 | +12.143 | 5 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pc-203 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
48 x PLATE | PLT16*210 | +12.144 | +12.160 | 5 | 99 | 11.1 | 0.1 | 17.7 | 0.2 | 210 | 16 | 425 | pc-384 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*490.8 | +12.128 | +12.144 | 5 | 99 | 23 | 0.2 | 17.2 | 0.3 | 490.8 | 16 | 503.1 | pc-280 | 0.393061 | 0.24692 | 0.000256 | 0.00292607 | 0.00292607
PLATE | PLT16*507.6 | +12.128 | +12.144 | 5 | 99 | 28.4 | 0.2 | 16.9 | 0.5 | 507.6 | 16 | 679.1 | pc-255 | 0.485289 | 0.344728 | 0.000256 | 0.00363649 | 0.00363649
PLATE | PLT16*504.7 | +12.128 | +12.144 | 5 | 99 | 29.4 | 0.2 | 16.9 | 0.5 | 504.7 | 16 | 685 | pc-254 | 0.501278 | 0.345694 | 0.000256 | 0.00376051 | 0.00376051
PLATE | PLT16*549.3 | +12.128 | +12.144 | 5 | 99 | 31.1 | 0.2 | 16.9 | 0.5 | 549.3 | 16 | 614.1 | pc-253 | 0.526795 | 0.337327 | 0.000256 | 0.00396228 | 0.00396228
PLATE | PLT16*421.7 | +12.128 | +12.144 | 5 | 99 | 20 | 0.2 | 17.2 | 0.3 | 421.7 | 16 | 493.8 | pc-281 | 0.343074 | 0.208232 | 0.000256 | 0.00254218 | 0.00254218
PLATE | PLT16*497.5 | +12.128 | +12.144 | 5 | 99 | 24.4 | 0.2 | 17.2 | 0.3 | 497.5 | 16 | 538.4 | pc-282 | 0.416995 | 0.26787 | 0.000256 | 0.00310854 | 0.00310854
PLATE | PLT16*535 | +12.128 | +12.144 | 5 | 99 | 29.4 | 0.2 | 16.9 | 0.5 | 535 | 16 | 644.5 | pc-252 | 0.500313 | 0.344786 | 0.000256 | 0.00375517 | 0.00375517
6 x PLATE | PLT10*81.9 | +12.161 | +12.243 | 5 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pc-203 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
PLATE | PLT16*526.9 | +12.128 | +12.144 | 5 | 99 | 32.6 | 0.3 | 16.9 | 0.6 | 526.9 | 16 | 641.4 | pc-251 | 0.551117 | 0.337947 | 0.000256 | 0.00414992 | 0.00414992
PLATE | PLT16*351.5 | +12.128 | +12.144 | 5 | 99 | 17.2 | 0.1 | 17.3 | 0.3 | 351.5 | 16 | 477.4 | pc-277 | 0.296393 | 0.167781 | 0.000256 | 0.00218309 | 0.00218309
PLATE | PLT16*690.7 | +12.128 | +12.144 | 5 | 99 | 43.6 | 0.3 | 16.8 | 0.6 | 690.7 | 16 | 727.2 | pc-250 | 0.732115 | 0.502216 | 0.000256 | 0.00555919 | 0.00555919
PLATE | PLT16*615.2 | +12.128 | +12.144 | 5 | 99 | 40.5 | 0.3 | 16.8 | 0.6 | 615.2 | 16 | 755.3 | pc-402 | 0.681585 | 0.464647 | 0.000256 | 0.00516267 | 0.00516267
PLATE | PLT16*592.6 | +12.128 | +12.144 | 5 | 99 | 38.1 | 0.3 | 16.8 | 0.6 | 592.6 | 16 | 716.9 | pc-401 | 0.642087 | 0.424825 | 0.000256 | 0.0048563 | 0.0048563
PLATE | PLT16*443.8 | +12.128 | +12.144 | 5 | 99 | 20.8 | 0.2 | 17.2 | 0.3 | 443.8 | 16 | 496.2 | pc-278 | 0.357117 | 0.220202 | 0.000256 | 0.00264995 | 0.00264995
PLATE | PLT16*577.9 | +12.128 | +12.144 | 5 | 99 | 33.5 | 0.3 | 16.9 | 0.6 | 577.9 | 16 | 596 | pc-249 | 0.565759 | 0.34445 | 0.000256 | 0.004266 | 0.004266
PLATE | PLT16*494.5 | +12.128 | +12.144 | 5 | 99 | 26.4 | 0.2 | 17.2 | 0.5 | 494.5 | 16 | 593.7 | pc-279 | 0.45061 | 0.293589 | 0.000256 | 0.00336504 | 0.00336504
PLATE | PLT16*520.5 | +12.128 | +12.144 | 5 | 99 | 30.2 | 0.2 | 16.9 | 0.5 | 520.5 | 16 | 662.1 | pc-248 | 0.512292 | 0.344629 | 0.000256 | 0.00384742 | 0.00384742
PLATE | PLT16*521.3 | +12.128 | +12.144 | 5 | 99 | 29.2 | 0.2 | 16.9 | 0.5 | 521.3 | 16 | 660.4 | pc-247 | 0.496646 | 0.344215 | 0.000256 | 0.00372586 | 0.00372586
PLATE | PLT16*509.5 | +12.128 | +12.144 | 5 | 99 | 27.6 | 0.2 | 16.9 | 0.5 | 509.5 | 16 | 671.2 | pc-246 | 0.469049 | 0.341978 | 0.000256 | 0.00351042 | 0.00351042
PLATE | PLT16*482.1 | +12.128 | +12.144 | 5 | 99 | 33 | 0.3 | 16.9 | 0.6 | 482.1 | 16 | 770.6 | pc-273 | 0.560591 | 0.371541 | 0.000256 | 0.00420299 | 0.00420299
4 x PLATE | PLT10*81.8 | +12.062 | +12.143 | 5 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pc-203 | 0.0264636 | 0.0145791 | 0.0001 | 0.00011015 | 0.000252685
PLATE | PLT16*340 | +12.128 | +12.144 | 5 | 99 | 25 | 0.2 | 17.2 | 0.3 | 340 | 16 | 749.8 | pc-245 | 0.427972 | 0.254897 | 0.000256 | 0.00318906 | 0.00318906
PLATE | PLT16*467.4 | +12.128 | +12.144 | 5 | 99 | 25.5 | 0.2 | 17.2 | 0.3 | 467.4 | 16 | 691.6 | pc-244 | 0.433724 | 0.323209 | 0.000256 | 0.00323358 | 0.00323358
PLATE | PLT16*486.9 | +12.128 | +12.144 | 5 | 99 | 30.4 | 0.2 | 16.9 | 0.5 | 486.9 | 16 | 700.9 | pc-274 | 0.516894 | 0.34126 | 0.000256 | 0.00387021 | 0.00387021
PLATE | PLT16*456 | +12.128 | +12.144 | 5 | 99 | 21.2 | 0.2 | 17.2 | 0.3 | 456 | 16 | 497.1 | pc-275 | 0.364721 | 0.226639 | 0.000256 | 0.00270824 | 0.00270824
PLATE | PLT16*786.3 | +12.128 | +12.144 | 5 | 99 | 76.1 | 0.6 | 16.5 | 1.3 | 786.3 | 16 | 968.4 | pc-227 | 1.25964 | 0.761478 | 0.000256 | 0.00969989 | 0.0115148
PLATE | PLT16*456 | +12.128 | +12.144 | 5 | 99 | 21.2 | 0.2 | 17.2 | 0.3 | 456 | 16 | 497.1 | pc-275 | 0.364722 | 0.226639 | 0.000256 | 0.00270824 | 0.00270824
PLATE | PLT16*410.1 | +12.128 | +12.144 | 5 | 99 | 19.4 | 0.2 | 17.2 | 0.3 | 410.1 | 16 | 491.3 | pc-276 | 0.33583 | 0.20146 | 0.000256 | 0.00248663 | 0.00248663
PLATE | PLT16*618.1 | +12.128 | +12.144 | 5 | 99 | 36 | 0.3 | 16.9 | 0.6 | 618.1 | 16 | 639.3 | pc-243 | 0.606474 | 0.395187 | 0.000256 | 0.00458246 | 0.00458246
PLATE | PLT16*622 | +12.128 | +12.144 | 5 | 99 | 41.8 | 0.3 | 16.8 | 0.6 | 622 | 16 | 778.5 | pc-400 | 0.70319 | 0.484249 | 0.000256 | 0.00532895 | 0.00532895
PLATE | PLT16*337.2 | +12.128 | +12.144 | 5 | 99 | 16.8 | 0.1 | 17.3 | 0.3 | 337.2 | 16 | 479.5 | pc-272 | 0.290742 | 0.161708 | 0.000256 | 0.00213931 | 0.00213931
2 x PLATE | PLT20*140 | +14.950 | +14.970 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +15.180 | +15.200 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
PLATE | PLT20*140 | +19.116 | +19.136 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT20*140 | +19.452 | +19.472 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
PLATE | PLT20*140 | +19.117 | +19.137 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
PLATE | PLT20*140 | +18.350 | +18.370 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
PLATE | PLT20*140 | +18.580 | +18.600 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
PLATE | PLT20*140 | +17.095 | +17.115 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
PLATE | PLT20*140 | +17.430 | +17.450 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
4 x PLATE | PLT10*238 | +14.956 | +15.194 | 5 | 99 | 4.5 | 0 | 27.6 | 0.1 | 238 | 10 | 238 | pc-133 | 0.122808 | 0.056644 | 0.0001 | 0.00056644 | 0.00056644
2 x PLATE | PLT10*94.5 | +14.614 | +14.792 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +14.489 | +14.925 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*351.3 | +14.599 | +14.950 | 5 | 99 | 14.1 | 0 | 17.5 | 0.2 | 351.3 | 16 | 431.2 | pc-269 | 0.248186 | 0.151481 | 0.000256 | 0.00181277 | 0.00181277
4 x PLATE | PLT10*94.5 | +15.299 | +15.497 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +15.215 | +15.577 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*321.7 | +15.200 | +15.522 | 5 | 99 | 16.2 | 0 | 17.5 | 0.3 | 321.7 | 16 | 511.2 | pc-270 | 0.279945 | 0.164452 | 0.000256 | 0.00204827 | 0.00204827
4 x PLATE | PLT10*94.5 | +16.797 | +16.995 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +16.717 | +17.079 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*321.7 | +16.773 | +17.094 | 5 | 99 | 16.2 | 0 | 17.5 | 0.3 | 321.7 | 16 | 511.2 | pc-270 | 0.279945 | 0.164452 | 0.000256 | 0.00204827 | 0.00204827
