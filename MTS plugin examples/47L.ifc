Properties of the parts of a building model (IFC2X3), part 21 of 22

# IfcElementAssembly (4115)
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Steel Assembly | RIGID_FRAME | 125.2 | +5.500 | +5.700 | C-D/2-3 | 471-B-A61 | 240.974
Steel Assembly | RIGID_FRAME | 46.8 | +5.500 | +5.700 | C-D/2-3 | 471-B-A108 | 337.988
Steel Assembly | RIGID_FRAME | 133.8 | +5.500 | +5.700 | C-D/2-3 | 471-B-A93 | 336.58
2 x Steel Assembly | RIGID_FRAME | 46.7 | +5.500 | +5.700 | C-D/2-3 | 471-B-A111 | 346.838
Steel Assembly | RIGID_FRAME | 46.6 | +5.500 | +5.700 | C-D/2-3 | 471-B-A107 | 346.838
Steel Assembly | RIGID_FRAME | 46.8 | +5.500 | +5.700 | C-D/2-3 | 471-B-A106 | 337.988
Steel Assembly | RIGID_FRAME | 129.1 | +5.500 | +5.700 | C-D/2-3 | 471-B-A92 | 160
Steel Assembly | RIGID_FRAME | 47 | +5.500 | +5.700 | C-D/2-3 | 471-B-A110 | 327.903
Steel Assembly | RIGID_FRAME | 130.2 | +5.500 | +5.700 | C-D/2-3 | 471-B-A94 | 326.494
Steel Assembly | RIGID_FRAME | 28.1 | +5.500 | +5.700 | C-D/2-3 | 471-B-A118 | 455.898
Steel Assembly | RIGID_FRAME | 28.1 | +5.500 | +5.700 | C-D/2-3 | 471-B-A99 | 465.643
Steel Assembly | RIGID_FRAME | 27.9 | +5.500 | +5.700 | C-D/2-3 | 471-B-A97 | 453.536
Steel Assembly | RIGID_FRAME | 27.9 | +5.500 | +5.700 | C-D/2-3 | 471-B-A98 | 447.622
Steel Assembly | RIGID_FRAME | 88.4 | +5.500 | +5.700 | C-D/2-3 | 471-B-A95 | 292.047
Steel Assembly | RIGID_FRAME | 46.6 | +5.500 | +5.700 | C-D/2-3 | 471-B-A109 | 345.692
Steel Assembly | RIGID_FRAME | 27.9 | +5.500 | +5.700 | C-D/2-3 | 471-B-A100 | 446.565
Steel Assembly | RIGID_FRAME | 27.9 | +5.500 | +5.700 | C-D/2-3 | 471-B-A116 | 447.945
2 x Steel Assembly | RIGID_FRAME | 62.6 | +3.050 | +3.250 | A-B/1-2 | 471-D-C242 | 160
Steel Assembly | RIGID_FRAME | 274.3 | +5.256 | +5.449 | C-D/1-2 | 471-B-A204 | 210
Steel Assembly | RIGID_FRAME | 15.1 | +5.513 | +5.593 | C-D/2-3 | 471-B-A155 | 80
Steel Assembly | RIGID_FRAME | 15.8 | +5.513 | +5.593 | C-D/2-3 | 471-B-A154 | 80
Steel Assembly | RIGID_FRAME | 174.2 | +15.702 | +17.692 | D/2-3 | 471-C-B278 | 254
Steel Assembly | RIGID_FRAME | 238.5 | +15.725 | +17.662 | D/2-3 | 471-C-B251 | 219.1
Steel Assembly | RIGID_FRAME | 261.1 | +4.949 | +6.067 | E/3-4 | 471-B-A53 | 190
Steel Assembly | RIGID_FRAME | 284.5 | +14.986 | +16.045 | E/1-2 | 471-C-B39 | 190
2 x Steel Assembly | RIGID_FRAME | 260.6 | +0.175 | +5.319 | E/2-3 | 471-B-A230 | 219.1
Steel Assembly | RIGID_FRAME | 18.4 | +17.863 | +17.943 | C-D/3-4 | 471-C-B156 | 80
Steel Assembly | RIGID_FRAME | 53.6 | +17.850 | +18.050 | C-D/3-4 | 471-C-B66 | 314.617
2 x Steel Assembly | RIGID_FRAME | 18.3 | +17.863 | +17.943 | C-D/3-4 | 471-C-B157 | 80
3 x Steel Assembly | RIGID_FRAME | 20 | +17.863 | +17.943 | C-D/3-4 | 471-C-B158 | 80
Steel Assembly | RIGID_FRAME | 53.2 | +17.850 | +18.050 | C-D/3-4 | 471-C-B101 | 332.719
Steel Assembly | RIGID_FRAME | 53.5 | +17.850 | +18.050 | C-D/3-4 | 471-C-B98 | 323.651
Steel Assembly | RIGID_FRAME | 53.3 | +17.850 | +18.050 | C-D/3-4 | 471-C-B100 | 332.719
Steel Assembly | RIGID_FRAME | 53.5 | +17.850 | +18.050 | C-D/3-4 | 471-C-B99 | 323.651
Steel Assembly | RIGID_FRAME | 53.8 | +17.850 | +18.050 | C-D/3-4 | 471-C-B67 | 305.904
Steel Assembly | RIGID_FRAME | 17.6 | +17.863 | +17.943 | C-D/3-4 | 471-C-B162 | 80
2 x Steel Assembly | RIGID_FRAME | 316.5 | +5.825 | +12.119 | A-B/6 | 471-D-C444 | 219.1
2 x Steel Assembly | RIGID_FRAME | 316.5 | +5.825 | +12.119 | A-B/5 | 471-D-C444 | 219.1
2 x Steel Assembly | RIGID_FRAME | 247.9 | +0.428 | +5.319 | C-D/4 | 471-B-A227 | 219.1
Steel Assembly | RIGID_FRAME | 214.4 | +0.623 | +5.114 | D-E/4 | 471-B-A229 | 219.1
Steel Assembly | RIGID_FRAME | 201.5 | +5.890 | +10.044 | D-E/4 | 471-B-A228 | 219.1
2 x Steel Assembly | RIGID_FRAME | 316.5 | +5.825 | +12.119 | A-B/4 | 471-D-C443 | 219.1
Steel Assembly | RIGID_FRAME | 102.7 | +12.300 | +12.500 | A-B/1-2 | 471-D-C170 | 160
2 x Steel Assembly | RIGID_FRAME | 52.1 | +12.300 | +12.500 | A-B/2-3 | 471-D-C217 | 160
2 x Steel Assembly | RIGID_FRAME | 77.7 | +12.300 | +12.500 | A-B/2-3 | 471-D-C216 | 160
4 x Steel Assembly | RIGID_FRAME | 77.7 | +12.300 | +12.500 | A-B/3-4 | 471-D-C216 | 160
2 x Steel Assembly | RIGID_FRAME | 52.1 | +12.300 | +12.500 | A-B/3-4 | 471-D-C217 | 160
6 x Steel Assembly | RIGID_FRAME | 77.7 | +12.300 | +12.500 | A-B/4-5 | 471-D-C216 | 160
3 x Steel Assembly | RIGID_FRAME | 52.1 | +12.300 | +12.500 | A-B/4-5 | 471-D-C217 | 160
5 x Steel Assembly | RIGID_FRAME | 77.7 | +12.300 | +12.500 | A-B/5-6 | 471-D-C216 | 160
3 x Steel Assembly | RIGID_FRAME | 52.1 | +12.300 | +12.500 | A-B/5-6 | 471-D-C217 | 160
2 x Steel Assembly | RIGID_FRAME | 238.6 | +10.690 | +15.319 | C-D/3 | 471-C-B254 | 219.1
2 x Steel Assembly | RIGID_FRAME | 248.4 | +0.425 | +5.319 | C-D/3 | 471-B-A222 | 219.1
2 x Steel Assembly | RIGID_FRAME | 152.1 | +15.725 | +17.669 | C-D/3 | 471-C-B255 | 219.1
Steel Assembly | RIGID_FRAME | 441.1 | +23.609 | +24.719 | C-D/3 | 471-C-B42 | 190
Steel Assembly | RIGID_FRAME | 227.3 | +24.403 | +28.697 | C-D/3 | 471-E-D190 | 219.1
Steel Assembly | RIGID_FRAME | 227.5 | +24.403 | +28.697 | C-D/3 | 471-E-D191 | 219.1
2 x Steel Assembly | RIGID_FRAME | 316.5 | +5.825 | +12.119 | A-B/3 | 471-D-C443 | 219.1
Steel Assembly | RIGID_FRAME | 179.1 | +17.342 | +18.401 | D-E/3 | 471-C-B45 | 190
Steel Assembly | RIGID_FRAME | 178.4 | +20.754 | +21.809 | D-E/3 | 471-C-B49 | 190
Steel Assembly | RIGID_FRAME | 175.9 | +23.614 | +24.671 | D-E/3 | 471-C-B50 | 190
Steel Assembly | RIGID_FRAME | 142.2 | +21.485 | +23.937 | D-E/3 | 471-C-B272 | 219.1
Steel Assembly | RIGID_FRAME | 119.8 | +24.343 | +26.138 | D-E/3 | 471-E-D194 | 219.1
Steel Assembly | RIGID_FRAME | 106.3 | +18.075 | +19.478 | D-E/3 | 471-C-B271 | 219.1
Steel Assembly | RIGID_FRAME | 102.4 | +19.780 | +21.079 | D-E/3 | 471-C-B270 | 219.1
Steel Assembly | RIGID_FRAME | 135.4 | +10.615 | +12.868 | D-E/3 | 471-C-B269 | 219.1
Steel Assembly | RIGID_FRAME | 124.8 | +15.725 | +17.669 | D-E/3 | 471-C-B267 | 219.1
Steel Assembly | RIGID_FRAME | 131.7 | +5.725 | +7.868 | D-E/3 | 471-B-A238 | 219.1
Steel Assembly | RIGID_FRAME | 128.1 | +8.170 | +10.209 | D-E/3 | 471-B-A237 | 219.1
Steel Assembly | RIGID_FRAME | 134.7 | +0.213 | +2.423 | D-E/3 | 471-B-A236 | 219.1
Steel Assembly | RIGID_FRAME | 145.6 | +2.740 | +5.304 | D-E/3 | 471-B-A235 | 219.1
Steel Assembly | RIGID_FRAME | 176.1 | +14.993 | +16.053 | D-E/3 | 471-C-B43 | 190
Steel Assembly | RIGID_FRAME | 131.9 | +13.170 | +15.319 | D-E/3 | 471-C-B268 | 219.1
Steel Assembly | RIGID_FRAME | 122.1 | +19.152 | +20.105 | D-E/3 | 471-C-B212 | 170
Steel Assembly | RIGID_FRAME | 116 | +7.542 | +8.497 | D-E/3 | 471-B-A185 | 170
Steel Assembly | RIGID_FRAME | 115.4 | +12.543 | +13.496 | D-E/3 | 471-C-B210 | 170
Steel Assembly | RIGID_FRAME | 37.4 | +10.390 | +10.590 | C-D/3-4 | 471-B-A57 | 160
Steel Assembly | RIGID_FRAME | 37.6 | +10.390 | +10.590 | C-D/3-4 | 471-B-A101 | 160
Steel Assembly | RIGID_FRAME | 37.4 | +10.390 | +10.590 | C-D/3-4 | 471-B-A96 | 160
Steel Assembly | RIGID_FRAME | 93.8 | +10.390 | +10.590 | C-D/3-4 | 471-B-A80 | 160
2 x Steel Assembly | RIGID_FRAME | 93.8 | +10.390 | +10.590 | C-D/3-4 | 471-B-A65 | 160
2 x Steel Assembly | RIGID_FRAME | 93.8 | +10.390 | +10.590 | C-D/3-4 | 471-B-A66 | 160
2 x Steel Assembly | RIGID_FRAME | 168.1 | +21.485 | +23.937 | C-D/2 | 471-C-B259 | 219.1
Steel Assembly | RIGID_FRAME | 441.1 | +23.609 | +24.719 | C-D/2 | 471-C-B42 | 190
2 x Steel Assembly | RIGID_FRAME | 185.7 | +18.075 | +21.079 | C-D/2 | 471-C-B258 | 219.1
2 x Steel Assembly | RIGID_FRAME | 227.3 | +24.403 | +28.697 | C-D/2 | 471-E-D185 | 219.1
Steel Assembly | RIGID_FRAME | 64.7 | +10.390 | +10.590 | D-E/3-4 | 471-B-A72 | 160
2 x Steel Assembly | RIGID_FRAME | 152.1 | +15.725 | +17.669 | C-D/2 | 471-C-B255 | 219.1
2 x Steel Assembly | RIGID_FRAME | 238.6 | +10.690 | +15.319 | C-D/2 | 471-C-B254 | 219.1
Steel Assembly | RIGID_FRAME | 64.7 | +10.390 | +10.590 | D-E/1-2 | 471-B-A64 | 160
Steel Assembly | RIGID_FRAME | 64.7 | +10.390 | +10.590 | D-E/1-2 | 471-B-A62 | 160
Steel Assembly | RIGID_FRAME | 102.9 | +10.390 | +10.590 | C-D/1-2 | 471-B-A78 | 170
Steel Assembly | RIGID_FRAME | 102.7 | +10.390 | +10.590 | C-D/1-2 | 471-B-A75 | 160.008
Steel Assembly | RIGID_FRAME | 102.7 | +10.390 | +10.590 | C-D/1-2 | 471-B-A67 | 160
Steel Assembly | RIGID_FRAME | 102.7 | +10.390 | +10.590 | C-D/1-2 | 471-B-A91 | 160
Steel Assembly | RIGID_FRAME | 15.8 | +10.403 | +10.483 | C-D/2-3 | 471-B-A159 | 80
Steel Assembly | RIGID_FRAME | 15.1 | +10.403 | +10.483 | C-D/2-3 | 471-B-A160 | 80
4 x Steel Assembly | RIGID_FRAME | 17.5 | +10.403 | +10.483 | C-D/2-3 | 471-B-A144 | 80
2 x Steel Assembly | RIGID_FRAME | 14.6 | +10.403 | +10.483 | C-D/2-3 | 471-B-A161 | 80
2 x Steel Assembly | RIGID_FRAME | 231.1 | +5.790 | +10.209 | C-D/2 | 471-B-A223 | 219.1
Steel Assembly | RIGID_FRAME | 17.1 | +10.403 | +10.483 | C-D/2-3 | 471-B-A153 | 80
Steel Assembly | RIGID_FRAME | 17.5 | +10.403 | +10.483 | C-D/2-3 | 471-B-A152 | 80
2 x Steel Assembly | RIGID_FRAME | 17.6 | +10.403 | +10.483 | C-D/2-3 | 471-B-A146 | 80
4 x Steel Assembly | RIGID_FRAME | 40.1 | +10.390 | +10.590 | C-D/2-3 | 471-B-A200 | 135.765
Steel Assembly | RIGID_FRAME | 133.8 | +10.390 | +10.590 | C-D/2-3 | 471-B-A93 | 336.58
3 x Steel Assembly | RIGID_FRAME | 16.3 | +10.403 | +10.483 | C-D/2-3 | 471-B-A151 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +10.403 | +10.483 | C-D/2-3 | 471-B-A150 | 80
Steel Assembly | RIGID_FRAME | 17.1 | +10.403 | +10.483 | C-D/2-3 | 471-B-A149 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +10.403 | +10.483 | C-D/2-3 | 471-B-A145 | 80
Steel Assembly | RIGID_FRAME | 115.4 | +12.543 | +13.496 | D-E/2 | 471-C-B210 | 170
Steel Assembly | RIGID_FRAME | 131.9 | +13.170 | +15.319 | D-E/2 | 471-C-B268 | 219.1
Steel Assembly | RIGID_FRAME | 119.8 | +24.343 | +26.138 | D-E/2 | 471-E-D194 | 219.1
Steel Assembly | RIGID_FRAME | 142.2 | +21.485 | +23.937 | D-E/2 | 471-C-B272 | 219.1
Steel Assembly | RIGID_FRAME | 175.9 | +23.614 | +24.671 | D-E/2 | 471-C-B51 | 190
Steel Assembly | RIGID_FRAME | 102.4 | +19.780 | +21.079 | D-E/2 | 471-C-B270 | 219.1
Steel Assembly | RIGID_FRAME | 178.4 | +20.754 | +21.809 | D-E/2 | 471-C-B47 | 190
Steel Assembly | RIGID_FRAME | 106.3 | +18.075 | +19.478 | D-E/2 | 471-C-B271 | 219.1
Steel Assembly | RIGID_FRAME | 122.1 | +19.152 | +20.105 | D-E/2 | 471-C-B211 | 170
Steel Assembly | RIGID_FRAME | 124.8 | +15.725 | +17.669 | D-E/2 | 471-C-B267 | 219.1
Steel Assembly | RIGID_FRAME | 135.4 | +10.615 | +12.868 | D-E/2 | 471-C-B269 | 219.1
Steel Assembly | RIGID_FRAME | 128.1 | +8.170 | +10.209 | D-E/2 | 471-B-A237 | 219.1
Steel Assembly | RIGID_FRAME | 131.7 | +5.725 | +7.868 | D-E/2 | 471-B-A238 | 219.1
Steel Assembly | RIGID_FRAME | 116 | +7.542 | +8.497 | D-E/2 | 471-B-A185 | 170
Steel Assembly | RIGID_FRAME | 145.6 | +2.740 | +5.304 | D-E/2 | 471-B-A235 | 219.1
Steel Assembly | RIGID_FRAME | 115.7 | +2.097 | +3.062 | D-E/2 | 471-B-A183 | 170
Steel Assembly | RIGID_FRAME | 134.7 | +0.213 | +2.423 | D-E/2 | 471-B-A236 | 219.1
Steel Assembly | RIGID_FRAME | 64.7 | +5.500 | +5.700 | D-E/1-2 | 471-B-A83 | 160
2 x Steel Assembly | RIGID_FRAME | 57.9 | +5.500 | +5.700 | A-B/1-2 | 471-D-C210 | 160
3 x Steel Assembly | RIGID_FRAME | 30.4 | +5.500 | +5.700 | A-B/2-3 | 471-D-C215 | 160
Steel Assembly | RIGID_FRAME | 71.4 | +5.500 | +5.700 | A-B/2-3 | 471-D-C232 | 160
2 x Steel Assembly | RIGID_FRAME | 316.5 | +5.825 | +12.119 | A-B/2 | 471-D-C443 | 219.1
Steel Assembly | RIGID_FRAME | 102.7 | +5.500 | +5.700 | B-C/1-2 | 471-D-C254 | 160
Steel Assembly | RIGID_FRAME | 102.7 | +5.500 | +5.700 | B-C/1-2 | 471-D-C260 | 160
Steel Assembly | RIGID_FRAME | 38.5 | +5.500 | +5.700 | C-D/3-4 | 471-B-A70 | 160
3 x Steel Assembly | RIGID_FRAME | 17.6 | +5.513 | +5.593 | C-D/2-3 | 471-B-A146 | 80
4 x Steel Assembly | RIGID_FRAME | 40.1 | +5.500 | +5.700 | C-D/2-3 | 471-B-A200 | 135.765
Steel Assembly | RIGID_FRAME | 173.2 | +5.500 | +5.700 | C-D/2-3 | 471-B-A90 | 447.925
2 x Steel Assembly | RIGID_FRAME | 102.2 | +0.425 | +2.369 | C-D/2 | 471-B-A224 | 219.1
2 x Steel Assembly | RIGID_FRAME | 131.9 | +2.775 | +5.319 | C-D/2 | 471-B-A243 | 219.1
Steel Assembly | RIGID_FRAME | 17.1 | +5.513 | +5.593 | C-D/2-3 | 471-B-A149 | 80
2 x Steel Assembly | RIGID_FRAME | 15.8 | +5.513 | +5.593 | C-D/2-3 | 471-B-A148 | 80
5 x Steel Assembly | RIGID_FRAME | 17.5 | +5.513 | +5.593 | C-D/2-3 | 471-B-A144 | 80
4 x Steel Assembly | RIGID_FRAME | 16.3 | +5.513 | +5.593 | C-D/2-3 | 471-B-A151 | 80
Steel Assembly | RIGID_FRAME | 17.1 | +5.513 | +5.593 | C-D/2-3 | 471-B-A153 | 80
Steel Assembly | RIGID_FRAME | 17.5 | +5.513 | +5.593 | C-D/2-3 | 471-B-A152 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +5.513 | +5.593 | C-D/2-3 | 471-B-A150 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +5.513 | +5.593 | C-D/2-3 | 471-B-A145 | 80
4 x Steel Assembly | RIGID_FRAME | 102.7 | +5.500 | +5.700 | C-D/1-2 | 471-B-A77 | 160
Steel Assembly | RIGID_FRAME | 102.7 | +5.500 | +5.700 | C-D/1-2 | 471-B-A75 | 160.008
Steel Assembly | RIGID_FRAME | 93.8 | +5.500 | +5.700 | C-D/3-4 | 471-B-A84 | 160
3 x Steel Assembly | RIGID_FRAME | 93.8 | +5.500 | +5.700 | C-D/3-4 | 471-B-A80 | 160
3 x Steel Assembly | RIGID_FRAME | 20 | +5.513 | +5.593 | C-D/4-5 | 471-B-A142 | 80
Steel Assembly | RIGID_FRAME | 53.5 | +5.500 | +5.700 | C-D/4-5 | 471-B-A68 | 246.342
Steel Assembly | RIGID_FRAME | 53.2 | +5.500 | +5.700 | C-D/4-5 | 471-B-A103 | 332.719
Steel Assembly | RIGID_FRAME | 53.3 | +5.500 | +5.700 | C-D/4-5 | 471-B-A102 | 332.719
Steel Assembly | RIGID_FRAME | 53.5 | +5.500 | +5.700 | C-D/4-5 | 471-B-A104 | 323.651
Steel Assembly | RIGID_FRAME | 18.3 | +5.513 | +5.593 | C-D/4-5 | 471-B-A143 | 80
Steel Assembly | RIGID_FRAME | 18.8 | +5.513 | +5.593 | C-D/4-5 | 471-B-A141 | 80
Steel Assembly | RIGID_FRAME | 9.2 | +5.614 | +5.700 | C-D/4 | 471-B-A139 | 160
Steel Assembly | RIGID_FRAME | 8.9 | +5.614 | +5.700 | C-D/4 | 471-B-A136 | 160
Steel Assembly | RIGID_FRAME | 9.2 | +5.614 | +5.700 | C-D/4-5 | 471-B-A138 | 160
Steel Assembly | RIGID_FRAME | 8.9 | +5.614 | +5.700 | C-D/4-5 | 471-B-A137 | 160
5 x Steel Assembly | RIGID_FRAME | 158.5 | +2.498 | +2.750 | B-C/2-3 | 471-D-C351 | 160
2 x Steel Assembly | RIGID_FRAME | 158.5 | +2.498 | +2.750 | B-C/3-4 | 471-D-C351 | 160
Steel Assembly | RIGID_FRAME | 979.5 | +12.002 | +18.050 | E/1 | 471-C-B238 | 310.6
Steel Assembly | RIGID_FRAME | 258.7 | +15.725 | +17.669 | C-D/1 | 471-C-B273 | 219.1
Steel Assembly | RIGID_FRAME | 907.7 | +6.702 | +15.700 | B/1 | 471-D-C152 | 304.8
Steel Assembly | RIGID_FRAME | 124.8 | +15.725 | +17.669 | D-E/1 | 471-C-B264 | 219.1
Steel Assembly | RIGID_FRAME | 334.1 | +10.615 | +15.319 | C-D/1 | 471-C-B263 | 219.1
Steel Assembly | RIGID_FRAME | 224.5 | +2.138 | +2.394 | B-C/RACK1-2 | 471-D-C370 | 146.4
2 x Steel Assembly | RIGID_FRAME | 224.5 | +2.138 | +2.394 | C-D/RACK1-2 | 471-B-A199 | 146.4
Steel Assembly | RIGID_FRAME | 164.4 | +2.775 | +5.319 | B-C/1 | 471-D-C430 | 219.1
Steel Assembly | RIGID_FRAME | 164.2 | +2.775 | +5.319 | B-C/1 | 471-D-C431 | 219.1
Steel Assembly | RIGID_FRAME | 86 | +7.698 | +7.950 | A-B/1-2 | 471-D-C348 | 146.1
2 x Steel Assembly | RIGID_FRAME | 171.2 | +2.775 | +5.319 | C-D/1 | 471-B-A232 | 219.1
Steel Assembly | RIGID_FRAME | 201.7 | +5.890 | +10.049 | D-E/1 | 471-B-A226 | 219.1
Steel Assembly | RIGID_FRAME | 209.2 | +10.790 | +15.144 | D-E/1 | 471-C-B265 | 219.1
Steel Assembly | RIGID_FRAME | 149.1 | +2.631 | +5.294 | D-E/1 | 471-B-A234 | 219.1
Steel Assembly | RIGID_FRAME | 138.7 | +0.228 | +2.546 | D-E/1 | 471-B-A233 | 219.1
Steel Assembly | RIGID_FRAME | 34.4 | +2.570 | +2.750 | A-B/1-2 | 471-D-C372 | 85
Steel Assembly | RIGID_FRAME | 28.7 | +2.750 | +3.250 | B/1-2 | 471-D-C353 | 220
2 x Steel Assembly | RIGID_FRAME | 827.5 | +3.550 | +12.090 | A-B/RACK1 | 471-0-010012 | 304.8
Steel Assembly | RIGID_FRAME | 827.5 | +3.550 | +12.090 | B-C/RACK1 | 471-0-010010 | 304.8
Steel Assembly | RIGID_FRAME | 827.5 | +3.550 | +12.090 | C-D/RACK1 | 471-0-010011 | 304.8
Steel Assembly | RIGID_FRAME | 827.5 | +3.550 | +12.090 | E/RACK1 | 471-0-010009 | 304.8
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | E/3 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | D/3 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | C/3 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | C/2 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | D/2 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | E/2 | 471-0-010032 | 750
8 x Steel Assembly | RIGID_FRAME | 4415.6 | -1.330 | -0.330 | C-D/2-3 | 471-0-010031 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | B/6 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | B/5 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | B/4 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | C/4 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | D/4 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | E/4 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | A/6 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | A/5 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | A/4 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | A/3 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | E/1 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | D/1 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | C/1 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | B/1 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | A/1 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | B/2 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | B/3 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 5740.3 | -1.330 | -0.030 | A/2 | 471-0-010032 | 750
Steel Assembly | RIGID_FRAME | 7850 | -1.830 | -0.830 | A-B/1 | 10012 | 400
Steel Assembly | RIGID_FRAME | 18840 | -1.830 | -0.830 | B/5-6 | 10011 | 400
Steel Assembly | RIGID_FRAME | 27318 | -1.830 | -0.830 | A-B/6 | 10007 | 400
Steel Assembly | RIGID_FRAME | 18840 | -1.830 | -0.830 | A/5-6 | 10011 | 400
Steel Assembly | RIGID_FRAME | 18840 | -1.830 | -0.830 | A/4-5 | 10011 | 400
Steel Assembly | RIGID_FRAME | 12560 | -1.830 | -0.830 | A/3-4 | 10010 | 400
Steel Assembly | RIGID_FRAME | 21980 | -1.830 | -0.830 | A/2-3 | 10009 | 400
Steel Assembly | RIGID_FRAME | 18840 | -1.830 | -0.830 | B/4-5 | 10011 | 400
Steel Assembly | RIGID_FRAME | 12560 | -1.830 | -0.830 | B/3-4 | 10010 | 400
Steel Assembly | RIGID_FRAME | 13816 | -1.830 | -0.830 | B/1-2 | 10000 | 400
Steel Assembly | RIGID_FRAME | 21980 | -1.830 | -0.830 | B/2-3 | 10009 | 400
Steel Assembly | RIGID_FRAME | 9106 | -1.830 | -0.830 | A-B/2 | 10008 | 400
Steel Assembly | RIGID_FRAME | 27318 | -1.830 | -0.830 | A-B/3 | 10007 | 400
Steel Assembly | RIGID_FRAME | 27318 | -1.830 | -0.830 | A-B/4 | 10007 | 400
Steel Assembly | RIGID_FRAME | 27318 | -1.830 | -0.830 | A-B/5 | 10007 | 400
Steel Assembly | RIGID_FRAME | 11775 | -1.830 | -0.830 | B-C/3 | 10006 | 400
Steel Assembly | RIGID_FRAME | 11775 | -1.830 | -0.830 | B-C/2 | 10006 | 400
Steel Assembly | RIGID_FRAME | 17238.6 | -1.830 | -0.830 | C-D/4 | 10005 | 400
Steel Assembly | RIGID_FRAME | 17238.6 | -1.830 | -0.830 | C-D/1 | 10005 | 400
Steel Assembly | RIGID_FRAME | 18039.3 | -1.830 | -0.830 | B-C/4 | 10004 | 400
Steel Assembly | RIGID_FRAME | 18039.3 | -1.830 | -0.830 | B-C/1 | 10004 | 400
Steel Assembly | RIGID_FRAME | 16014 | -1.830 | -0.830 | A-B/2 | 10003 | 400
Steel Assembly | RIGID_FRAME | 19468 | -1.830 | -0.830 | A-B/1 | 10002 | 400
Steel Assembly | RIGID_FRAME | 13816 | -1.830 | -0.830 | A-B/1-2 | 10000 | 400
Steel Assembly | RIGID_FRAME | 961.6 | -1.030 | -0.030 | A-B/1-2 | 471-0-010013 | 350
Steel Assembly | RIGID_FRAME | 961.6 | -1.030 | -0.030 | A-B/2 | 471-0-010013 | 350
Steel Assembly | RIGID_FRAME | 2198 | -1.830 | -0.830 | A-B/2 | 10001 | 400
Steel Assembly | RIGID_FRAME | 13816 | -1.830 | -0.830 | A/1-2 | 10000 | 400
Steel Assembly | RIGID_FRAME | 961.6 | -1.030 | -0.030 | A-B/1 | 471-0-010013 | 350

# IfcMechanicalFastener: Bolt assembly (7470)
In: Undefined
Tekla Bolt - Washer type: FLAT-E; Slotted hole x: 0 mm; Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material = Bolt standard | Washer count | Washer name | Nut count | Nut type | Nut name | Slotted hole y (mm) | Bolt hole diameter (mm) | Bolt count | Bolt Name
1109 x Bolt assembly | 20 | 50 | 8.8XOX | 4 | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 4 | BOLTM20*50
222 x Bolt assembly | 20 | 55 | 8.8XOX | 4 | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 4 | BOLTM20*55
250 x Bolt assembly | 20 | 50 | 8.8XOX | 2 | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 2 | BOLTM20*50
1001 x Bolt assembly | 20 | 45 | 8.8XOX | 2 | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 2 | BOLTM20*45
10 x Bolt assembly | 24 | 70 | 8.8XOX | 6 | WASHERM24-FLAT-E | 6 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 6 | BOLTM24*70
7 x Bolt assembly | 24 | 80 | 8.8XOX | 6 | WASHERM24-FLAT-E | 6 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 6 | BOLTM24*80
3 x Bolt assembly | 16 | 40 | 8.8XOX | 2 | WASHERM16-FLAT-E | 2 | GR8-HEX | NUTM16-GR8-HEX | 0 | 18 | 2 | BOLTM16*40
48 x Bolt assembly | 16 | 40 | 8.8XOX | 4 | WASHERM16-FLAT-E | 4 | GR8-HEX | NUTM16-GR8-HEX | 0 | 18 | 4 | BOLTM16*40
137 x Bolt assembly | 12 | 6.8 | 8.8XOX | 0 | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 14 | 4 | BOLTM12*25
309 x Bolt assembly | 20 | 65 | 8.8XOX | 4 | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 4 | BOLTM20*65
10 x Bolt assembly | 24 | 60 | 8.8XOX | 6 | WASHERM24-FLAT-E | 6 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 6 | BOLTM24*60
7 x Bolt assembly | 24 | 60 | 8.8XOX | 2 | WASHERM24-FLAT-E | 2 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 2 | BOLTM24*60
Bolt assembly | 24 | 80 | 8.8XOX | 2 | WASHERM24-FLAT-E | 2 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 2 | BOLTM24*80
9 x Bolt assembly | 24 | 80 | 8.8XOX | 4 | WASHERM24-FLAT-E | 4 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 4 | BOLTM24*80
366 x Bolt assembly | 20 | 60 | 8.8XOX | 4 | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 4 | BOLTM20*60
5 x Bolt assembly | 20 | 45 | 8.8XOX | 4 | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 4 | BOLTM20*45
748 x Bolt assembly | 16 | 40 | 4.8XOX | 2 | WASHERM16-FLAT-E | 2 | GR4-HEX | NUTM16-GR4-HEX | 0 | 18 | 2 | BOLTM16*40
42 x Bolt assembly | 20 | 55 | 8.8XOX | 6 | WASHERM20-FLAT-E | 6 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 6 | BOLTM20*55
50 x Bolt assembly | 20 | 55 | 8.8XOX | 2 | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 2 | BOLTM20*55
45 x Bolt assembly | 20 | 90 | 8.8XOX | 6 | WASHERM20-FLAT-E | 6 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 6 | BOLTM20*90
13 x Bolt assembly | 30 | 100 | 8.8XOX | 6 | WASHERM30-FLAT-E | 6 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 6 | BOLTM30*100
3 x Bolt assembly | 20 | 40 | 8.8XOX | 4 | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 4 | BOLTM20*40
3 x Bolt assembly | 16 | 45 | 8.8XOX | 2 | WASHERM16-FLAT-E | 2 | GR8-HEX | NUTM16-GR8-HEX | 0 | 18 | 2 | BOLTM16*45
13 x Bolt assembly | 20 | 55 | 8.8XOX | 3 | WASHERM20-FLAT-E | 3 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 3 | BOLTM20*55
5 x Bolt assembly | 20 | 50 | 8.8XOX | 3 | WASHERM20-FLAT-E | 3 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 3 | BOLTM20*50
320 x Bolt assembly | 24 | 65 | 8.8XOX | 4 | WASHERM24-FLAT-E | 4 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 4 | BOLTM24*65
170 x Bolt assembly | 30 | 70 | 8.8XOX | 4 | WASHERM30-FLAT-E | 4 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 4 | BOLTM30*70
16 x Bolt assembly | 30 | 70 | 8.8XOX | 6 | WASHERM30-FLAT-E | 6 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 6 | BOLTM30*70
24 x Bolt assembly | 20 | 65 | 8.8XOX | 14 | WASHERM20-FLAT-E | 14 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 14 | BOLTM20*65
44 x Bolt assembly | 20 | 65 | 8.8XOX | 10 | WASHERM20-FLAT-E | 10 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 10 | BOLTM20*65
9 x Bolt assembly | 30 | 80 | 8.8XOX | 14 | WASHERM30-FLAT-E | 14 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 14 | BOLTM30*80
5 x Bolt assembly | 30 | 80 | 8.8XOX | 10 | WASHERM30-FLAT-E | 10 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 10 | BOLTM30*80
7 x Bolt assembly | 30 | 90 | 8.8XOX | 10 | WASHERM30-FLAT-E | 10 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 10 | BOLTM30*90
250 x Bolt assembly | 16 | 45 | 4.8XOX | 2 | WASHERM16-FLAT-E | 2 | GR4-HEX | NUTM16-GR4-HEX | 0 | 18 | 2 | BOLTM16*45
14 x Bolt assembly | 20 | 65 | 8.8XOX | 2 | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 2 | BOLTM20*65
113 x Bolt assembly | 20 | 65 | 8.8XOX | 6 | WASHERM20-FLAT-E | 6 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 6 | BOLTM20*65
3 x Bolt assembly | 30 | 80 | 8.8XOX | 12 | WASHERM30-FLAT-E | 12 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 12 | BOLTM30*80
11 x Bolt assembly | 30 | 90 | 8.8XOX | 6 | WASHERM30-FLAT-E | 6 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 6 | BOLTM30*90
8 x Bolt assembly | 30 | 70 | 8.8XOX | 8 | WASHERM30-FLAT-E | 8 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 8 | BOLTM30*70
4 x Bolt assembly | 20 | 60 | 8.8XOX | 2 | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 2 | BOLTM20*60
Bolt assembly | 20 | 75 | 8.8XOX | 2 | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 2 | BOLTM20*80
33 x Bolt assembly | 24 | 75 | 8.8XOX | 6 | WASHERM24-FLAT-E | 6 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 6 | BOLTM24*80
28 x Bolt assembly | 20 | 45 | 8.8XOX | 1 | WASHERM20-FLAT-E | 1 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 1 | BOLTM20*45
14 x Bolt assembly | 20 | 10 | 8.8XOX | 0 | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 1 | BOLTM20*40
44 x Bolt assembly | 24 | 6 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 1 | BOLTM24*50
22 x Bolt assembly | 24 | 49 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 1 | BOLTM24*50
6 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 31 | BOLTM24*50
2 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 28 | BOLTM24*50
13 x Bolt assembly | 16 | 45 | 8.8XOX | 4 | WASHERM16-FLAT-E | 4 | GR8-HEX | NUTM16-GR8-HEX | 0 | 18 | 4 | BOLTM16*45
5 x Bolt assembly | 16 | 50 | 8.8XOX | 2 | WASHERM16-FLAT-E | 2 | GR8-HEX | NUTM16-GR8-HEX | 0 | 18 | 2 | BOLTM16*50
11 x Bolt assembly | 20 | 55 | 8.8XOX | 1 | WASHERM20-FLAT-E | 1 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 1 | BOLTM20*55
4 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 11 | BOLTM24*50
4 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 12 | BOLTM24*50
8 x Bolt assembly | 20 | 11.5 | 8.8XOX | 0 | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 24 | 4 | BOLTM20*40
24 x Bolt assembly | 20 | 11.5 | 8.8XOX | 0 | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 24 | 2 | BOLTM20*40
63 x Bolt assembly | 20 | 65 | 8.8XOX | 8 | WASHERM20-FLAT-E | 8 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 8 | BOLTM20*65
Bolt assembly | 24 | 90 | 8.8XOX | 2 | WASHERM24-FLAT-E | 2 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 2 | BOLTM24*90
5 x Bolt assembly | 24 | 65 | 8.8XOX | 6 | WASHERM24-FLAT-E | 6 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 6 | BOLTM24*65
152 x Bolt assembly | 24 | 90 | 8.8XOX | 4 | WASHERM24-FLAT-E | 4 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 4 | BOLTM24*90
15 x Bolt assembly | 24 | 70 | 8.8XOX | 8 | WASHERM24-FLAT-E | 8 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 8 | BOLTM24*70
20 x Bolt assembly | 20 | 60 | 8.8XOX | 6 | WASHERM20-FLAT-E | 6 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 6 | BOLTM20*60
7 x Bolt assembly | 24 | 90 | 8.8XOX | 6 | WASHERM24-FLAT-E | 6 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 6 | BOLTM24*90
2 x Bolt assembly | 20 | 90 | 8.8XOX | 10 | WASHERM20-FLAT-E | 10 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 10 | BOLTM20*90
9 x Bolt assembly | 24 | 75 | 8.8XOX | 8 | WASHERM24-FLAT-E | 8 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 8 | BOLTM24*80
2 x Bolt assembly | 24 | 90 | 8.8XOX | 10 | WASHERM24-FLAT-E | 10 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 10 | BOLTM24*90
2 x Bolt assembly | 24 | 65 | 8.8XOX | 10 | WASHERM24-FLAT-E | 10 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 10 | BOLTM24*65
5 x Bolt assembly | 30 | 100 | 8.8XOX | 8 | WASHERM30-FLAT-E | 8 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 8 | BOLTM30*100
29 x Bolt assembly | 20 | 70 | 8.8XOX | 6 | WASHERM20-FLAT-E | 6 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 6 | BOLTM20*70
12 x Bolt assembly | 20 | 60 | 8.8XOX | 8 | WASHERM20-FLAT-E | 8 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 8 | BOLTM20*60
13 x Bolt assembly | 20 | 60 | 8.8XOX | 10 | WASHERM20-FLAT-E | 10 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 10 | BOLTM20*60
7 x Bolt assembly | 20 | 60 | 8.8XOX | 14 | WASHERM20-FLAT-E | 14 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 14 | BOLTM20*60
3 x Bolt assembly | 30 | 70 | 8.8XOX | 10 | WASHERM30-FLAT-E | 10 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 10 | BOLTM30*70
2 x Bolt assembly | 36 | 80 | 8.8XOX | 10 | WASHERM36-FLAT-E | 10 | GR8-HEX | NUTM36-GR8-HEX | 0 | 38 | 10 | BOLTM36*80
Bolt assembly | 24 | 75 | 8.8XOX | 4 | WASHERM24-FLAT-E | 4 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 4 | BOLTM24*80
10 x Bolt assembly | 30 | 80 | 8.8XOX | 6 | WASHERM30-FLAT-E | 6 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 6 | BOLTM30*80
35 x Bolt assembly | 20 | 75 | 8.8XOX | 6 | WASHERM20-FLAT-E | 6 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 6 | BOLTM20*80
25 x Bolt assembly | 20 | 75 | 8.8XOX | 14 | WASHERM20-FLAT-E | 14 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 14 | BOLTM20*80
12 x Bolt assembly | 20 | 70 | 8.8XOX | 12 | WASHERM20-FLAT-E | 12 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 12 | BOLTM20*70
10 x Bolt assembly | 20 | 65 | 8.8XOX | 12 | WASHERM20-FLAT-E | 12 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 12 | BOLTM20*65
20 x Bolt assembly | 20 | 75 | 8.8XOX | 10 | WASHERM20-FLAT-E | 10 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 10 | BOLTM20*80
21 x Bolt assembly | 20 | 70 | 8.8XOX | 4 | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 4 | BOLTM20*70
5 x Bolt assembly | 20 | 70 | 8.8XOX | 2 | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 2 | BOLTM20*70
3 x Bolt assembly | 20 | 55 | 8.8XOX | 8 | WASHERM20-FLAT-E | 8 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 8 | BOLTM20*55
11 x Bolt assembly | 20 | 50 | 8.8XOX | 1 | WASHERM20-FLAT-E | 1 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 1 | BOLTM20*50
9 x Bolt assembly | 16 | 50 | 8.8XOX | 4 | WASHERM16-FLAT-E | 4 | GR8-HEX | NUTM16-GR8-HEX | 0 | 18 | 4 | BOLTM16*50
8 x Bolt assembly | 20 | 40 | 8.8XOX | 1 | WASHERM20-FLAT-E | 1 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 1 | BOLTM20*40
2 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 29 | BOLTM24*50
2 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 34 | BOLTM24*50
2 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 20 | BOLTM24*50
2 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 30 | BOLTM24*50
2 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 26 | BOLTM24*50
6 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 25 | BOLTM24*50
2 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 15 | BOLTM24*50
2 x Bolt assembly | 20 | 50 | 8.8XOX | 8 | WASHERM20-FLAT-E | 8 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 8 | BOLTM20*50
838 x Bolt assembly | 12 | 35 | 8.8XOX | 2 | WASHERM12-FLAT-E | 2 | GR8-HEX | NUTM12-GR8-HEX | 0 | 14 | 2 | BOLTM12*35
4 x Bolt assembly | 16 | 45 | 8.8XOX | 1 | WASHERM16-FLAT-E | 1 | GR8-HEX | NUTM16-GR8-HEX | 0 | 18 | 1 | BOLTM16*45
14 x Bolt assembly | 20 | 75 | 8.8XOX | 8 | WASHERM20-FLAT-E | 8 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 8 | BOLTM20*80
48 x Bolt assembly | 24 | 100 | 8.8XOX | 4 | WASHERM24-FLAT-E | 4 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 4 | BOLTM24*100
128 x Bolt assembly | 30 | 110 | 8.8XOX | 4 | WASHERM30-FLAT-E | 4 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 4 | BOLTM30*110
32 x Bolt assembly | 24 | 90 | 8.8XOX | 8 | WASHERM24-FLAT-E | 8 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 8 | BOLTM24*90
2 x Bolt assembly | 12 | 10 | 8.8XOX | 0 | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 14 | 2 | BOLTM12*25
4 x Bolt assembly | 30 | 90 | 8.8XOX | 8 | WASHERM30-FLAT-E | 8 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 8 | BOLTM30*90
3 x Bolt assembly | 30 | 80 | 8.8XOX | 8 | WASHERM30-FLAT-E | 8 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 8 | BOLTM30*80
4 x Bolt assembly | 20 | 10.9 | 8.8XOX | 0 | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 2 | BOLTM20*40
2 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 6 | BOLTM24*50
4 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 16 | BOLTM24*50
30 x Bolt assembly | 20 | 60 | 8.8XOX | 4 | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 50 | 22 | 4 | BOLTM20*60
15 x Bolt assembly | 20 | 65 | 8.8XOX | 4 | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 50 | 22 | 4 | BOLTM20*65
Bolt assembly | 20 | 60 | 8.8XOX | 12 | WASHERM20-FLAT-E | 12 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 12 | BOLTM20*60
7 x Bolt assembly | 30 | 80 | 8.8XOX | 4 | WASHERM30-FLAT-E | 4 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 4 | BOLTM30*80
3 x Bolt assembly | 20 | 12 | 8.8XOX | 0 | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 24 | 4 | BOLTM20*40
12 x Bolt assembly | 24 | 25 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 30 | 4 | BOLTM24*50
96 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 1 | BOLTM24*50
12 x Bolt assembly | 24 | 40 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 30 | 4 | BOLTM24*50
2 x Bolt assembly | 24 | 10 | 8.8XOX | 0 | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 26 | 36 | BOLTM24*50
2 x Bolt assembly | 30 | 80 | 8.8XOX | 16 | WASHERM30-FLAT-E | 16 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 16 | BOLTM30*80
Bolt assembly | 20 | 90 | 8.8XOX | 4 | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 4 | BOLTM20*90
2 x Bolt assembly | 20 | 75 | 8.8XOX | 16 | WASHERM20-FLAT-E | 16 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 16 | BOLTM20*80
Bolt assembly | 20 | 75 | 8.8XOX | 4 | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 4 | BOLTM20*80
5 x Bolt assembly | 30 | 90 | 8.8XOX | 12 | WASHERM30-FLAT-E | 12 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 12 | BOLTM30*90
Bolt assembly | 30 | 90 | 8.8XOX | 14 | WASHERM30-FLAT-E | 14 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 14 | BOLTM30*90
8 x Bolt assembly | 20 | 55 | 8.8XOX | 4 | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 2 | BOLTM20*55
Bolt assembly | 30 | 90 | 8.8XOX | 4 | WASHERM30-FLAT-E | 4 | GR8-HEX | NUTM30-GR8-HEX | 0 | 32 | 4 | BOLTM30*90
Bolt assembly | 20 | 70 | 8.8XOX | 8 | WASHERM20-FLAT-E | 8 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 8 | BOLTM20*70
Bolt assembly | 20 | 70 | 8.8XOX | 10 | WASHERM20-FLAT-E | 10 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 10 | BOLTM20*70
Bolt assembly | 12 | 40 | 4.8XOX | 2 | WASHERM12-FLAT-E | 2 | GR4-HEX | NUTM12-GR4-HEX | 0 | 14 | 2 | BOLTM12*40
7 x Bolt assembly | 12 | 40 | 4.8XOX | 4 | WASHERM12-FLAT-E | 2 | GR4-HEX | NUTM12-GR4-HEX | 0 | 14 | 2 | BOLTM12*40
2 x Bolt assembly | 16 | 45 | 8.8XOX | 8 | WASHERM16-FLAT-E | 4 | GR8-HEX | NUTM16-GR8-HEX | 0 | 18 | 4 | BOLTM16*45
3 x Bolt assembly | 20 | 75 | 8.8XOX | 12 | WASHERM20-FLAT-E | 12 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 12 | BOLTM20*80
Bolt assembly | 20 | 60 | 8.8XOX | 8 | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 22 | 4 | BOLTM20*60

# IfcMember: CHS219.1*8.0 (260)
In: Undefined
Description: CHS219.1*8.0; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 16.5 m2; Height: 219.1 mm; Width: 219.1 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00529936 m2
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
BRACE | +0.573 | +2.276 | 5 | 1 | 78.3 | 1.3 | 1881.2 | mc-443 | 1881.2 | 1.29488 | 0.00978086 | 0.00996918 | 76.7798 | 78.2581
BRACE | +0.222 | +2.296 | 5 | 1 | 107.7 | 1.7 | 2588 | mc-442 | 2588.01 | 1.78139 | 0.0134994 | 0.0137148 | 105.971 | 107.661
BRACE | +2.950 | +5.060 | 5 | 1 | 87.5 | 1.5 | 2103.4 | mc-441 | 2103.39 | 1.44781 | 0.0109498 | 0.0111466 | 85.9559 | 87.5009
BRACE | +2.950 | +5.024 | 5 | 1 | 86.1 | 1.5 | 2068.9 | mc-440 | 2068.92 | 1.42409 | 0.0107685 | 0.010964 | 84.5324 | 86.0671
BRACE | +5.948 | +12.130 | 5 | 1 | 261.9 | 4.3 | 6296.8 | mc-439 | 6296.8 | 4.33423 | 0.0330118 | 0.033369 | 259.143 | 261.947
BRACE | +66.489 | +70.150 | 8 | 1 | 161.4 | 2.7 | 3879.5 | mf-326 | 3879.49 | 2.67034 | 0.0202941 | 0.0205588 | 159.308 | 161.387
BRACE | +63.665 | +65.679 | 8 | 1 | 97.8 | 1.6 | 2350.6 | mf-324 | 2350.56 | 1.61794 | 0.0122502 | 0.0124565 | 96.164 | 97.7833
BRACE | +58.264 | +62.851 | 8 | 1 | 198 | 3.3 | 4760.1 | mf-322 | 4760.12 | 3.2765 | 0.0249272 | 0.0252256 | 195.678 | 198.021
BRACE | +55.517 | +57.452 | 8 | 1 | 95.2 | 1.6 | 2289.2 | mf-320 | 2289.2 | 1.57571 | 0.0119274 | 0.0121313 | 93.6298 | 95.2306
BRACE | +53.235 | +54.755 | 8 | 1 | 81 | 1.3 | 1946.2 | mf-318 | 1946.23 | 1.33964 | 0.010123 | 0.0103138 | 79.4654 | 80.9632
BRACE | +48.938 | +52.446 | 8 | 1 | 155.1 | 2.6 | 3727.8 | mf-316 | 3727.78 | 2.56592 | 0.0194959 | 0.0197549 | 153.043 | 155.076
BRACE | +44.811 | +48.108 | 7 | 1 | 146.8 | 2.5 | 3529.8 | me-203 | 3529.8 | 2.42964 | 0.0184543 | 0.0187057 | 144.866 | 146.84
BRACE | +44.821 | +48.100 | 7 | 1 | 139.2 | 2.3 | 3346.4 | me-202 | 3346.37 | 2.30338 | 0.0174605 | 0.0177336 | 137.065 | 139.209
BRACE | +39.265 | +43.992 | 7 | 1 | 223.3 | 3.7 | 5367.8 | me-200 | 5367.78 | 3.69477 | 0.0281241 | 0.0284458 | 220.774 | 223.3
BRACE | +36.440 | +38.512 | 7 | 1 | 134.4 | 2.2 | 3230.4 | me-198 | 3230.38 | 2.22354 | 0.016879 | 0.0171189 | 132.5 | 134.384
BRACE | +31.939 | +35.689 | 6 | 1 | 187.3 | 3.1 | 4502.2 | md-166 | 4502.18 | 3.09895 | 0.0235701 | 0.0238587 | 185.025 | 187.291
BRACE | +29.246 | +31.203 | 6 | 1 | 127.5 | 2.1 | 3066 | md-164 | 3066.02 | 2.11041 | 0.0160143 | 0.0162479 | 125.712 | 127.546
BRACE | +24.542 | +28.496 | 6 | 1 | 194.6 | 3.2 | 4677.9 | md-163 | 4677.87 | 3.21989 | 0.0244656 | 0.0247898 | 192.055 | 194.6
BRACE | +21.725 | +24.032 | 5 | 1 | 127.3 | 2.1 | 3059.9 | mc-438 | 3059.91 | 2.1062 | 0.0159533 | 0.0162156 | 125.234 | 127.292
BRACE | +21.635 | +23.787 | 5 | 1 | 134.8 | 2.2 | 3240.7 | mc-437 | 3240.66 | 2.23062 | 0.0169331 | 0.0171734 | 132.925 | 134.811
BRACE | +0.381 | +5.097 | 5 | 1 | 199.8 | 3.3 | 4803.4 | mc-435 | 4803.38 | 3.30628 | 0.0251547 | 0.0254549 | 197.465 | 199.821
BRACE | +5.949 | +11.895 | 5 | 1 | 249.8 | 4.1 | 6004.6 | mc-434 | 6004.57 | 4.13308 | 0.0314743 | 0.0318204 | 247.073 | 249.79
BRACE | +15.839 | +18.987 | 5 | 6 | 278.4 | 4.7 | 6691.9 | mc-431 | 6691.89 | 4.60618 | 0.0350904 | 0.0354627 | 275.459 | 278.382
4 x BRACE | +48.910 | +52.474 | 8 | 1 | 183.8 | 3 | 4419.3 | mf-299 | 4419.25 | 3.04187 | 0.0231338 | 0.0234192 | 181.6 | 183.841
4 x BRACE | +58.244 | +62.870 | 8 | 1 | 221.8 | 3.7 | 5331.6 | mf-306 | 5331.57 | 3.66985 | 0.0279336 | 0.0282539 | 219.279 | 221.793
4 x BRACE | +66.461 | +70.084 | 8 | 1 | 186 | 3.1 | 4470 | mf-305 | 4469.98 | 3.07679 | 0.0234007 | 0.023688 | 183.695 | 185.951
4 x BRACE | +31.990 | +35.702 | 6 | 1 | 189 | 3.1 | 4542.8 | md-157 | 4542.84 | 3.12694 | 0.023784 | 0.0240741 | 186.704 | 188.982
4 x BRACE | +39.313 | +43.995 | 7 | 1 | 223.9 | 3.7 | 5382.3 | me-191 | 5382.3 | 3.70476 | 0.0282005 | 0.0285228 | 221.374 | 223.904
BRACE | +2.965 | +5.074 | 5 | 5 | 102.8 | 1.7 | 2470.4 | mc-430 | 2470.4 | 1.70043 | 0.0128807 | 0.0130915 | 101.113 | 102.769
BRACE | +2.925 | +5.170 | 5 | 5 | 142.2 | 2.3 | 3417.4 | mc-429 | 3417.37 | 2.35225 | 0.0178628 | 0.0181099 | 140.223 | 142.162
BRACE | +2.959 | +5.100 | 5 | 5 | 107.9 | 1.7 | 2593 | mc-428 | 2593 | 1.78482 | 0.0135257 | 0.0137413 | 106.177 | 107.869
BRACE | +0.315 | +2.179 | 5 | 5 | 90.1 | 1.5 | 2165.4 | mc-427 | 2165.37 | 1.49048 | 0.0112759 | 0.0114751 | 88.5158 | 90.0795
4 x VERT. BRACE | +5.917 | +9.942 | 3 | 1 | 199.8 | 3.3 | 4801.2 | ma-192 | 4801.21 | 3.30478 | 0.0251433 | 0.0254433 | 197.375 | 199.73
2 x VERT BRACE | +10.953 | +15.063 | 4 | 5 | 182.2 | 3 | 4380.2 | mb-231 | 4380.21 | 3.015 | 0.0229284 | 0.0232123 | 179.988 | 182.217
2 x BRACE | +12.716 | +15.123 | 5 | 5 | 117.5 | 1.9 | 2825.5 | mc-426 | 2825.48 | 1.94484 | 0.0147488 | 0.0149732 | 115.778 | 117.54
2 x VERT. BRACE | +8.013 | +10.049 | 3 | 1 | 132.8 | 2.2 | 3192.8 | ma-219 | 3192.79 | 2.19767 | 0.0166813 | 0.0169198 | 130.948 | 132.82
2 x VERT. BRACE | +5.846 | +7.342 | 3 | 1 | 114.3 | 1.9 | 2747.5 | ma-196 | 2747.5 | 1.89117 | 0.0143386 | 0.01456 | 112.558 | 114.296
VERT. BRACE | +0.333 | +5.054 | 3 | 5 | 238.6 | 4 | 5735.3 | ma-218 | 5735.32 | 3.94775 | 0.0300578 | 0.0303935 | 235.953 | 238.589
VERT. BRACE | +5.956 | +9.979 | 3 | 5 | 213.9 | 3.5 | 5141.3 | ma-217 | 5141.26 | 3.53885 | 0.0269324 | 0.0272454 | 211.419 | 213.876
VERT BRACE | +10.849 | +15.086 | 4 | 5 | 221.4 | 3.7 | 5322.3 | mb-232 | 5322.31 | 3.66347 | 0.0278849 | 0.0282049 | 218.896 | 221.408
VERT. BRACE | +0.302 | +5.085 | 3 | 5 | 250.4 | 4.1 | 6019.2 | ma-216 | 6019.22 | 4.14317 | 0.0315514 | 0.031898 | 247.679 | 250.4
VERT. BRACE | +5.904 | +10.030 | 3 | 5 | 229 | 3.8 | 5504.5 | ma-215 | 5504.51 | 3.78888 | 0.0288434 | 0.0291704 | 226.421 | 228.987
VERT BRACE | +15.833 | +17.561 | 4 | 5 | 153.3 | 2.5 | 3685.5 | mb-230 | 3685.5 | 2.53681 | 0.0192735 | 0.0195308 | 151.297 | 153.317
BRACE | +0.284 | +2.185 | 5 | 5 | 95 | 1.6 | 2283 | mc-424 | 2282.95 | 1.57141 | 0.0118945 | 0.0120982 | 93.3718 | 94.9707
BRACE | +0.190 | +2.220 | 5 | 5 | 127.3 | 2.1 | 3061.9 | mc-423 | 3061.85 | 2.10754 | 0.0159924 | 0.0162259 | 125.54 | 127.373
10 x BRACE | +6.024 | +11.921 | 5 | 1 | 285.2 | 4.7 | 6856.3 | mc-422 | 6856.26 | 4.71932 | 0.0359552 | 0.0363338 | 282.248 | 285.22
2 x VERT BRACE | +21.661 | +23.761 | 4 | 1 | 111 | 1.7 | 2667.4 | mb-228 | 2667.42 | 1.83605 | 0.0139172 | 0.0141356 | 109.25 | 110.965
2 x BRACE | +24.496 | +25.986 | 6 | 1 | 88.5 | 1.5 | 2128.1 | md-159 | 2128.09 | 1.46482 | 0.0110798 | 0.0112775 | 86.9763 | 88.5287
2 x VERT BRACE | +18.208 | +19.346 | 4 | 1 | 75 | 1.3 | 1802.8 | mb-227 | 1802.78 | 1.24089 | 0.00936826 | 0.00955358 | 73.5408 | 74.9956
2 x VERT BRACE | +19.907 | +20.952 | 4 | 1 | 71.3 | 1.3 | 1712.9 | mb-226 | 1712.91 | 1.17904 | 0.00889548 | 0.00907736 | 69.8295 | 71.2573
2 x VERT BRACE | +10.785 | +12.699 | 4 | 1 | 104.2 | 1.7 | 2504.1 | mb-225 | 2504.08 | 1.72362 | 0.0130579 | 0.01327 | 102.504 | 104.17
2 x VERT BRACE | +13.336 | +15.153 | 4 | 1 | 100.6 | 1.7 | 2418.1 | mb-224 | 2418.09 | 1.66443 | 0.0126055 | 0.0128143 | 98.9529 | 100.592
2 x VERT BRACE | +15.884 | +17.511 | 4 | 1 | 93.5 | 1.5 | 2247.3 | mb-223 | 2247.31 | 1.54688 | 0.011707 | 0.0119093 | 91.8999 | 93.4881
VERT. BRACE | +5.891 | +7.702 | 3 | 1 | 100.5 | 1.7 | 2413.2 | ma-209 | 2413.23 | 1.66108 | 0.0125799 | 0.0127886 | 98.7521 | 100.39
2 x VERT. BRACE | +8.332 | +10.047 | 3 | 1 | 96.8 | 1.6 | 2327.6 | ma-208 | 2327.63 | 1.60216 | 0.0121296 | 0.012335 | 95.2172 | 96.8296
2 x VERT. BRACE | +0.380 | +2.256 | 3 | 1 | 103.5 | 1.7 | 2487.3 | ma-207 | 2487.33 | 1.71208 | 0.0129697 | 0.0131812 | 101.812 | 103.473
2 x VERT. BRACE | +2.920 | +5.125 | 3 | 1 | 114.3 | 1.9 | 2749.1 | ma-206 | 2749.08 | 1.89226 | 0.0143469 | 0.0145684 | 112.623 | 114.362
VERT. BRACE | +2.973 | +5.122 | 3 | 1 | 100.6 | 1.7 | 2419.6 | ma-214 | 2419.57 | 1.66545 | 0.0126133 | 0.0128222 | 99.0143 | 100.654
VERT. BRACE | +2.973 | +5.122 | 3 | 1 | 100.6 | 1.7 | 2419.4 | ma-214 | 2419.37 | 1.6653 | 0.0126122 | 0.0128211 | 99.0057 | 100.646
2 x VERT BRACE | +18.181 | +20.974 | 4 | 5 | 267.9 | 4.5 | 6440.5 | mb-222 | 6440.5 | 4.43314 | 0.0337678 | 0.0341306 | 265.077 | 267.925
VERT. BRACE | +0.323 | +5.074 | 3 | 5 | 240 | 4 | 5768.2 | ma-213 | 5768.17 | 3.97036 | 0.0302306 | 0.0305676 | 237.31 | 239.956
VERT. BRACE | +0.292 | +5.105 | 3 | 5 | 251.8 | 4.1 | 6052.8 | ma-212 | 6052.76 | 4.16625 | 0.0317279 | 0.0320758 | 249.064 | 251.795
VERT. BRACE | +5.899 | +10.035 | 3 | 5 | 229.6 | 3.8 | 5518.3 | ma-211 | 5518.35 | 3.79841 | 0.0289163 | 0.0292437 | 226.993 | 229.563
4 x VERT. BRACE | +0.373 | +5.122 | 3 | 5 | 229.4 | 3.8 | 5513.6 | ma-201 | 5513.62 | 3.79515 | 0.0288914 | 0.0292187 | 226.797 | 229.367
VERT. BRACE | +5.915 | +9.964 | 3 | 5 | 203.7 | 3.5 | 4896.3 | ma-210 | 4896.32 | 3.37025 | 0.0256437 | 0.0259474 | 201.303 | 203.687
3 x VERT. BRACE | +5.915 | +9.969 | 3 | 5 | 203.9 | 3.5 | 4902.6 | ma-202 | 4902.56 | 3.37455 | 0.0256766 | 0.0259805 | 201.561 | 203.947
2 x VERT BRACE | +10.756 | +15.179 | 4 | 5 | 312.4 | 5.2 | 7509.2 | mb-212 | 7509.2 | 5.16876 | 0.0393904 | 0.039794 | 309.214 | 312.383
BRACE | +5.890 | +11.954 | 5 | 5 | 361.6 | 5.9 | 8692.5 | mc-421 | 8692.51 | 5.98326 | 0.0456159 | 0.0460648 | 358.085 | 361.609
BRACE | +0.198 | +5.171 | 5 | 5 | 332.2 | 5.5 | 7985.7 | mc-420 | 7985.73 | 5.49676 | 0.0418974 | 0.0423193 | 328.895 | 332.206
BRACE | +0.257 | +5.134 | 5 | 5 | 253.9 | 4.1 | 6102.7 | mc-419 | 6102.68 | 4.20061 | 0.0319905 | 0.0323403 | 251.125 | 253.871
BRACE | +0.254 | +5.128 | 5 | 5 | 244.2 | 4 | 5870.5 | mc-418 | 5870.46 | 4.04077 | 0.0307687 | 0.0311097 | 241.535 | 244.211
BRACE | +0.215 | +5.158 | 5 | 5 | 300.2 | 5 | 7215.3 | mc-417 | 7215.27 | 4.96644 | 0.037844 | 0.0382363 | 297.075 | 300.155
2 x BRACE | +5.902 | +11.943 | 5 | 5 | 333 | 5.5 | 8004 | mc-406 | 8003.96 | 5.50931 | 0.0419933 | 0.0424159 | 329.648 | 332.965
BRACE | +5.937 | +11.917 | 5 | 5 | 283.3 | 4.7 | 6810.1 | mc-416 | 6810.13 | 4.68757 | 0.0357125 | 0.0360894 | 280.343 | 283.301
2 x BRACE | +0.203 | +5.157 | 5 | 5 | 299.8 | 4.8 | 7205.6 | mc-405 | 7205.57 | 4.95976 | 0.0377929 | 0.0381849 | 296.674 | 299.752
2 x BRACE | +5.902 | +11.943 | 5 | 5 | 333.6 | 5.5 | 8019.8 | mc-404 | 8019.79 | 5.5202 | 0.0420766 | 0.0424998 | 330.301 | 333.623
BRACE | +5.977 | +11.868 | 5 | 5 | 280 | 4.7 | 6731 | mc-415 | 6730.96 | 4.63308 | 0.035296 | 0.0356698 | 277.073 | 280.008
BRACE | +5.890 | +11.954 | 5 | 5 | 361.2 | 5.9 | 8682.2 | mc-414 | 8682.18 | 5.97614 | 0.0455615 | 0.04601 | 357.658 | 361.179
BRACE | +5.899 | +10.036 | 5 | 5 | 229.6 | 3.8 | 5522 | mc-413 | 5522 | 3.80092 | 0.0289355 | 0.0292631 | 227.143 | 229.715
BRACE | +12.657 | +14.793 | 5 | 5 | 154.6 | 2.6 | 3717 | mc-412 | 3717.05 | 2.55853 | 0.0194394 | 0.019698 | 152.6 | 154.629
BRACE | +12.623 | +15.221 | 5 | 5 | 271.3 | 4.5 | 6521.9 | mc-411 | 6521.92 | 4.48919 | 0.0341962 | 0.034562 | 268.44 | 271.312
2 x BRACE | +60.931 | +62.898 | 8 | 1 | 106.6 | 1.7 | 2561.8 | mf-315 | 2561.77 | 1.76333 | 0.0133614 | 0.0135757 | 104.887 | 106.57
2 x BRACE | +63.649 | +65.696 | 8 | 1 | 109.3 | 1.7 | 2630.1 | mf-314 | 2630.07 | 1.81034 | 0.0137207 | 0.0139377 | 107.708 | 109.411
2 x BRACE | +66.431 | +68.017 | 8 | 1 | 92.5 | 1.5 | 2224.2 | mf-313 | 2224.25 | 1.531 | 0.0115857 | 0.0117871 | 90.9474 | 92.5287
2 x BRACE | +68.627 | +70.118 | 8 | 1 | 89 | 1.5 | 2139.2 | mf-312 | 2139.23 | 1.47248 | 0.0111384 | 0.0113366 | 87.4362 | 88.992
3 x BRACE | +66.402 | +70.142 | 8 | 5 | 293.7 | 4.8 | 7059 | mf-302 | 7059.02 | 4.85889 | 0.0370219 | 0.0374083 | 290.622 | 293.655
BRACE | +55.501 | +57.468 | 8 | 1 | 106.5 | 1.7 | 2559.1 | mf-311 | 2559.14 | 1.76151 | 0.0133476 | 0.0135618 | 104.778 | 106.46
BRACE | +58.219 | +60.284 | 8 | 1 | 110.2 | 1.7 | 2648.6 | mf-310 | 2648.56 | 1.82306 | 0.013818 | 0.0140357 | 108.471 | 110.18
BRACE | +55.501 | +57.468 | 8 | 1 | 106.5 | 1.7 | 2559.4 | mf-311 | 2559.43 | 1.76171 | 0.0133491 | 0.0135633 | 104.79 | 106.472
BRACE | +58.219 | +60.284 | 8 | 1 | 110.2 | 1.7 | 2648.3 | mf-310 | 2648.29 | 1.82288 | 0.0138166 | 0.0140342 | 108.46 | 110.169
2 x BRACE | +48.891 | +50.711 | 8 | 1 | 101.1 | 1.7 | 2431.4 | mf-309 | 2431.43 | 1.67361 | 0.0126757 | 0.012885 | 99.504 | 101.147
BRACE | +51.315 | +52.523 | 8 | 1 | 78.3 | 1.3 | 1881.2 | mf-308 | 1881.15 | 1.29484 | 0.00978057 | 0.00996889 | 76.7775 | 78.2557
BRACE | +53.220 | +54.770 | 8 | 1 | 91.1 | 1.5 | 2189.8 | mf-307 | 2189.82 | 1.5073 | 0.0114045 | 0.0116047 | 89.5255 | 91.0965
BRACE | +51.315 | +52.523 | 8 | 1 | 78.3 | 1.3 | 1881.2 | mf-308 | 1881.15 | 1.29484 | 0.00978057 | 0.00996889 | 76.7775 | 78.2558
BRACE | +53.220 | +54.770 | 8 | 1 | 91.1 | 1.5 | 2189.8 | mf-307 | 2189.82 | 1.5073 | 0.0114045 | 0.0116046 | 89.5255 | 91.0964
2 x BRACE | +44.765 | +46.571 | 7 | 1 | 100.6 | 1.7 | 2419.1 | me-196 | 2419.1 | 1.66512 | 0.0126108 | 0.0128197 | 98.9947 | 100.634
2 x BRACE | +47.163 | +48.194 | 7 | 1 | 71.1 | 1.3 | 1709.7 | me-195 | 1709.68 | 1.17681 | 0.00887847 | 0.00906023 | 69.696 | 71.1228
2 x BRACE | +36.468 | +38.484 | 7 | 1 | 108.1 | 1.7 | 2597.8 | me-194 | 2597.82 | 1.78814 | 0.0135511 | 0.0137668 | 106.376 | 108.069
2 x BRACE | +39.239 | +41.354 | 7 | 1 | 112 | 1.7 | 2692.5 | me-193 | 2692.53 | 1.85333 | 0.0140493 | 0.0142687 | 110.287 | 112.009
2 x BRACE | +42.004 | +44.022 | 7 | 1 | 108.3 | 1.7 | 2606.6 | me-192 | 2606.59 | 1.79417 | 0.0135972 | 0.0138133 | 106.738 | 108.434
2 x BRACE | +29.275 | +31.178 | 6 | 1 | 103.7 | 1.7 | 2492.5 | md-162 | 2492.54 | 1.71567 | 0.0129972 | 0.0132089 | 102.028 | 103.69
2 x BRACE | +31.913 | +33.563 | 6 | 1 | 94.3 | 1.6 | 2270.3 | md-161 | 2270.33 | 1.56272 | 0.0118281 | 0.0120313 | 92.8504 | 94.4456
2 x BRACE | +34.180 | +35.734 | 6 | 1 | 90.9 | 1.5 | 2185.1 | md-160 | 2185.13 | 1.50407 | 0.0113798 | 0.0115798 | 89.3316 | 90.9012
2 x BRACE | +26.610 | +28.529 | 6 | 1 | 104.4 | 1.7 | 2509 | md-158 | 2508.97 | 1.72698 | 0.0130836 | 0.0132959 | 102.706 | 104.373
VERT. BRACE | +5.891 | +7.702 | 3 | 1 | 100.3 | 1.7 | 2413.2 | ma-209 | 2413.23 | 1.66108 | 0.0125799 | 0.0127886 | 98.7521 | 100.39
3 x BRACE | +44.722 | +48.198 | 7 | 5 | 286.5 | 4.7 | 6887.4 | me-189 | 6887.43 | 4.74078 | 0.0361192 | 0.036499 | 283.536 | 286.517
BRACE | +39.211 | +44.047 | 7 | 5 | 324.4 | 5.5 | 7797 | me-187 | 7796.98 | 5.36684 | 0.0409044 | 0.041319 | 321.099 | 324.354
BRACE | +24.593 | +28.507 | 6 | 1 | 196.3 | 3.2 | 4717.6 | md-156 | 4717.62 | 3.24725 | 0.0247036 | 0.0250004 | 193.923 | 196.253
BRACE | +24.593 | +28.507 | 6 | 1 | 196.1 | 3.2 | 4714.3 | md-155 | 4714.28 | 3.24495 | 0.024686 | 0.0249827 | 193.785 | 196.114
VERT. BRACE | +2.813 | +5.112 | 3 | 1 | 117.9 | 1.9 | 2831.4 | ma-205 | 2831.42 | 1.94893 | 0.0147801 | 0.0150047 | 116.024 | 117.787
VERT. BRACE | +0.398 | +2.375 | 3 | 1 | 107.4 | 1.7 | 2581.4 | ma-204 | 2581.42 | 1.77685 | 0.0134648 | 0.0136799 | 105.699 | 107.387
VERT. BRACE | +2.927 | +5.168 | 3 | 1 | 139.8 | 2.3 | 3361.3 | ma-203 | 3361.26 | 2.31363 | 0.0175676 | 0.0178126 | 137.906 | 139.829
VERT. BRACE | +2.927 | +5.168 | 3 | 1 | 139.8 | 2.3 | 3361.3 | ma-203 | 3361.26 | 2.31363 | 0.0175676 | 0.0178125 | 137.906 | 139.828
BRACE | +2.933 | +5.162 | 5 | 1 | 132.8 | 2.2 | 3195.1 | mc-410 | 3195.09 | 2.19926 | 0.0166934 | 0.016932 | 131.043 | 132.916
BRACE | +2.933 | +5.162 | 5 | 1 | 133.2 | 2.2 | 3201.4 | mc-409 | 3201.43 | 2.20362 | 0.0167267 | 0.0169655 | 131.305 | 133.179
2 x BRACE | +5.927 | +10.028 | 5 | 1 | 223.7 | 3.7 | 5376.6 | mc-408 | 5376.63 | 3.70086 | 0.0281707 | 0.0284927 | 221.14 | 223.668
BRACE | +58.191 | +62.923 | 8 | 5 | 321.4 | 5.3 | 7725.2 | mf-296 | 7725.23 | 5.31745 | 0.0405269 | 0.0409388 | 318.136 | 321.369
VERT. BRACE | +0.833 | +4.904 | 3 | 1 | 183.1 | 3 | 4402.4 | ma-200 | 4402.37 | 3.03025 | 0.023045 | 0.0233298 | 180.903 | 183.139
VERT. BRACE | +6.098 | +9.837 | 3 | 1 | 170.2 | 2.8 | 4091.9 | ma-199 | 4091.88 | 2.81653 | 0.0214114 | 0.0216843 | 168.08 | 170.222
2 x VERT. BRACE | +0.626 | +5.121 | 3 | 1 | 216.6 | 3.6 | 5208.7 | ma-198 | 5208.71 | 3.58527 | 0.0272872 | 0.0276028 | 214.205 | 216.682
VERT. BRACE | +6.098 | +9.842 | 3 | 1 | 170.5 | 2.8 | 4097.5 | ma-197 | 4097.5 | 2.8204 | 0.021441 | 0.0217141 | 168.312 | 170.456
BRACE | +0.214 | +5.158 | 5 | 5 | 300.3 | 5 | 7219 | mc-407 | 7219 | 4.969 | 0.0378636 | 0.0382561 | 297.229 | 300.31
3 x BRACE | +31.883 | +35.759 | 6 | 5 | 297.2 | 4.8 | 7143.9 | md-152 | 7143.91 | 4.91732 | 0.0374685 | 0.0378582 | 294.128 | 297.187
3 x BRACE | +24.477 | +28.565 | 6 | 5 | 303 | 5 | 7283.9 | md-151 | 7283.91 | 5.01368 | 0.0382051 | 0.0386001 | 299.91 | 303.011
BRACE | +63.574 | +65.763 | 8 | 5 | 221.4 | 3.7 | 5318.8 | mf-303 | 5318.78 | 3.66104 | 0.0278663 | 0.0281861 | 218.75 | 221.261
VERT BRACE | +10.999 | +14.935 | 4 | 1 | 177.9 | 3 | 4276.3 | mb-221 | 4276.25 | 2.94344 | 0.0223815 | 0.0226614 | 175.694 | 177.892
VERT BRACE | +15.884 | +17.511 | 4 | 1 | 93.6 | 1.5 | 2249.8 | mb-220 | 2249.77 | 1.54857 | 0.0117199 | 0.0119224 | 92.0015 | 93.5905
VERT BRACE | +10.759 | +15.175 | 4 | 1 | 302.8 | 5 | 7279.2 | mb-219 | 7279.19 | 5.01044 | 0.0381803 | 0.0385751 | 299.715 | 302.814
VERT BRACE | +15.834 | +17.560 | 4 | 5 | 152.4 | 2.5 | 3662.8 | mb-218 | 3662.78 | 2.52118 | 0.0191539 | 0.0194104 | 150.358 | 152.372
VERT BRACE | +10.802 | +15.132 | 4 | 5 | 235.6 | 4 | 5664.6 | mb-217 | 5664.58 | 3.89906 | 0.0296856 | 0.0300187 | 233.032 | 235.647
2 x BRACE | +58.191 | +62.923 | 8 | 5 | 321.4 | 5.3 | 7725.7 | mf-296 | 7725.74 | 5.3178 | 0.0405296 | 0.0409415 | 318.157 | 321.391
BRACE | +55.427 | +57.531 | 8 | 3 | 218.4 | 3.6 | 5250.5 | mf-301 | 5250.53 | 3.61406 | 0.0275073 | 0.0278245 | 215.932 | 218.422
3 x BRACE | +48.851 | +52.533 | 8 | 5 | 292.1 | 4.8 | 7021.4 | mf-292 | 7021.41 | 4.833 | 0.036824 | 0.037209 | 289.069 | 292.091
3 x BRACE | +53.191 | +54.798 | 8 | 1 | 118.4 | 1.9 | 2847.9 | mf-300 | 2847.85 | 1.96024 | 0.0148665 | 0.0150918 | 116.702 | 118.471
BRACE | +53.191 | +54.798 | 8 | 1 | 118.4 | 1.9 | 2847.9 | mf-300 | 2847.86 | 1.96024 | 0.0148665 | 0.0150918 | 116.702 | 118.471
2 x BRACE | +63.622 | +65.723 | 8 | 1 | 135.3 | 2.2 | 3251.7 | mf-298 | 3251.73 | 2.23824 | 0.0169914 | 0.0172321 | 133.382 | 135.272
2 x BRACE | +55.474 | +57.496 | 8 | 1 | 132.6 | 2.2 | 3187.7 | mf-297 | 3187.72 | 2.19418 | 0.0166546 | 0.0168929 | 130.738 | 132.609
2 x BRACE | +44.795 | +48.139 | 7 | 1 | 177 | 3 | 4255.7 | me-190 | 4255.67 | 2.92928 | 0.0222732 | 0.0225524 | 174.845 | 177.036
BRACE | +36.394 | +38.543 | 7 | 5 | 218.4 | 3.6 | 5249.9 | me-188 | 5249.93 | 3.61365 | 0.0275041 | 0.0278213 | 215.907 | 218.397
2 x BRACE | +39.211 | +44.047 | 7 | 5 | 324.4 | 5.3 | 7797 | me-187 | 7796.98 | 5.36684 | 0.0409044 | 0.041319 | 321.099 | 324.354
BRACE | +29.200 | +31.235 | 6 | 5 | 214.9 | 3.5 | 5164.8 | md-154 | 5164.8 | 3.55505 | 0.0270562 | 0.0273701 | 212.391 | 214.856
2 x BRACE | +36.440 | +38.512 | 7 | 1 | 134.4 | 2.2 | 3227.6 | me-185 | 3227.62 | 2.22164 | 0.0168645 | 0.0171043 | 132.386 | 134.269
2 x BRACE | +24.593 | +28.507 | 6 | 1 | 196.1 | 3.2 | 4716 | md-150 | 4715.95 | 3.2461 | 0.0246948 | 0.0249915 | 193.854 | 196.184
2 x VERT BRACE | +21.634 | +23.789 | 4 | 1 | 136.8 | 2.3 | 3288.9 | mb-215 | 3288.88 | 2.26381 | 0.0171868 | 0.017429 | 134.916 | 136.817
2 x VERT BRACE | +18.240 | +20.915 | 4 | 1 | 154.3 | 2.5 | 3712.1 | mb-214 | 3712.11 | 2.55513 | 0.0194135 | 0.0196718 | 152.396 | 154.424
VERT BRACE | +10.756 | +15.179 | 4 | 5 | 312.4 | 5.2 | 7509.1 | mb-212 | 7509.09 | 5.16868 | 0.0393898 | 0.0397934 | 309.21 | 312.378
VERT. BRACE | +0.623 | +2.172 | 3 | 1 | 70.9 | 1.3 | 1704.1 | ma-195 | 1704.13 | 1.17299 | 0.00884928 | 0.00903083 | 69.4668 | 70.892
VERT. BRACE | +0.623 | +2.172 | 3 | 1 | 70.9 | 1.3 | 1704.5 | ma-195 | 1704.47 | 1.17323 | 0.00885105 | 0.00903261 | 69.4807 | 70.906
VERT. BRACE | +5.983 | +10.017 | 3 | 1 | 199.8 | 3.3 | 4804.3 | ma-194 | 4804.25 | 3.30688 | 0.0251593 | 0.0254595 | 197.501 | 199.857
VERT. BRACE | +5.983 | +10.017 | 3 | 1 | 199.8 | 3.3 | 4804.8 | ma-194 | 4804.75 | 3.30722 | 0.025162 | 0.0254621 | 197.522 | 199.878
4 x VERT BRACE | +10.885 | +15.124 | 4 | 1 | 207.4 | 3.5 | 4984.8 | mb-210 | 4984.83 | 3.43117 | 0.0261094 | 0.0264164 | 204.959 | 207.369
4 x VERT BRACE | +15.855 | +17.539 | 4 | 1 | 120.9 | 1.9 | 2905.7 | mb-211 | 2905.75 | 2.00009 | 0.0151711 | 0.0153986 | 119.093 | 120.879
VERT. BRACE | +0.623 | +5.122 | 3 | 1 | 217.1 | 3.6 | 5218.6 | ma-193 | 5218.59 | 3.59207 | 0.0273392 | 0.0276552 | 214.613 | 217.093
VERT. BRACE | +0.623 | +5.122 | 3 | 1 | 217.1 | 3.6 | 5219.2 | ma-193 | 5219.22 | 3.59251 | 0.0273425 | 0.0276585 | 214.639 | 217.12
VERT BRACE | +21.634 | +23.789 | 4 | 1 | 136.8 | 2.3 | 3290.9 | mb-209 | 3290.93 | 2.26522 | 0.0171976 | 0.0174398 | 135.001 | 136.903
VERT BRACE | +21.634 | +23.789 | 4 | 1 | 136.8 | 2.3 | 3286.8 | mb-208 | 3286.83 | 2.2624 | 0.017176 | 0.0174181 | 134.832 | 136.732
BRACE | +63.587 | +65.717 | 8 | 5 | 185.8 | 3.1 | 4465.5 | mf-291 | 4465.47 | 3.07369 | 0.023377 | 0.0236642 | 183.509 | 185.764
BRACE | +55.437 | +57.506 | 8 | 5 | 189.4 | 3.1 | 4552.7 | mf-290 | 4552.72 | 3.13374 | 0.023836 | 0.0241265 | 187.113 | 189.393
BRACE | +36.404 | +38.517 | 7 | 5 | 190.4 | 3.1 | 4576.7 | me-184 | 4576.73 | 3.15027 | 0.0239623 | 0.0242537 | 188.104 | 190.392
BRACE | +29.212 | +31.213 | 6 | 5 | 182.4 | 3 | 4385.7 | md-149 | 4385.73 | 3.0188 | 0.0229574 | 0.0232416 | 180.216 | 182.446
2 x BRACE | +29.247 | +31.206 | 6 | 1 | 130.3 | 2.1 | 3130.6 | md-148 | 3130.58 | 2.15485 | 0.016354 | 0.0165901 | 128.379 | 130.232
VERT. BRACE | +5.926 | +10.009 | 3 | 5 | 217.1 | 3.6 | 5220.7 | ma-191 | 5220.75 | 3.59356 | 0.0273506 | 0.0276666 | 214.702 | 217.183
VERT BRACE | +18.192 | +20.935 | 4 | 5 | 233.2 | 3.8 | 5606.6 | mb-206 | 5606.56 | 3.85913 | 0.0293804 | 0.0297112 | 230.636 | 233.233
VERT BRACE | +21.600 | +23.812 | 4 | 5 | 187.7 | 3.1 | 4512.6 | mb-205 | 4512.65 | 3.10616 | 0.0236252 | 0.0239142 | 185.458 | 187.726
BRACE | +5.932 | +11.922 | 5 | 5 | 292.1 | 4.8 | 7020.8 | mc-403 | 7020.81 | 4.83258 | 0.0368209 | 0.0372058 | 289.044 | 292.066

# IfcMember: CHS273.1*10.0 (8)
In: Undefined
Description: CHS273.1*10.0; Material: STEEL/S355JR
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 13.3 m2; Height: 273.1 mm; Width: 273.1 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00826752 m2
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Volume (m3) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
BRACE | +15.928 | +20.854 | 5 | 1 | 357.5 | 0 | 4.7 | 5508 | mc-454 | 5507.99 | 4.72569 | 0.0449639 | 0.0455374 | 352.967 | 357.469
BRACE | +16.136 | +20.693 | 5 | 1 | 322.4 | 0 | 4.3 | 4968.1 | mc-453 | 4968.09 | 4.26247 | 0.0405027 | 0.0410738 | 317.946 | 322.429
VERT BRACE | +18.376 | +23.789 | 4 | 5 | 414 | 0.1 | 5.5 | 6378.3 | mb-237 | 6378.33 | 5.47241 | 0.0520975 | 0.052733 | 408.966 | 413.954
VERT BRACE | +16.091 | +20.931 | 4 | 5 | 368.8 | 0 | 4.8 | 5682.5 | mb-236 | 5682.54 | 4.87544 | 0.0463945 | 0.0469805 | 364.197 | 368.797
2 x VERT. BRACE | +0.475 | +5.032 | 3 | 5 | 340.8 | 0 | 4.5 | 5250.6 | ma-222 | 5250.61 | 4.50486 | 0.0428903 | 0.0434095 | 336.689 | 340.765
2 x VERT. BRACE | +5.913 | +9.956 | 3 | 5 | 315.3 | 0 | 4.1 | 4858 | ma-221 | 4857.87 | 4.1679 | 0.0396713 | 0.0401625 | 311.42 | 315.276

# IfcMember: IPE200 (42)
In: Undefined
Description: IPE200; Material: STEEL/S355JR
