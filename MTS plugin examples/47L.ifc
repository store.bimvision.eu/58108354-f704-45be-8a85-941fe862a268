Properties of the parts of a building model (IFC2X3), part 22 of 22

# IfcMember: IPE200 (42)
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 34.3 m2; Height: 200 mm; Width: 100 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.0028535 m2
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x KNEE BRACE | +69.160 | +70.282 | 8 | 7 | 35.6 | 1.1 | 1587.6 | mf-135 | 1587.63 | 1.21961 | 0.003781 | 0.0045303 | 29.6809 | 35.5628
2 x KNEE BRACE | +61.960 | +63.082 | 8 | 7 | 35.6 | 1.1 | 1587.6 | mf-135 | 1587.63 | 1.21961 | 0.003781 | 0.0045303 | 29.6809 | 35.5628
2 x KNEE BRACE | +53.815 | +54.937 | 8 | 7 | 35.6 | 1.1 | 1587.6 | mf-135 | 1587.63 | 1.21961 | 0.003781 | 0.0045303 | 29.6809 | 35.5628
2 x KNEE BRACE | +43.117 | +44.205 | 7 | 7 | 34.5 | 1.1 | 1539.5 | me-79 | 1539.54 | 1.18267 | 0.00364999 | 0.00439309 | 28.6524 | 34.4858
2 x KNEE BRACE | +34.815 | +35.900 | 6 | 7 | 34.4 | 1.1 | 1535.4 | md-67 | 1535.44 | 1.17952 | 0.00363881 | 0.00438139 | 28.5647 | 34.3939
2 x KNEE BRACE | +27.625 | +28.710 | 6 | 7 | 34.4 | 1.1 | 1535.4 | md-67 | 1535.44 | 1.17952 | 0.00363881 | 0.00438139 | 28.5647 | 34.3939
2 x KNEE BRACE | +68.530 | +70.280 | 8 | 7 | 55.5 | 1.7 | 2474.8 | mf-133 | 2474.83 | 1.90116 | 0.00619847 | 0.00706194 | 48.658 | 55.4363
KNEE BRACE | +64.276 | +65.880 | 8 | 7 | 50.8 | 1.6 | 2268.3 | mf-134 | 2268.29 | 1.74249 | 0.00563567 | 0.00647256 | 44.24 | 50.8096
2 x KNEE BRACE | +61.330 | +63.080 | 8 | 7 | 55.5 | 1.7 | 2474.8 | mf-133 | 2474.83 | 1.90116 | 0.00619847 | 0.00706194 | 48.658 | 55.4363
2 x KNEE BRACE | +53.185 | +54.935 | 8 | 7 | 55.5 | 1.7 | 2474.8 | mf-133 | 2474.83 | 1.90116 | 0.00619847 | 0.00706194 | 48.658 | 55.4363
2 x KNEE BRACE | +46.076 | +48.332 | 7 | 7 | 71.5 | 2.5 | 3191.7 | me-78 | 3191.7 | 2.45186 | 0.00815178 | 0.00910752 | 63.9915 | 71.494
KNEE BRACE | +43.449 | +44.361 | 7 | 14 | 28.9 | 0.8 | 1289.1 | me-77 | 1289.09 | 0.990273 | 0.00296754 | 0.00367841 | 23.2952 | 28.8755
KNEE BRACE | +69.524 | +70.436 | 8 | 7 | 28.9 | 0.8 | 1289.1 | mf-132 | 1289.09 | 0.990273 | 0.00296754 | 0.00367841 | 23.2952 | 28.8755
KNEE BRACE | +54.179 | +55.091 | 8 | 14 | 28.9 | 0.8 | 1289.1 | mf-132 | 1289.09 | 0.990273 | 0.00296754 | 0.00367841 | 23.2952 | 28.8755
KNEE BRACE | +62.324 | +63.236 | 8 | 14 | 28.9 | 0.8 | 1289.1 | mf-132 | 1289.09 | 0.990273 | 0.00296754 | 0.00367841 | 23.2952 | 28.8755
KNEE BRACE | +37.912 | +38.824 | 7 | 14 | 28.9 | 0.8 | 1289.1 | me-77 | 1289.09 | 0.990273 | 0.00296754 | 0.00367841 | 23.2952 | 28.8755
2 x KNEE BRACE | +42.455 | +44.205 | 7 | 7 | 55.5 | 1.7 | 2474.8 | me-76 | 2474.83 | 1.90116 | 0.00619847 | 0.00706194 | 48.658 | 55.4363
KNEE BRACE | +35.154 | +36.056 | 6 | 14 | 28.6 | 0.8 | 1275.4 | md-65 | 1275.37 | 0.979735 | 0.00293016 | 0.00363927 | 23.0018 | 28.5682
2 x KNEE BRACE | +34.150 | +35.900 | 6 | 7 | 55.5 | 1.7 | 2474.8 | md-66 | 2474.83 | 1.90116 | 0.00619847 | 0.00706194 | 48.658 | 55.4363
2 x KNEE BRACE | +26.960 | +28.710 | 6 | 7 | 55.5 | 1.7 | 2474.8 | md-66 | 2474.83 | 1.90116 | 0.00619847 | 0.00706194 | 48.658 | 55.4363
KNEE BRACE | +27.964 | +28.866 | 6 | 14 | 28.6 | 0.8 | 1275.4 | md-65 | 1275.37 | 0.979735 | 0.00293016 | 0.00363927 | 23.0018 | 28.5682
2 x BEAM | +20.005 | +21.090 | 4 | 7 | 34.4 | 1.1 | 1535.4 | mb-92 | 1535.44 | 1.17952 | 0.00363881 | 0.00438139 | 28.5647 | 34.3939
BEAM | +20.344 | +21.246 | 4 | 14 | 28.6 | 0.8 | 1275.4 | mb-90 | 1275.37 | 0.979735 | 0.00293016 | 0.00363927 | 23.0018 | 28.5682
BEAM | +16.934 | +17.836 | 4 | 14 | 28.6 | 0.8 | 1275.4 | mb-90 | 1275.37 | 0.979735 | 0.00293016 | 0.00363927 | 23.0018 | 28.5682
2 x KNEE BRACE | +3.580 | +5.330 | 3 | 7 | 55.5 | 1.7 | 2474.8 | ma-97 | 2474.83 | 1.90116 | 0.00619847 | 0.00706194 | 48.658 | 55.4363
2 x BEAM | +15.930 | +17.680 | 4 | 7 | 55.5 | 1.7 | 2474.8 | mb-89 | 2474.83 | 1.90116 | 0.00619847 | 0.00706194 | 48.658 | 55.4363

# IfcMember: PFC200*75 (73)
In: Undefined
Description: PFC200*75; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27.8 m2; Height: 200 mm; Width: 75 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00309554 m2
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
BEAM | +13.900 | +15.700 | 5 | 3 | 63.9 | 1.7 | 2631.4 | mc-28 | 2631.41 | 1.77676 | 0.00778364 | 0.00814562 | 61.1016 | 63.9432
BEAM | +13.900 | +15.700 | 5 | 3 | 63.9 | 1.7 | 2631.4 | mc-27 | 2631.41 | 1.77676 | 0.00778364 | 0.00814562 | 61.1016 | 63.9432
BEAM | +10.602 | +12.500 | 5 | 3 | 76 | 1.9 | 3126.4 | mc-26 | 3126.39 | 2.11098 | 0.00900056 | 0.00967786 | 70.6544 | 75.9712
BEAM | +10.602 | +12.500 | 5 | 3 | 76 | 1.9 | 3126.4 | mc-25 | 3126.39 | 2.11098 | 0.00900056 | 0.00967786 | 70.6544 | 75.9712
KNEE BRACE | +11.051 | +12.286 | 5 | 7 | 42.4 | 1.1 | 1745.9 | mc-24 | 1745.88 | 1.17884 | 0.00469792 | 0.00540443 | 36.8787 | 42.4248
STRINGER | +66.050 | +68.450 | 8 | 3 | 87.3 | 2.5 | 3591.9 | mf-17 | 3591.88 | 2.42529 | 0.0107025 | 0.0111188 | 84.0147 | 87.2826
STRINGER | +66.050 | +68.450 | 8 | 3 | 87.3 | 2.5 | 3591.9 | mf-18 | 3591.88 | 2.42529 | 0.0107025 | 0.0111188 | 84.0147 | 87.2826
STRINGER | +57.820 | +60.735 | 8 | 3 | 109.3 | 3 | 4498.1 | mf-14 | 4498.09 | 3.03718 | 0.0134616 | 0.013924 | 105.673 | 109.304
STRINGER | +57.820 | +60.735 | 8 | 3 | 109.3 | 3 | 4498.1 | mf-11 | 4498.09 | 3.03718 | 0.0134616 | 0.013924 | 105.673 | 109.304
STRINGER | +55.105 | +58.020 | 8 | 3 | 109.3 | 3 | 4498 | mf-11 | 4498.03 | 3.03714 | 0.0134614 | 0.0139238 | 105.672 | 109.302
STRINGER | +55.105 | +58.020 | 8 | 3 | 109.3 | 3 | 4498 | mf-10 | 4498.03 | 3.03714 | 0.0134614 | 0.0139238 | 105.672 | 109.302
STRINGER | +48.500 | +51.153 | 8 | 3 | 100.6 | 2.8 | 4138.8 | mf-9 | 4138.83 | 2.79459 | 0.0123743 | 0.0128119 | 97.138 | 100.573
STRINGER | +48.500 | +51.153 | 8 | 3 | 100.6 | 2.8 | 4138.8 | mf-8 | 4138.83 | 2.79459 | 0.0123743 | 0.0128119 | 97.138 | 100.573
STRINGER | +50.953 | +53.040 | 8 | 3 | 77.7 | 2.2 | 3199.2 | mf-7 | 3199.22 | 2.16016 | 0.0095188 | 0.00990332 | 74.7226 | 77.7411
STRINGER | +50.953 | +53.040 | 8 | 3 | 77.7 | 2.2 | 3199.2 | mf-6 | 3199.22 | 2.16016 | 0.0095188 | 0.00990332 | 74.7226 | 77.7411
STRINGER | +52.840 | +55.305 | 8 | 3 | 93 | 2.6 | 3826 | mf-5 | 3826.04 | 2.5834 | 0.0114237 | 0.0118437 | 89.6758 | 92.9728
STRINGER | +52.840 | +55.305 | 8 | 3 | 93 | 2.6 | 3826 | mf-4 | 3826.04 | 2.5834 | 0.0114237 | 0.0118437 | 89.6758 | 92.9728
STRINGER | +46.813 | +48.700 | 7 | 3 | 70 | 1.9 | 2878.7 | me-8 | 2878.85 | 1.94384 | 0.00854627 | 0.00891159 | 67.0882 | 69.956
STRINGER | +46.813 | +48.700 | 7 | 3 | 70 | 1.9 | 2878.7 | me-7 | 2878.85 | 1.94384 | 0.00854627 | 0.00891159 | 67.0882 | 69.956
STRINGER | +44.375 | +47.013 | 7 | 3 | 100.3 | 2.8 | 4129.5 | me-6 | 4129.48 | 2.78828 | 0.0123469 | 0.012783 | 96.9228 | 100.346
STRINGER | +44.375 | +47.013 | 7 | 3 | 100.3 | 2.8 | 4129.5 | me-5 | 4129.48 | 2.78828 | 0.0123469 | 0.012783 | 96.9228 | 100.346
STRINGER | +41.606 | +44.575 | 7 | 3 | 110.2 | 3.1 | 4532.4 | me-2 | 4532.43 | 3.06036 | 0.0135627 | 0.0140303 | 106.467 | 110.138
STRINGER | +41.606 | +44.575 | 7 | 3 | 110.2 | 3.1 | 4532.4 | me-1 | 4532.43 | 3.06036 | 0.0135627 | 0.0140303 | 106.467 | 110.138
STRINGER | +38.838 | +41.806 | 7 | 3 | 110.2 | 3.1 | 4531.8 | me-4 | 4531.8 | 3.05993 | 0.0135608 | 0.0140284 | 106.453 | 110.123
STRINGER | +38.838 | +41.806 | 7 | 3 | 110.2 | 3.1 | 4531.8 | me-3 | 4531.8 | 3.05993 | 0.0135608 | 0.0140284 | 106.453 | 110.123
STRINGER | +36.070 | +39.038 | 7 | 3 | 110.2 | 3.1 | 4531.8 | me-2 | 4531.79 | 3.05993 | 0.0135608 | 0.0140284 | 106.452 | 110.123
STRINGER | +36.070 | +39.038 | 7 | 3 | 110.2 | 3.1 | 4531.8 | me-1 | 4531.79 | 3.05993 | 0.0135608 | 0.0140284 | 106.452 | 110.123
STRINGER | +33.799 | +36.270 | 6 | 3 | 93.1 | 2.6 | 3829.8 | md-7 | 3829.8 | 2.58593 | 0.0114346 | 0.0118553 | 89.762 | 93.0641
STRINGER | +33.799 | +36.270 | 6 | 3 | 93.1 | 2.6 | 3829.8 | md-8 | 3829.8 | 2.58593 | 0.0114346 | 0.0118553 | 89.762 | 93.0641
STRINGER | +31.528 | +33.999 | 6 | 3 | 93.1 | 2.6 | 3829.8 | md-8 | 3829.8 | 2.58594 | 0.0114347 | 0.0118553 | 89.7621 | 93.0642
STRINGER | +31.528 | +33.999 | 6 | 3 | 93.1 | 2.6 | 3829.8 | md-7 | 3829.8 | 2.58594 | 0.0114347 | 0.0118553 | 89.7621 | 93.0642
STRINGER | +28.880 | +31.728 | 6 | 3 | 108.3 | 3 | 4456 | md-6 | 4455.97 | 3.00873 | 0.0133377 | 0.0137936 | 104.701 | 108.28
STRINGER | +28.880 | +31.728 | 6 | 3 | 108.3 | 3 | 4456 | md-5 | 4455.97 | 3.00873 | 0.0133377 | 0.0137936 | 104.701 | 108.28
STRINGER | +26.215 | +29.080 | 6 | 3 | 108.5 | 3 | 4466.6 | md-4 | 4466.59 | 3.01591 | 0.0133689 | 0.0138265 | 104.946 | 108.538
STRINGER | +26.215 | +29.080 | 6 | 3 | 108.5 | 3 | 4466.6 | md-3 | 4466.59 | 3.01591 | 0.0133689 | 0.0138265 | 104.946 | 108.538
STRINGER | +24.118 | +26.415 | 6 | 3 | 85.7 | 2.5 | 3525.9 | md-2 | 3525.86 | 2.38071 | 0.0105098 | 0.0109145 | 82.502 | 85.6785
STRINGER | +24.118 | +26.415 | 6 | 3 | 85.7 | 2.5 | 3525.9 | md-1 | 3525.86 | 2.38071 | 0.0105098 | 0.0109145 | 82.502 | 85.6785
STRINGER | +21.260 | +24.318 | 4 | 3 | 116.2 | 3.2 | 4782.5 | mb-9 | 4782.47 | 3.22919 | 0.0143287 | 0.0148043 | 112.48 | 116.214
STRINGER | +21.260 | +24.318 | 4 | 3 | 116.2 | 3.2 | 4782.5 | mb-8 | 4782.47 | 3.22919 | 0.0143287 | 0.0148043 | 112.48 | 116.214
STRINGER | +19.555 | +21.460 | 4 | 3 | 70.2 | 1.9 | 2890.3 | mb-6 | 2890.25 | 1.95154 | 0.0085792 | 0.0089469 | 67.3467 | 70.2331
STRINGER | +19.555 | +21.460 | 4 | 3 | 70.2 | 1.9 | 2890.3 | mb-7 | 2890.25 | 1.95154 | 0.0085792 | 0.0089469 | 67.3467 | 70.2331
STRINGER | +17.850 | +19.755 | 4 | 3 | 70.2 | 1.9 | 2890.3 | mb-7 | 2890.25 | 1.95154 | 0.0085792 | 0.0089469 | 67.3467 | 70.2331
STRINGER | +17.850 | +19.755 | 4 | 3 | 70.2 | 1.9 | 2890.3 | mb-6 | 2890.25 | 1.95154 | 0.0085792 | 0.0089469 | 67.3467 | 70.2331
STRINGER | +15.500 | +18.050 | 4 | 3 | 94.3 | 2.6 | 3879.8 | mb-5 | 3879.85 | 2.61973 | 0.0115811 | 0.0120102 | 90.912 | 94.2803
STRINGER | +15.500 | +18.050 | 4 | 3 | 94.3 | 2.6 | 3879.8 | mb-4 | 3879.85 | 2.61973 | 0.0115811 | 0.0120102 | 90.912 | 94.2803
STRINGER | +12.945 | +15.700 | 4 | 3 | 102.1 | 2.8 | 4203.3 | mb-2 | 4203.27 | 2.83811 | 0.0125634 | 0.0130114 | 98.623 | 102.139
STRINGER | +12.945 | +15.700 | 4 | 3 | 102.1 | 2.8 | 4203.3 | mb-3 | 4203.27 | 2.83811 | 0.0125634 | 0.0130114 | 98.623 | 102.139
STRINGER | +10.390 | +13.145 | 4 | 3 | 102.1 | 2.8 | 4203.3 | mb-3 | 4203.27 | 2.83811 | 0.0125634 | 0.0130114 | 98.623 | 102.139
STRINGER | +10.390 | +13.145 | 4 | 3 | 102.1 | 2.8 | 4203.3 | mb-2 | 4203.27 | 2.83811 | 0.0125634 | 0.0130114 | 98.623 | 102.139
STRINGER | +7.945 | +10.590 | 3 | 3 | 100.5 | 2.8 | 4133.8 | ma-5 | 4133.84 | 2.79123 | 0.0123596 | 0.0127965 | 97.0231 | 100.452
STRINGER | +7.945 | +10.590 | 3 | 3 | 100.5 | 2.8 | 4133.8 | ma-6 | 4133.84 | 2.79123 | 0.0123596 | 0.0127965 | 97.0231 | 100.452
STRINGER | +5.500 | +8.145 | 3 | 3 | 100.5 | 2.8 | 4133.8 | ma-6 | 4133.84 | 2.79122 | 0.0123596 | 0.0127965 | 97.023 | 100.452
STRINGER | +5.500 | +8.145 | 3 | 3 | 100.5 | 2.8 | 4133.8 | ma-5 | 4133.84 | 2.79122 | 0.0123596 | 0.0127965 | 97.023 | 100.452
STRINGER | +2.500 | +5.700 | 3 | 3 | 118.4 | 3.3 | 4872.5 | ma-4 | 4872.5 | 3.28998 | 0.0145943 | 0.015083 | 114.565 | 118.402
STRINGER | +2.500 | +5.700 | 3 | 3 | 118.4 | 3.3 | 4872.5 | ma-3 | 4872.5 | 3.28998 | 0.0145943 | 0.015083 | 114.565 | 118.402
STRINGER | -0.060 | +2.700 | 3 | 3 | 104.7 | 3 | 4303 | ma-2 | 4302.98 | 2.90543 | 0.0127387 | 0.01332 | 99.9985 | 104.562
STRINGER | -0.060 | +2.700 | 3 | 3 | 104.7 | 3 | 4303 | ma-1 | 4302.98 | 2.90543 | 0.0127387 | 0.01332 | 99.9985 | 104.562
STRINGER | +68.250 | +70.650 | 8 | 3 | 87.3 | 2.5 | 3591.9 | mf-18 | 3591.88 | 2.42529 | 0.0107025 | 0.0111188 | 84.0147 | 87.2826
STRINGER | +68.250 | +70.650 | 8 | 3 | 87.3 | 2.5 | 3591.9 | mf-17 | 3591.88 | 2.42529 | 0.0107025 | 0.0111188 | 84.0147 | 87.2826
STRINGER | +63.250 | +66.250 | 8 | 3 | 110.6 | 3.1 | 4552.3 | mf-13 | 4552.34 | 3.0738 | 0.0136214 | 0.014092 | 106.928 | 110.622
STRINGER | +63.250 | +66.250 | 8 | 3 | 110.6 | 3.1 | 4552.3 | mf-12 | 4552.34 | 3.0738 | 0.0136214 | 0.014092 | 106.928 | 110.622
STRINGER | +60.535 | +63.450 | 8 | 3 | 109.3 | 3 | 4498.1 | mf-11 | 4498.06 | 3.03715 | 0.0134615 | 0.0139239 | 105.673 | 109.303
STRINGER | +60.535 | +63.450 | 8 | 3 | 109.3 | 3 | 4498.1 | mf-10 | 4498.06 | 3.03715 | 0.0134615 | 0.0139239 | 105.673 | 109.303
BEAM | -0.260 | +2.700 | 5 | 3 | 112.3 | 3.1 | 4623.1 | mc-12 | 4623.13 | 3.12161 | 0.0137116 | 0.0143111 | 107.636 | 112.342
BEAM | +2.500 | +5.700 | 5 | 3 | 118.4 | 3.3 | 4872.5 | mc-9 | 4872.5 | 3.28998 | 0.0145943 | 0.015083 | 114.565 | 118.402
BEAM | +5.500 | +7.900 | 5 | 3 | 87.3 | 2.5 | 3591.9 | mc-5 | 3591.87 | 2.42528 | 0.0107025 | 0.0111188 | 84.0146 | 87.2825
BEAM | +7.700 | +10.100 | 5 | 3 | 87.3 | 2.5 | 3591.9 | mc-5 | 3591.87 | 2.42528 | 0.0107025 | 0.0111188 | 84.0146 | 87.2825
BEAM | +9.900 | +12.500 | 5 | 3 | 95.2 | 2.6 | 3912 | mc-3 | 3912.03 | 2.64146 | 0.0116755 | 0.0121099 | 91.6523 | 95.0623
BEAM | -0.260 | +2.700 | 5 | 3 | 112.3 | 3.1 | 4623.1 | mc-11 | 4623.13 | 3.12161 | 0.0137116 | 0.0143111 | 107.636 | 112.342
BEAM | +2.500 | +5.700 | 5 | 3 | 118.4 | 3.3 | 4872.5 | mc-8 | 4872.5 | 3.28998 | 0.0145943 | 0.015083 | 114.565 | 118.402
BEAM | +5.500 | +7.900 | 5 | 3 | 87.3 | 2.5 | 3591.9 | mc-4 | 3591.87 | 2.42528 | 0.0107025 | 0.0111188 | 84.0146 | 87.2825
BEAM | +7.700 | +10.100 | 5 | 3 | 87.3 | 2.5 | 3591.9 | mc-4 | 3591.87 | 2.42528 | 0.0107025 | 0.0111188 | 84.0146 | 87.2825
BEAM | +9.900 | +12.500 | 5 | 3 | 95.2 | 2.6 | 3912 | mc-2 | 3912.03 | 2.64146 | 0.0116755 | 0.0121099 | 91.6523 | 95.0623

# IfcMember: UB356*171*51, KNEE BRACE
In: Undefined
Description: UB356*171*51; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +45.224; Top elevation: +48.322; Phase: 7; Class: 7
Tekla Quantity - Weight: 223.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.8 m2; Net surface area: 5.6 m2; Height: 355.6 mm; Width: 171.5 mm; Length: 4381.2 mm
Pset_MemberCommon - LoadBearing: yes; Reference: me-30
BaseQuantities - Length: 4381.16 mm; OuterSurfaceArea: 5.98067 m2; GrossSurfaceArea: 5.98067 m2; CrossSectionArea: 0.00649682 m2; NetVolume: 0.0256528 m3; GrossVolume: 0.0284636 m3; NetWeight: 201.374 kg; GrossWeight: 223.439 kg

# IfcPlate: PLT10*200 (2)
In: Undefined
Description: PLT10*200; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +5.710; Top elevation: +6.100; Phase: 3; Class: 8
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27.3 m2; Net surface area: 0.2 m2; Height: 200 mm; Width: 10 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - Width: 200 mm; CrossSectionArea: 0.0001 m2
Name | Weight (kg) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
STRINGER | 7.2 | 552.1 | pa-66 | 0.194182 | 0.110415 | 0.000907012
STRINGER | 7 | 545.8 | pa-65 | 0.191226 | 0.109165 | 0.000892826

# IfcPlate: PLT750*60 (419)
In: Undefined
Description: PLT750*60
Tekla Common - Phase: 2; Class: 4
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.2 m2; Net surface area: 0.5 m2; Height: 60 mm; Width: 750 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - Width: 60 mm; CrossSectionArea: 0.5625 m2
Name | Material | Bottom elevation | Top elevation | Weight (kg) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3) | Area per tons (m2)
Step | MISCELLANEOUS/COMPONENT | +12.279 | +12.339 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +12.088 | +12.148 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +11.897 | +11.957 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +11.706 | +11.766 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +11.515 | +11.575 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +11.324 | +11.384 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +11.133 | +11.193 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +10.942 | +11.002 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +10.751 | +10.811 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +15.470 | +15.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +15.270 | +15.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +15.070 | +15.130 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +14.870 | +14.930 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +14.670 | +14.730 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +14.470 | +14.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +14.270 | +14.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +13.870 | +13.930 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +13.670 | +13.730 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +13.470 | +13.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +13.270 | +13.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +13.070 | +13.130 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +12.870 | +12.930 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +12.670 | +12.730 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +5.870 | +5.930 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +6.070 | +6.130 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +6.270 | +6.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +6.470 | +6.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +6.670 | +6.730 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +6.870 | +6.930 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +7.070 | +7.130 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +7.270 | +7.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +7.470 | +7.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +8.070 | +8.130 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +8.270 | +8.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +8.470 | +8.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +8.670 | +8.730 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +8.870 | +8.930 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +9.070 | +9.130 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +9.270 | +9.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +9.470 | +9.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +9.670 | +9.730 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +10.270 | +10.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +10.470 | +10.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +10.670 | +10.730 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +10.870 | +10.930 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +11.070 | +11.130 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +11.270 | +11.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +11.470 | +11.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +11.670 | +11.730 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +11.870 | +11.930 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +12.070 | +12.130 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +2.870 | +2.930 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +3.070 | +3.130 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +3.270 | +3.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +3.470 | +3.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +3.670 | +3.730 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +3.870 | +3.930 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +4.070 | +4.130 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +4.270 | +4.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +4.470 | +4.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +4.670 | +4.730 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +4.870 | +4.930 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +5.070 | +5.130 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +5.270 | +5.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +12.270 | +12.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +9.870 | +9.930 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +7.670 | +7.730 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +5.470 | +5.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +2.470 | +2.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +2.270 | +2.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +2.070 | +2.130 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +1.870 | +1.930 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +1.670 | +1.730 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +1.470 | +1.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +1.270 | +1.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +1.070 | +1.130 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +0.870 | +0.930 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +0.670 | +0.730 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +0.470 | +0.530 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +0.270 | +0.330 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | +0.070 | +0.130 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | MISCELLANEOUS/COMPONENT | -0.130 | -0.070 | 0 | 274.9 | 471-0-010002 | 0.529571 | 0.0165 | 0.0123
Step | STEEL/S355JR | +48.483 | +48.543 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +48.295 | +48.355 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +48.108 | +48.168 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +47.920 | +47.980 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +47.733 | +47.793 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +47.545 | +47.605 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +47.358 | +47.418 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +47.170 | +47.230 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +70.420 | +70.480 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +70.220 | +70.280 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +70.020 | +70.080 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +69.820 | +69.880 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +69.620 | +69.680 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +69.420 | +69.480 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +69.220 | +69.280 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +69.020 | +69.080 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +68.820 | +68.880 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +68.620 | +68.680 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +68.220 | +68.280 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +68.020 | +68.080 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +67.820 | +67.880 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +67.620 | +67.680 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +67.420 | +67.480 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +67.220 | +67.280 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +67.020 | +67.080 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +66.820 | +66.880 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +66.620 | +66.680 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +66.420 | +66.480 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +66.020 | +66.080 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +65.820 | +65.880 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +65.620 | +65.680 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +65.420 | +65.480 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +65.220 | +65.280 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +65.020 | +65.080 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +64.820 | +64.880 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +64.620 | +64.680 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +64.420 | +64.480 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +64.220 | +64.280 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +64.020 | +64.080 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +63.820 | +63.880 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +63.620 | +63.680 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +63.226 | +63.286 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +63.032 | +63.092 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +62.838 | +62.898 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +62.644 | +62.704 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +62.450 | +62.510 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +62.256 | +62.316 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +62.062 | +62.122 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +61.869 | +61.929 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +61.675 | +61.735 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +61.481 | +61.541 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +61.287 | +61.347 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +61.093 | +61.153 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +60.899 | +60.959 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +60.511 | +60.571 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +60.317 | +60.377 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +60.123 | +60.183 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +59.929 | +59.989 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +59.735 | +59.795 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +59.541 | +59.601 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +59.347 | +59.407 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +59.154 | +59.214 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +58.960 | +59.020 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +58.766 | +58.826 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +58.572 | +58.632 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +58.378 | +58.438 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +58.184 | +58.244 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +57.796 | +57.856 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +57.602 | +57.662 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +57.408 | +57.468 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +57.214 | +57.274 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +57.020 | +57.080 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +56.826 | +56.886 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +56.632 | +56.692 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +56.439 | +56.499 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +56.245 | +56.305 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +56.051 | +56.111 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +55.857 | +55.917 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +55.663 | +55.723 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +55.469 | +55.529 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +55.086 | +55.146 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +54.897 | +54.957 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +54.709 | +54.769 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +54.520 | +54.580 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +54.331 | +54.391 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +54.142 | +54.202 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +53.954 | +54.014 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +53.765 | +53.825 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +53.576 | +53.636 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +53.387 | +53.447 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +53.199 | +53.259 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +52.821 | +52.881 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +52.633 | +52.693 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +52.444 | +52.504 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +52.255 | +52.315 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +52.066 | +52.126 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +51.878 | +51.938 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +51.689 | +51.749 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +51.500 | +51.560 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +51.312 | +51.372 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +50.934 | +50.994 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +50.746 | +50.806 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +50.557 | +50.617 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +50.368 | +50.428 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +50.180 | +50.240 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +49.991 | +50.051 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +49.802 | +49.862 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +49.613 | +49.673 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +49.425 | +49.485 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +49.236 | +49.296 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +49.047 | +49.107 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +48.859 | +48.919 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +46.795 | +46.855 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +46.608 | +46.668 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +46.420 | +46.480 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +46.233 | +46.293 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +46.045 | +46.105 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +45.858 | +45.918 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +45.670 | +45.730 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +45.483 | +45.543 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +45.295 | +45.355 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +45.108 | +45.168 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +44.920 | +44.980 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +44.733 | +44.793 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +44.347 | +44.407 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +44.149 | +44.209 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +43.952 | +44.012 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +43.754 | +43.814 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +43.556 | +43.616 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +43.358 | +43.418 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +43.160 | +43.220 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +42.963 | +43.023 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +42.765 | +42.825 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +42.567 | +42.627 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +42.369 | +42.429 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +42.172 | +42.232 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +41.974 | +42.034 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +41.578 | +41.638 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +41.381 | +41.441 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +41.183 | +41.243 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +40.985 | +41.045 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +40.787 | +40.847 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +40.590 | +40.650 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +40.392 | +40.452 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +40.194 | +40.254 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +39.997 | +40.057 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +39.799 | +39.859 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +39.601 | +39.661 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +39.403 | +39.463 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +39.206 | +39.266 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +24.097 | +24.157 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +23.907 | +23.967 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +23.716 | +23.776 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +23.526 | +23.586 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +23.335 | +23.395 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +23.145 | +23.205 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +22.954 | +23.014 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +22.764 | +22.824 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +22.573 | +22.633 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +22.383 | +22.443 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +22.192 | +22.252 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +22.002 | +22.062 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +21.811 | +21.871 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +21.621 | +21.681 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +33.780 | +33.840 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +33.590 | +33.650 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +33.401 | +33.461 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +33.212 | +33.272 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +33.023 | +33.083 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +32.833 | +32.893 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +32.644 | +32.704 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +32.455 | +32.515 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +32.266 | +32.326 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +32.076 | +32.136 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +31.887 | +31.947 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +26.194 | +26.254 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +26.004 | +26.064 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +25.813 | +25.873 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +25.622 | +25.682 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +25.432 | +25.492 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +25.241 | +25.301 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +25.051 | +25.111 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +24.860 | +24.920 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +24.669 | +24.729 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +24.479 | +24.539 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +28.860 | +28.920 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +28.669 | +28.729 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +28.479 | +28.539 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +28.289 | +28.349 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +28.098 | +28.158 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +27.908 | +27.968 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +27.717 | +27.777 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +27.527 | +27.587 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +27.337 | +27.397 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +27.146 | +27.206 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +26.956 | +27.016 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +26.766 | +26.826 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +26.575 | +26.635 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +31.509 | +31.569 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +31.320 | +31.380 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +31.131 | +31.191 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +30.941 | +31.001 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +30.752 | +30.812 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +30.563 | +30.623 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +30.374 | +30.434 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +30.185 | +30.245 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +29.996 | +30.056 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +29.807 | +29.867 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +29.617 | +29.677 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +29.428 | +29.488 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +29.239 | +29.299 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +36.051 | +36.111 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +35.861 | +35.921 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +35.672 | +35.732 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +35.483 | +35.543 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +35.294 | +35.354 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +35.104 | +35.164 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +34.915 | +34.975 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +34.726 | +34.786 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +34.537 | +34.597 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +34.347 | +34.407 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +34.158 | +34.218 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +38.810 | +38.870 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +38.613 | +38.673 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +38.415 | +38.475 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +38.217 | +38.277 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +38.019 | +38.079 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +37.822 | +37.882 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +37.624 | +37.684 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +37.426 | +37.486 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +37.229 | +37.289 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +37.031 | +37.091 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +36.833 | +36.893 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +36.635 | +36.695 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +36.438 | +36.498 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +21.241 | +21.301 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +21.051 | +21.111 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +20.862 | +20.922 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +20.672 | +20.732 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +20.483 | +20.543 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +20.293 | +20.353 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +20.104 | +20.164 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | STEEL/S355JR | +19.914 | +19.974 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | MISCELLANEOUS/COMPONENT | +19.536 | +19.596 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +19.346 | +19.406 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +19.157 | +19.217 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +18.967 | +19.027 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +18.778 | +18.838 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +18.588 | +18.648 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +18.399 | +18.459 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +18.209 | +18.269 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | STEEL/S355JR | +17.824 | +17.884 | 100.1 | 285 | 471-0-010000 | 0.545771 | 0.0171 | 0.01275 | 5.5
Step | MISCELLANEOUS/COMPONENT | +17.628 | +17.688 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +17.432 | +17.492 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +17.237 | +17.297 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +17.041 | +17.101 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +16.845 | +16.905 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +16.649 | +16.709 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +16.453 | +16.513 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +16.257 | +16.317 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +16.062 | +16.122 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +15.866 | +15.926 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +15.473 | +15.533 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +15.277 | +15.337 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +15.080 | +15.140 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +14.884 | +14.944 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +14.687 | +14.747 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +14.491 | +14.551 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +14.294 | +14.354 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +14.098 | +14.158 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +13.901 | +13.961 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +13.705 | +13.765 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +13.508 | +13.568 | 0 | 245 | 471-0-010003 | 0.480971 | 0.0147 | 0.01095
Step | MISCELLANEOUS/COMPONENT | +13.312 | +13.372 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +12.918 | +12.978 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +12.722 | +12.782 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +12.525 | +12.585 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +12.329 | +12.389 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +12.132 | +12.192 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +11.936 | +11.996 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +11.739 | +11.799 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +11.543 | +11.603 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +11.346 | +11.406 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +11.150 | +11.210 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +10.953 | +11.013 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +10.757 | +10.817 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +10.372 | +10.432 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +10.184 | +10.244 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +9.996 | +10.056 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +9.808 | +9.868 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +9.620 | +9.680 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +9.432 | +9.492 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +9.243 | +9.303 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +9.055 | +9.115 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +8.867 | +8.927 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +8.679 | +8.739 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +8.491 | +8.551 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +8.303 | +8.363 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +5.470 | +5.530 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +5.270 | +5.330 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +5.070 | +5.130 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +4.870 | +4.930 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +4.670 | +4.730 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +4.470 | +4.530 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +4.270 | +4.330 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +4.070 | +4.130 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +3.870 | +3.930 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +3.670 | +3.730 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +3.470 | +3.530 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +3.270 | +3.330 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +3.070 | +3.130 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +2.870 | +2.930 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +2.470 | +2.530 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +2.270 | +2.330 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +2.070 | +2.130 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +1.870 | +1.930 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +1.670 | +1.730 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +1.470 | +1.530 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +1.270 | +1.330 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +1.070 | +1.130 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +0.870 | +0.930 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +0.670 | +0.730 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +0.470 | +0.530 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +0.270 | +0.330 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +0.070 | +0.130 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +7.927 | +7.987 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +7.739 | +7.799 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +7.551 | +7.611 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +7.363 | +7.423 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +7.175 | +7.235 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +6.987 | +7.047 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +6.798 | +6.858 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +6.610 | +6.670 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +6.422 | +6.482 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +6.234 | +6.294 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +6.046 | +6.106 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
Step | MISCELLANEOUS/COMPONENT | +5.858 | +5.918 | 0 | 285 | 471-0-010001 | 0.545771 | 0.0171 | 0.01275
