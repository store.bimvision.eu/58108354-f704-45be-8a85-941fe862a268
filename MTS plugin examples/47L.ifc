Properties of the parts of a building model (IFC2X3), part 19 of 22

# IfcElementAssembly (4115)
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
4 x Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A-B/1 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | A/1 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.325 | +13.605 | B/1 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 341.6 | +10.234 | +10.590 | B-C/1-2 | 471-D-C42 | 270
2 x Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | B-C/1-2 | 471-D-C342 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | B-C/1-2 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C/1-2 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C/1-2 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 7.7 | +11.565 | +12.680 | B-C/1-2 | 471-D-C338 | 141.158
Steel Assembly | RIGID_FRAME | 7.7 | +11.565 | +12.680 | B-C/1-2 | 471-D-C337 | 141.158
Steel Assembly | RIGID_FRAME | 7.7 | +12.298 | +13.412 | B/1-2 | 471-D-C338 | 141.158
Steel Assembly | RIGID_FRAME | 7.7 | +12.298 | +13.412 | B/1-2 | 471-D-C337 | 141.158
Steel Assembly | RIGID_FRAME | 7.7 | +10.833 | +11.947 | B-C/1-2 | 471-D-C338 | 141.158
Steel Assembly | RIGID_FRAME | 7.7 | +10.833 | +11.947 | B-C/1-2 | 471-D-C337 | 141.158
Steel Assembly |  | 0 | +12.279 | +12.339 | B/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +12.088 | +12.148 | B-C/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +11.897 | +11.957 | B-C/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +11.706 | +11.766 | B-C/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +11.515 | +11.575 | B-C/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +11.324 | +11.384 | B-C/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +11.133 | +11.193 | B-C/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +10.942 | +11.002 | B-C/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +10.751 | +10.811 | B-C/1-2 | 471-0-010002 | 750
Steel Assembly | RIGID_FRAME | 159.4 | +12.500 | +15.700 | A-B/1 | 471-D-C18 | 160
Steel Assembly | RIGID_FRAME | 159.4 | +12.500 | +15.700 | A-B/1-2 | 471-D-C19 | 160
Steel Assembly | RIGID_FRAME | 7.8 | +14.100 | +15.205 | A-B/1 | 471-D-C336 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +14.100 | +15.205 | A-B/1-2 | 471-D-C335 | 70.0002
Steel Assembly | RIGID_FRAME | 103.6 | +9.900 | +12.500 | <A/2-3 | 471-D-C8 | 135.999
Steel Assembly | RIGID_FRAME | 103.6 | +9.900 | +12.500 | <A/2-3 | 471-D-C12 | 136.001
Steel Assembly | RIGID_FRAME | 95.8 | +7.700 | +10.100 | <A/2-4 | 471-D-C9 | 135.999
Steel Assembly | RIGID_FRAME | 95.8 | +7.700 | +10.100 | <A/2-4 | 471-D-C13 | 136.001
Steel Assembly | RIGID_FRAME | 95.8 | +5.500 | +7.900 | <A/3-5 | 471-D-C10 | 135.999
Steel Assembly | RIGID_FRAME | 95.8 | +5.500 | +7.900 | <A/3-5 | 471-D-C14 | 136.001
Steel Assembly | RIGID_FRAME | 127 | +2.500 | +5.700 | <A/4-5 | 471-D-C11 | 135.999
Steel Assembly | RIGID_FRAME | 127 | +2.500 | +5.700 | <A/4-5 | 471-D-C2 | 136.001
Steel Assembly | RIGID_FRAME | 7.7 | +14.416 | +15.534 | A-B/1-2 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +14.416 | +15.534 | A-B/1 | 471-D-C334 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +15.488 | +16.606 | B/1-2 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +15.488 | +16.606 | B/1 | 471-D-C334 | 138.995
Steel Assembly |  | 0 | +15.470 | +15.530 | B/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +15.270 | +15.330 | A-B/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +15.070 | +15.130 | A-B/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +14.870 | +14.930 | A-B/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +14.670 | +14.730 | A-B/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +14.470 | +14.530 | A-B/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +14.270 | +14.330 | A-B/1-2 | 471-0-010002 | 750
Steel Assembly | RIGID_FRAME | 7.7 | +13.888 | +15.006 | A-B/1-2 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +13.888 | +15.006 | A-B/1 | 471-D-C334 | 138.995
Steel Assembly |  | 0 | +13.870 | +13.930 | A-B/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +13.670 | +13.730 | A-B/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +13.470 | +13.530 | A-B/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +13.270 | +13.330 | A-B/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +13.070 | +13.130 | A-B/1-2 | 471-0-010002 | 750
Steel Assembly |  | 0 | +12.870 | +12.930 | A-B/1-2 | 471-0-010002 | 750
Steel Assembly | RIGID_FRAME | 7.7 | +12.744 | +13.862 | A-B/1-2 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +12.744 | +13.862 | A-B/1 | 471-D-C334 | 138.995
Steel Assembly |  | 0 | +12.670 | +12.730 | A-B/1-2 | 471-0-010002 | 750
Steel Assembly | RIGID_FRAME | 387 | +4.992 | +6.048 | A/4-5 | 471-D-C48 | 196.75
Steel Assembly | RIGID_FRAME | 257.7 | +5.005 | +6.039 | A/3-4 | 471-D-C129 | 190
Steel Assembly | RIGID_FRAME | 428.5 | +4.991 | +6.052 | A/2-3 | 471-D-C127 | 271.751
Steel Assembly | RIGID_FRAME | 284.6 | +5.000 | +6.045 | A/1-2 | 471-D-C73 | 315.001
Steel Assembly | RIGID_FRAME | 331.6 | +0.053 | +5.319 | A/5-6 | 471-D-C428 | 219.1
Steel Assembly | RIGID_FRAME | 331.4 | +0.053 | +5.319 | A/4-5 | 471-D-C438 | 219.1
Steel Assembly | RIGID_FRAME | 275.5 | +0.063 | +5.319 | A/3-4 | 471-D-C439 | 219.1
Steel Assembly | RIGID_FRAME | 363.5 | +0.049 | +5.319 | A/2-3 | 471-D-C441 | 219.1
Steel Assembly | RIGID_FRAME | 285.1 | +0.072 | +5.319 | A/1-2 | 471-D-C440 | 219.1
Steel Assembly | RIGID_FRAME | 1284.9 | +0.000 | +12.500 | A/4 | 471-D-C149 | 637.86
Steel Assembly | RIGID_FRAME | 1284.7 | +0.000 | +12.500 | A/3 | 471-D-C147 | 626.066
Steel Assembly | RIGID_FRAME | 1285.4 | +0.000 | +12.500 | A/2 | 471-D-C145 | 637.867
Steel Assembly | RIGID_FRAME | 323.3 | +5.735 | +12.119 | A/1-2 | 471-D-C424 | 219.1
Steel Assembly | RIGID_FRAME | 392.9 | +5.725 | +12.119 | A/2-3 | 471-D-C442 | 219.1
Steel Assembly | RIGID_FRAME | 314.6 | +5.735 | +12.119 | A/3-4 | 471-D-C437 | 219.1
Steel Assembly | RIGID_FRAME | 364.2 | +5.725 | +12.119 | A/4-5 | 471-D-C427 | 219.1
Steel Assembly | RIGID_FRAME | 364.2 | +5.725 | +12.119 | A/5-6 | 471-D-C427 | 219.1
Steel Assembly | RIGID_FRAME | 7.8 | +12.500 | +13.605 | <A/2-3 | 471-D-C336 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +10.100 | +11.205 | <A/2-3 | 471-D-C336 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +10.100 | +11.205 | <A/2-3 | 471-D-C335 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +7.900 | +9.005 | <A/3-4 | 471-D-C336 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +7.900 | +9.005 | <A/3-4 | 471-D-C335 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +5.700 | +6.805 | <A/4-5 | 471-D-C336 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +2.700 | +3.805 | <A/5 | 471-D-C335 | 70.0002
Steel Assembly |  | 0 | +5.870 | +5.930 | <A/4 | 471-0-010002 | 750
Steel Assembly |  | 0 | +6.070 | +6.130 | <A/4 | 471-0-010002 | 750
Steel Assembly |  | 0 | +6.270 | +6.330 | <A/4 | 471-0-010002 | 750
Steel Assembly |  | 0 | +6.470 | +6.530 | <A/3-4 | 471-0-010002 | 750
Steel Assembly |  | 0 | +6.670 | +6.730 | <A/3-4 | 471-0-010002 | 750
Steel Assembly |  | 0 | +6.870 | +6.930 | <A/3-4 | 471-0-010002 | 750
Steel Assembly |  | 0 | +7.070 | +7.130 | <A/3-4 | 471-0-010002 | 750
Steel Assembly |  | 0 | +7.270 | +7.330 | <A/3-4 | 471-0-010002 | 750
Steel Assembly |  | 0 | +7.470 | +7.530 | <A/3-4 | 471-0-010002 | 750
Steel Assembly |  | 0 | +8.070 | +8.130 | <A/3-4 | 471-0-010002 | 750
Steel Assembly |  | 0 | +8.270 | +8.330 | <A/3-4 | 471-0-010002 | 750
Steel Assembly |  | 0 | +8.470 | +8.530 | <A/3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +8.670 | +8.730 | <A/3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +8.870 | +8.930 | <A/2-3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +9.070 | +9.130 | <A/2-3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +9.270 | +9.330 | <A/2-3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +9.470 | +9.530 | <A/2-3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +9.670 | +9.730 | <A/2-3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +10.270 | +10.330 | <A/2-3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +10.470 | +10.530 | <A/2-3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +10.670 | +10.730 | <A/2-3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +10.870 | +10.930 | <A/2-3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +11.070 | +11.130 | <A/2-3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +11.270 | +11.330 | <A/2-3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +11.470 | +11.530 | <A/2-3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +11.670 | +11.730 | <A/2-3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +11.870 | +11.930 | <A/2-3 | 471-0-010002 | 750
Steel Assembly |  | 0 | +12.070 | +12.130 | <A/2-3 | 471-0-010002 | 750
Steel Assembly | RIGID_FRAME | 7.7 | +4.252 | +5.370 | <A/4-5 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +4.252 | +5.370 | <A/4-5 | 471-D-C334 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +6.852 | +7.970 | <A/3-4 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +6.852 | +7.970 | <A/3-4 | 471-D-C334 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +9.052 | +10.170 | <A/2-3 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +9.052 | +10.170 | <A/2-3 | 471-D-C334 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +11.352 | +12.470 | <A/2-3 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +11.352 | +12.470 | <A/2-3 | 471-D-C334 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +10.416 | +11.534 | <A/2-3 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +10.416 | +11.534 | <A/2-3 | 471-D-C334 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +8.216 | +9.334 | <A/3-4 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +8.216 | +9.334 | <A/3-4 | 471-D-C334 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +6.016 | +7.134 | <A/4 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +6.016 | +7.134 | <A/4 | 471-D-C334 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +3.016 | +4.134 | <A/4-5 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +3.016 | +4.134 | <A/4-5 | 471-D-C334 | 138.995
Steel Assembly |  | 0 | +2.870 | +2.930 | <A/4-5 | 471-0-010002 | 750
Steel Assembly |  | 0 | +3.070 | +3.130 | <A/4-5 | 471-0-010002 | 750
Steel Assembly |  | 0 | +3.270 | +3.330 | <A/4-5 | 471-0-010002 | 750
Steel Assembly |  | 0 | +3.470 | +3.530 | <A/4-5 | 471-0-010002 | 750
Steel Assembly |  | 0 | +3.670 | +3.730 | <A/4-5 | 471-0-010002 | 750
Steel Assembly |  | 0 | +3.870 | +3.930 | <A/4-5 | 471-0-010002 | 750
Steel Assembly |  | 0 | +4.070 | +4.130 | <A/4-5 | 471-0-010002 | 750
Steel Assembly |  | 0 | +4.270 | +4.330 | <A/4-5 | 471-0-010002 | 750
Steel Assembly |  | 0 | +4.470 | +4.530 | <A/4-5 | 471-0-010002 | 750
Steel Assembly |  | 0 | +4.670 | +4.730 | <A/4-5 | 471-0-010002 | 750
Steel Assembly |  | 0 | +4.870 | +4.930 | <A/4-5 | 471-0-010002 | 750
Steel Assembly |  | 0 | +5.070 | +5.130 | <A/4-5 | 471-0-010002 | 750
Steel Assembly |  | 0 | +5.270 | +5.330 | <A/4-5 | 471-0-010002 | 750
Steel Assembly | RIGID_FRAME | 7.7 | +12.288 | +13.406 | <A/2-3 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +12.288 | +13.406 | <A/2-3 | 471-D-C334 | 138.995
Steel Assembly |  | 0 | +12.270 | +12.330 | <A/2-3 | 471-0-010002 | 750
Steel Assembly | RIGID_FRAME | 7.7 | +9.888 | +11.006 | <A/2-3 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +9.888 | +11.006 | <A/2-3 | 471-D-C334 | 138.995
Steel Assembly |  | 0 | +9.870 | +9.930 | <A/2-3 | 471-0-010002 | 750
Steel Assembly | RIGID_FRAME | 7.7 | +7.688 | +8.806 | <A/3-4 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +7.688 | +8.806 | <A/3-4 | 471-D-C334 | 138.995
Steel Assembly |  | 0 | +7.670 | +7.730 | <A/3-4 | 471-0-010002 | 750
Steel Assembly | RIGID_FRAME | 7.7 | +5.488 | +6.606 | <A/4-5 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +5.488 | +6.606 | <A/4-5 | 471-D-C334 | 138.995
Steel Assembly |  | 0 | +5.470 | +5.530 | <A/4-5 | 471-0-010002 | 750
Steel Assembly | RIGID_FRAME | 7.7 | +1.640 | +2.758 | <A/5-6 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +1.640 | +2.758 | <A/5-6 | 471-D-C334 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +0.792 | +1.910 | <A/5-6 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +0.792 | +1.910 | <A/5-6 | 471-D-C334 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +2.488 | +3.606 | <A/5-6 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +2.488 | +3.606 | <A/5-6 | 471-D-C334 | 138.995
Steel Assembly | RIGID_FRAME | 118.2 | -0.270 | +2.700 | <A/5-6 | 471-D-C4 | 90
Steel Assembly | RIGID_FRAME | 118.2 | -0.270 | +2.700 | <A/5-6 | 471-D-C5 | 90
Steel Assembly |  | 0 | +2.470 | +2.530 | <A/5-6 | 471-0-010002 | 750
Steel Assembly |  | 0 | +2.270 | +2.330 | <A/5-6 | 471-0-010002 | 750
Steel Assembly |  | 0 | +2.070 | +2.130 | <A/5-6 | 471-0-010002 | 750
Steel Assembly |  | 0 | +1.870 | +1.930 | <A/5-6 | 471-0-010002 | 750
Steel Assembly |  | 0 | +1.670 | +1.730 | <A/5-6 | 471-0-010002 | 750
Steel Assembly |  | 0 | +1.470 | +1.530 | <A/5-6 | 471-0-010002 | 750
Steel Assembly |  | 0 | +1.270 | +1.330 | <A/5-6 | 471-0-010002 | 750
Steel Assembly |  | 0 | +1.070 | +1.130 | <A/5-6 | 471-0-010002 | 750
Steel Assembly |  | 0 | +0.870 | +0.930 | <A/5-6 | 471-0-010002 | 750
Steel Assembly |  | 0 | +0.670 | +0.730 | <A/5-6 | 471-0-010002 | 750
Steel Assembly |  | 0 | +0.470 | +0.530 | <A/5-6 | 471-0-010002 | 750
Steel Assembly |  | 0 | +0.270 | +0.330 | <A/5-6 | 471-0-010002 | 750
Steel Assembly |  | 0 | +0.070 | +0.130 | <A/5-6 | 471-0-010002 | 750
Steel Assembly | RIGID_FRAME | 7.7 | -0.056 | +1.062 | <A/5-6 | 471-D-C333 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | -0.056 | +1.062 | <A/5-6 | 471-D-C334 | 138.995
Steel Assembly |  | 0 | -0.130 | -0.070 | <A/5-6 | 471-0-010002 | 750
Steel Assembly | RIGID_FRAME | 419.6 | +15.815 | +21.207 | C/3-4 | 471-C-B280 | 273.1
Steel Assembly | RIGID_FRAME | 2387.1 | +12.002 | +25.803 | C/3 | 471-C-B237 | 688.477
Steel Assembly | RIGID_FRAME | 464.7 | +18.100 | +24.065 | C/1-2 | 471-C-B281 | 273.1
Steel Assembly | RIGID_FRAME | 2375.2 | +12.002 | +25.803 | C/2 | 471-C-B243 | 688.49
Steel Assembly | RIGID_FRAME | 284.5 | +14.950 | +16.238 | C/3-4 | 471-C-B52 | 315
Steel Assembly | RIGID_FRAME | 299.5 | +17.350 | +18.523 | C/1-2 | 471-C-B38 | 190
Steel Assembly | RIGID_FRAME | 264.5 | +18.075 | +21.052 | C/2-3 | 471-C-B250 | 219.1
Steel Assembly | RIGID_FRAME | 250.7 | +18.052 | +21.102 | C/2-3 | 471-C-B279 | 254
Steel Assembly | RIGID_FRAME | 460.9 | +17.694 | +18.398 | C/2-3 | 471-C-B29 | 314.99
Steel Assembly | RIGID_FRAME | 174.2 | +15.702 | +17.692 | C/2-3 | 471-C-B278 | 254
Steel Assembly | RIGID_FRAME | 238.5 | +15.725 | +17.662 | C/2-3 | 471-C-B251 | 219.1
Steel Assembly | RIGID_FRAME | 448 | +14.992 | +16.035 | C/2-3 | 471-C-B63 | 321.75
Steel Assembly | RIGID_FRAME | 95.8 | +66.050 | +68.450 | D/2-3 | 471-G-F15 | 136
Steel Assembly | RIGID_FRAME | 95.8 | +66.050 | +68.450 | D-E/2-3 | 471-G-F17 | 136
Steel Assembly | RIGID_FRAME | 117.8 | +60.535 | +63.450 | D/2-3 | 471-G-F6 | 136
Steel Assembly | RIGID_FRAME | 117.8 | +60.535 | +63.450 | D-E/2-3 | 471-G-F5 | 136
Steel Assembly | RIGID_FRAME | 117.8 | +55.105 | +58.020 | D/2-3 | 471-G-F6 | 136
Steel Assembly | RIGID_FRAME | 101.6 | +31.528 | +33.999 | D/2-3 | 471-E-D179 | 136
Steel Assembly | RIGID_FRAME | 101.6 | +31.528 | +33.999 | D-E/2-3 | 471-E-D182 | 136
Steel Assembly | RIGID_FRAME | 95.8 | +68.250 | +70.650 | D-E/2-3 | 471-G-F16 | 136
Steel Assembly | RIGID_FRAME | 95.8 | +68.250 | +70.650 | E/2-3 | 471-G-F14 | 136
Steel Assembly | RIGID_FRAME | 119.2 | +63.250 | +66.250 | D-E/2-3 | 471-G-F9 | 136
Steel Assembly | RIGID_FRAME | 119.2 | +63.250 | +66.250 | E/2-3 | 471-G-F8 | 136
Steel Assembly | RIGID_FRAME | 117.8 | +57.820 | +60.735 | E/2-3 | 471-G-F7 | 136
Steel Assembly | RIGID_FRAME | 101.5 | +52.840 | +55.305 | D-E/2-3 | 471-G-F20 | 136
Steel Assembly | RIGID_FRAME | 101.5 | +52.840 | +55.305 | E/2-3 | 471-G-F18 | 136
Steel Assembly | RIGID_FRAME | 101.6 | +33.799 | +36.270 | D-E/2-3 | 471-E-D182 | 136
Steel Assembly | RIGID_FRAME | 101.6 | +33.799 | +36.270 | E/2-3 | 471-E-D179 | 136
Steel Assembly | RIGID_FRAME | 116.8 | +28.880 | +31.728 | D-E/2-3 | 471-E-D181 | 136
Steel Assembly | RIGID_FRAME | 116.8 | +28.880 | +31.728 | E/2-3 | 471-E-D178 | 136
Steel Assembly | RIGID_FRAME | 102.7 | +24.118 | +26.415 | D-E/2-3 | 471-E-D6 | 136
Steel Assembly | RIGID_FRAME | 102.7 | +24.118 | +26.415 | E/2-3 | 471-E-D7 | 136
Steel Assembly | RIGID_FRAME | 117.1 | +26.215 | +29.080 | D/2-3 | 471-E-D177 | 136
Steel Assembly | RIGID_FRAME | 117.1 | +26.215 | +29.080 | D-E/2-3 | 471-E-D180 | 136
Steel Assembly | RIGID_FRAME | 124.8 | +21.260 | +24.318 | D/2-3 | 471-C-B2 | 136
Steel Assembly | RIGID_FRAME | 124.8 | +21.260 | +24.318 | D-E/2-3 | 471-C-B11 | 136
Steel Assembly | RIGID_FRAME | 78.8 | +17.850 | +19.755 | D/2-3 | 471-C-B7 | 136
Steel Assembly | RIGID_FRAME | 78.8 | +17.850 | +19.755 | D-E/2-3 | 471-C-B9 | 136
Steel Assembly | RIGID_FRAME | 78.8 | +19.555 | +21.460 | D-E/2-3 | 471-C-B10 | 136
Steel Assembly | RIGID_FRAME | 78.8 | +19.555 | +21.460 | E/2-3 | 471-C-B8 | 136
Steel Assembly | RIGID_FRAME | 102.9 | +15.500 | +18.050 | D-E/2-3 | 471-C-B4 | 136
Steel Assembly | RIGID_FRAME | 102.9 | +15.500 | +18.050 | E/2-3 | 471-C-B6 | 136
Steel Assembly | RIGID_FRAME | 110.7 | +12.945 | +15.700 | D/2-3 | 471-C-B5 | 136
Steel Assembly | RIGID_FRAME | 110.7 | +12.945 | +15.700 | D-E/2-3 | 471-C-B3 | 136
Steel Assembly | RIGID_FRAME | 110.7 | +10.390 | +13.145 | D-E/2-3 | 471-C-B3 | 136
Steel Assembly | RIGID_FRAME | 110.7 | +10.390 | +13.145 | E/2-3 | 471-C-B5 | 136
Steel Assembly | RIGID_FRAME | 109 | +7.945 | +10.590 | D/2-3 | 471-B-A7 | 136
Steel Assembly | RIGID_FRAME | 109 | +7.945 | +10.590 | D-E/2-3 | 471-B-A8 | 136
Steel Assembly | RIGID_FRAME | 109 | +5.500 | +8.145 | D-E/2-3 | 471-B-A8 | 136
Steel Assembly | RIGID_FRAME | 109 | +5.500 | +8.145 | E/2-3 | 471-B-A7 | 136
Steel Assembly | RIGID_FRAME | 127 | +2.500 | +5.700 | D/2-3 | 471-B-A5 | 136
Steel Assembly | RIGID_FRAME | 127 | +2.500 | +5.700 | D-E/2-3 | 471-B-A6 | 136
Steel Assembly | RIGID_FRAME | 266.9 | +10.625 | +15.309 | E/1-2 | 471-C-B261 | 219.1
Steel Assembly | RIGID_FRAME | 343.6 | +10.615 | +15.319 | E/2-3 | 471-C-B256 | 219.1
Steel Assembly | RIGID_FRAME | 183.6 | +15.725 | +17.669 | E/1-2 | 471-C-B262 | 219.1
Steel Assembly | RIGID_FRAME | 269.1 | +15.725 | +17.669 | E/2-3 | 471-C-B257 | 219.1
Steel Assembly | RIGID_FRAME | 299.2 | +18.075 | +21.079 | E/2-3 | 471-C-B266 | 219.1
Steel Assembly | RIGID_FRAME | 284.5 | +21.485 | +23.937 | E/2-3 | 471-C-B260 | 219.1
Steel Assembly | RIGID_FRAME | 208.3 | +15.413 | +15.632 | D-E/1-2 | 471-C-B247 | 250
Steel Assembly | RIGID_FRAME | 196.2 | +14.850 | +16.053 | D-E/1 | 471-C-B46 | 416.921
Steel Assembly | RIGID_FRAME | 197.9 | +14.993 | +16.053 | D-E/2 | 471-C-B24 | 468.247
Steel Assembly | RIGID_FRAME | 317.8 | +15.413 | +15.632 | C-D/1-2 | 471-C-B246 | 250
Steel Assembly | RIGID_FRAME | 468.7 | +15.008 | +16.051 | C-D/2 | 471-C-B36 | 599.634
Steel Assembly | RIGID_FRAME | 422.9 | +14.992 | +16.032 | C-D/1 | 471-C-B40 | 451.143
Steel Assembly | RIGID_FRAME | 305.7 | +17.593 | +17.812 | C-D/1-2 | 471-C-B248 | 250
Steel Assembly | RIGID_FRAME | 415.7 | +17.363 | +18.050 | C-D/1 | 471-C-B31 | 608.992
Steel Assembly | RIGID_FRAME | 175.6 | +17.606 | +17.799 | D-E/1-2 | 471-C-B235 | 210
Steel Assembly | RIGID_FRAME | 179.3 | +17.342 | +18.050 | D-E/1 | 471-C-B44 | 552.35
Steel Assembly | RIGID_FRAME | 192 | +17.342 | +18.401 | D-E/2 | 471-C-B48 | 476.601
Steel Assembly | RIGID_FRAME | 47 | +21.260 | +21.460 | C-D/2-3 | 471-C-B115 | 327.903
Steel Assembly | RIGID_FRAME | 489.1 | +20.753 | +21.813 | C-D/2 | 471-C-B26 | 314.99
Steel Assembly | RIGID_FRAME | 27.9 | +21.260 | +21.460 | C-D/1-2 | 471-C-B233 | 87
Steel Assembly | RIGID_FRAME | 25.2 | +21.260 | +21.460 | C-D/1-2 | 471-C-B234 | 75
Steel Assembly | RIGID_FRAME | 51.6 | +21.160 | +21.460 | C-D/1-2 | 471-C-B229 | 100
Steel Assembly | RIGID_FRAME | 26.7 | +21.260 | +21.460 | C-D/1-2 | 471-C-B231 | 75
Steel Assembly | RIGID_FRAME | 377.5 | +21.104 | +21.460 | C-D/1-2 | 471-C-B21 | 183.5
Steel Assembly | RIGID_FRAME | 44.6 | +19.996 | +21.102 | C/1-2 | 471-C-B135 | 180
Steel Assembly | RIGID_FRAME | 44.6 | +19.996 | +21.102 | D/1-2 | 471-C-B135 | 180
Steel Assembly | RIGID_FRAME | 81.8 | +21.104 | +21.460 | D/1-2 | 471-C-B22 | 190
2 x Steel Assembly | RIGID_FRAME | 102.7 | +17.850 | +18.050 | C-D/1-2 | 471-C-B132 | 160
Steel Assembly | RIGID_FRAME | 30.2 | +26.063 | +26.215 | D-E/2-3 | 471-E-D98 | 152.4
Steel Assembly | RIGID_FRAME | 36.1 | +21.257 | +21.460 | C-D/2-3 | 471-C-B228 | 203.2
Steel Assembly | RIGID_FRAME | 11.1 | +21.273 | +21.353 | C-D/2-3 | 471-C-B182 | 80
Steel Assembly | RIGID_FRAME | 46.4 | +21.257 | +21.460 | C-D/2-3 | 471-C-B227 | 289.896
Steel Assembly | RIGID_FRAME | 53 | +21.106 | +21.460 | C-D/2-3 | 471-C-B96 | 346.428
Steel Assembly | RIGID_FRAME | 15.1 | +21.273 | +21.353 | C-D/2-3 | 471-C-B183 | 80
Steel Assembly | RIGID_FRAME | 57.1 | +21.257 | +21.460 | C-D/2 | 471-C-B225 | 291.298
Steel Assembly | RIGID_FRAME | 46.4 | +21.260 | +21.460 | C-D/2-3 | 471-C-B94 | 354.431
Steel Assembly | RIGID_FRAME | 57.5 | +19.555 | +19.755 | D-E/2-3 | 471-C-B119 | 280.928
Steel Assembly | RIGID_FRAME | 30.2 | +19.403 | +19.555 | D-E/2-3 | 471-C-B143 | 152.4
Steel Assembly | RIGID_FRAME | 472.1 | +17.694 | +18.394 | D/2-3 | 471-C-B30 | 446.2
Steel Assembly | RIGID_FRAME | 27.9 | +17.847 | +18.050 | D/2-3 | 471-C-B220 | 302.729
Steel Assembly | RIGID_FRAME | 65.5 | +17.847 | +18.050 | D/2-3 | 471-C-B221 | 264.068
Steel Assembly | RIGID_FRAME | 44.7 | +17.847 | +18.050 | C-D/2-3 | 471-C-B213 | 203.2
Steel Assembly | RIGID_FRAME | 11.1 | +17.863 | +17.943 | C-D/2-3 | 471-C-B159 | 80
Steel Assembly | RIGID_FRAME | 132.7 | +17.850 | +18.050 | C-D/2-3 | 471-C-B73 | 326.494
Steel Assembly | RIGID_FRAME | 6 | +17.863 | +17.943 | C-D/2-3 | 471-C-B164 | 80
Steel Assembly | RIGID_FRAME | 34.5 | +17.696 | +18.050 | C-D/2-3 | 471-C-B88 | 388.318
Steel Assembly | RIGID_FRAME | 88.8 | +17.847 | +18.050 | D/2-3 | 471-C-B219 | 247.708
Steel Assembly | RIGID_FRAME | 15.6 | +17.863 | +17.943 | C-D/2-3 | 471-C-B171 | 80
Steel Assembly | RIGID_FRAME | 12.2 | +17.863 | +17.943 | C-D/2-3 | 471-C-B176 | 80
Steel Assembly | RIGID_FRAME | 46.3 | +17.847 | +18.050 | C-D/2-3 | 471-C-B226 | 292.56
Steel Assembly | RIGID_FRAME | 46.6 | +17.850 | +18.050 | C-D/2-3 | 471-C-B91 | 351.926
Steel Assembly | RIGID_FRAME | 70 | +24.118 | +24.318 | D-E/2-3 | 471-C-B120 | 272.119
Steel Assembly | RIGID_FRAME | 30.2 | +23.966 | +24.118 | D-E/2-3 | 471-C-B143 | 152.4
Steel Assembly | RIGID_FRAME | 13.8 | +17.863 | +17.943 | C-D/2-3 | 471-C-B175 | 80
Steel Assembly | RIGID_FRAME | 47 | +17.850 | +18.050 | C-D/2-3 | 471-C-B93 | 325.878
Steel Assembly | RIGID_FRAME | 30.2 | +17.750 | +18.050 | C-D/2-3 | 471-C-B104 | 455.898
Steel Assembly | RIGID_FRAME | 46.6 | +17.847 | +18.050 | C-D/2 | 471-C-B218 | 314.762
Steel Assembly | RIGID_FRAME | 28.3 | +21.160 | +21.460 | C-D/2-3 | 471-C-B103 | 307.949
Steel Assembly | RIGID_FRAME | 51.2 | +21.257 | +21.460 | C/2-3 | 471-C-B224 | 274.324
Steel Assembly | RIGID_FRAME | 33.9 | +21.257 | +21.460 | C/2-3 | 471-C-B223 | 289.02
Steel Assembly | RIGID_FRAME | 26.2 | +21.108 | +21.260 | B-C/2-3 | 471-C-B142 | 152.4
Steel Assembly | RIGID_FRAME | 6.9 | +21.273 | +21.353 | C-D/2-3 | 471-C-B189 | 80
Steel Assembly | RIGID_FRAME | 47.2 | +21.257 | +21.460 | C-D/2-3 | 471-C-B215 | 306.657
Steel Assembly | RIGID_FRAME | 9.7 | +21.273 | +21.353 | C-D/2-3 | 471-C-B178 | 80
Steel Assembly | RIGID_FRAME | 46.7 | +21.257 | +21.460 | C-D/2-3 | 471-C-B214 | 314.57
Steel Assembly | RIGID_FRAME | 45.2 | +21.257 | +21.460 | C/2-3 | 471-C-B222 | 279.462
Steel Assembly | RIGID_FRAME | 10.1 | +21.273 | +21.353 | C-D/2-3 | 471-C-B185 | 80
Steel Assembly | RIGID_FRAME | 136 | +21.106 | +21.460 | C-D/2-3 | 471-C-B71 | 350.694
Steel Assembly | RIGID_FRAME | 46.7 | +21.257 | +21.460 | C-D/2-3 | 471-C-B216 | 285.703
Steel Assembly | RIGID_FRAME | 8.7 | +21.273 | +21.353 | C-D/2-3 | 471-C-B188 | 80
Steel Assembly | RIGID_FRAME | 26.1 | +21.260 | +21.460 | C-D/2-3 | 471-C-B95 | 280.723
Steel Assembly | RIGID_FRAME | 9.7 | +21.273 | +21.353 | C-D/2-3 | 471-C-B180 | 80
Steel Assembly | RIGID_FRAME | 130.9 | +21.260 | +21.460 | C-D/2-3 | 471-C-B75 | 269.033
Steel Assembly | RIGID_FRAME | 48.4 | +21.257 | +21.460 | C-D/2-3 | 471-C-B217 | 371.999
Steel Assembly | RIGID_FRAME | 11.6 | +21.273 | +21.353 | C-D/2-3 | 471-C-B187 | 80
Steel Assembly | RIGID_FRAME | 28.3 | +21.260 | +21.460 | C-D/2-3 | 471-C-B85 | 437.576
Steel Assembly | RIGID_FRAME | 33.5 | +20.952 | +21.104 | C-D/2-3 | 471-C-B140 | 152.4
Steel Assembly | RIGID_FRAME | 39.4 | +20.952 | +21.104 | B-C/2-3 | 471-C-B141 | 152.4
Steel Assembly | RIGID_FRAME | 100.3 | +21.106 | +21.460 | B-C/2-3 | 471-C-B12 | 239.993
Steel Assembly | RIGID_FRAME | 140.4 | +21.106 | +21.460 | C-D/2-3 | 471-C-B74 | 326.494
5 x Steel Assembly | RIGID_FRAME | 27.2 | +20.952 | +21.104 | C-D/2-3 | 471-C-B139 | 152.4
Steel Assembly | RIGID_FRAME | 979.5 | +12.002 | +18.050 | D/1 | 471-C-B239 | 310.6
Steel Assembly | RIGID_FRAME | 53.2 | +21.106 | +21.460 | C-D/2-3 | 471-C-B111 | 337.988
Steel Assembly | RIGID_FRAME | 53 | +21.106 | +21.460 | C-D/2-3 | 471-C-B110 | 346.838
Steel Assembly | RIGID_FRAME | 74.1 | +24.118 | +24.318 | D-E/2-3 | 471-C-B17 | 226.818
Steel Assembly | RIGID_FRAME | 8.2 | +24.143 | +25.423 | E/2-3 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +24.143 | +25.423 | D/2-3 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 424.3 | +23.625 | +24.670 | D/2-3 | 471-C-B62 | 315.067
Steel Assembly | RIGID_FRAME | 8.2 | +24.143 | +25.423 | D/2-3 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 424.3 | +23.625 | +24.670 | E/2-3 | 471-C-B61 | 315.067
Steel Assembly | RIGID_FRAME | 8.2 | +24.143 | +25.423 | E/2-3 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 74.5 | +21.260 | +21.460 | D-E/2-3 | 471-C-B16 | 226.342
Steel Assembly | RIGID_FRAME | 70 | +21.260 | +21.460 | D-E/2-3 | 471-C-B121 | 271.642
Steel Assembly | RIGID_FRAME | 30.2 | +21.108 | +21.260 | D-E/2-3 | 471-C-B143 | 152.4
3 x Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | C/2-3 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | C/3 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 310.5 | +21.104 | +21.813 | C-D/3 | 471-C-B65 | 309.99
Steel Assembly | RIGID_FRAME | 65.2 | +21.104 | +21.460 | C-D/3 | 471-C-B56 | 314.99
Steel Assembly | RIGID_FRAME | 65.2 | +21.104 | +21.460 | C-D/3 | 471-C-B57 | 314.99
3 x Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | C-D/3 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | D/3 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | C/3 | 471-C-B204 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | C-D/2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | D/2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | C/2 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 33.5 | +17.542 | +17.694 | C-D/3 | 471-C-B140 | 152.4
Steel Assembly | RIGID_FRAME | 131.6 | +17.696 | +18.050 | C-D/2-3 | 471-C-B76 | 240.974
2 x Steel Assembly | RIGID_FRAME | 27.2 | +17.542 | +17.694 | C-D/2-3 | 471-C-B139 | 152.4
Steel Assembly | RIGID_FRAME | 10.8 | +17.863 | +17.943 | B-C/2-3 | 471-C-B152 | 80
Steel Assembly | RIGID_FRAME | 34.2 | +17.850 | +18.050 | B-C/2-3 | 471-C-B131 | 358.705
Steel Assembly | RIGID_FRAME | 11.9 | +17.863 | +17.943 | B-C/2-3 | 471-C-B151 | 80
Steel Assembly | RIGID_FRAME | 34.6 | +17.696 | +18.050 | C-D/2-3 | 471-C-B102 | 472.715
2 x Steel Assembly | RIGID_FRAME | 27.1 | +17.698 | +17.850 | C-D/3-4 | 471-C-B137 | 152.4
Steel Assembly | RIGID_FRAME | 170.3 | +17.850 | +18.050 | C-D/3-4 | 471-C-B68 | 408.488
Steel Assembly | RIGID_FRAME | 436.6 | +20.761 | +21.797 | D/2-3 | 471-C-B28 | 314.99
3 x Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | D/2-3 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | D/2 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 427.2 | +20.761 | +21.797 | E/2-3 | 471-C-B60 | 265.75
2 x Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | E/2-3 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | E/2-3 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | D/2-3 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | D/3 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 74.5 | +17.850 | +18.050 | D-E/2-3 | 471-C-B16 | 226.342
Steel Assembly | RIGID_FRAME | 70 | +17.850 | +18.050 | D-E/2-3 | 471-C-B121 | 271.642
Steel Assembly | RIGID_FRAME | 30.2 | +17.698 | +17.850 | D-E/2-3 | 471-C-B143 | 152.4
3 x Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | C/2-3 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 92.8 | +17.850 | +18.050 | B-C/2-3 | 471-C-B1 | 159.994
Steel Assembly | RIGID_FRAME | 37 | +15.192 | +15.344 | D-E/2-3 | 471-C-B138 | 152.4
Steel Assembly | RIGID_FRAME | 75.9 | +15.346 | +15.700 | D-E/2-3 | 471-C-B125 | 288.136
Steel Assembly | RIGID_FRAME | 34.9 | +17.850 | +18.050 | B-C/2 | 471-C-B122 | 316.875
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | B-C/2 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | B-C/2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 34.7 | +21.260 | +21.460 | B-C/2 | 471-C-B123 | 319.726
Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | B-C/2 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 10.8 | +17.863 | +17.943 | B-C/2-3 | 471-C-B150 | 80
Steel Assembly | RIGID_FRAME | 36.2 | +17.750 | +18.050 | B-C/2-3 | 471-C-B118 | 251.849
Steel Assembly | RIGID_FRAME | 34.9 | +17.850 | +18.050 | B-C/2-3 | 471-C-B18 | 256.549
Steel Assembly | RIGID_FRAME | 32.6 | +17.850 | +18.050 | B-C/2-3 | 471-C-B116 | 256.83
Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.590 | B-C/2-3 | 471-C-B201 | 70
Steel Assembly | RIGID_FRAME | 11.4 | +21.273 | +21.353 | B-C/2-3 | 471-C-B186 | 80
Steel Assembly | RIGID_FRAME | 36.9 | +21.260 | +21.460 | B-C/2-3 | 471-C-B20 | 360.317
Steel Assembly | RIGID_FRAME | 10.8 | +21.273 | +21.353 | B-C/2-3 | 471-C-B150 | 80
Steel Assembly | RIGID_FRAME | 36.2 | +21.160 | +21.460 | B-C/2-3 | 471-C-B97 | 251.849
Steel Assembly | RIGID_FRAME | 34.9 | +21.260 | +21.460 | B-C/2-3 | 471-C-B19 | 256.549
Steel Assembly | RIGID_FRAME | 11.1 | +21.273 | +21.353 | B-C/2-3 | 471-C-B159 | 80
Steel Assembly | RIGID_FRAME | 32.7 | +21.260 | +21.460 | B-C/2-3 | 471-C-B117 | 253.691
Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.590 | B-C/2-3 | 471-C-B202 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | C/2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 36.6 | +20.337 | +21.258 | B-C/2 | 471-C-B134 | 160
Steel Assembly | RIGID_FRAME | 8.2 | +21.285 | +22.565 | B-C/2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.180 | B-C/2-3 | 471-C-B201 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | C/2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | C/2-3 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | C/3 | 471-C-B203 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | C-D/3-4 | 471-C-B204 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | D/3-4 | 471-C-B203 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | C/3-4 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 124.6 | +17.694 | +18.050 | C/3-4 | 471-C-B55 | 340.75
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | C/3 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 123.2 | +17.694 | +18.050 | D/3-4 | 471-C-B54 | 265.75
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | D/3 | 471-C-B203 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | E/2-3 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 430.5 | +17.364 | +18.394 | E/2-3 | 471-C-B59 | 265.75
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | E/2-3 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | D/2-3 | 471-C-B204 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | D/2-3 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | D/2 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | D/3 | 471-C-B204 | 70
4 x Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | C-D/2 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 112.3 | +17.850 | +18.050 | C-D/1-2 | 471-C-B69 | 319.01
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | C-D/2 | 471-C-B204 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | C-D/1-2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | C-D/1 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 245.2 | +17.694 | +18.050 | D/1-2 | 471-C-B33 | 265.75
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | D/1-2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 269.1 | +17.350 | +18.050 | E/1-2 | 471-C-B34 | 265.75
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | E/1-2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | E/1 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | D/2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | D-E/1 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 67.4 | +17.850 | +18.050 | D-E/1-2 | 471-C-B127 | 215
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | E/1-2 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | D-E/1-2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | E/1 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | C-D/1 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +17.875 | +19.155 | C/2 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 233.3 | +15.448 | +15.700 | C-D/2-3 | 471-C-B205 | 395.952
3 x Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | C-D/2-3 | 471-C-B203 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | D/2-3 | 471-C-B203 | 70
4 x Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | C/2-3 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | C/3-4 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | C/4 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | C/3 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | C/3 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 297.4 | +14.989 | +16.045 | C/1-2 | 471-C-B53 | 315
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | C/1-2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | C/1 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | C/2 | 471-C-B204 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | C-D/2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | E/2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | D-E/2 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | C/2 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | D/2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 15.6 | +24.138 | +24.208 | D-E/2-3 | 471-C-B200 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +24.143 | +25.423 | E/2 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +24.143 | +25.423 | D/2 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 15.8 | +21.273 | +21.353 | C-D/2-3 | 471-C-B181 | 80
Steel Assembly | RIGID_FRAME | 29.9 | +21.260 | +21.460 | C-D/2-3 | 471-C-B106 | 515.435
Steel Assembly | RIGID_FRAME | 17.3 | +21.273 | +21.353 | C-D/2-3 | 471-C-B179 | 80
Steel Assembly | RIGID_FRAME | 15.8 | +21.280 | +21.350 | D-E/2-3 | 471-C-B199 | 70
Steel Assembly | RIGID_FRAME | 12.8 | +19.575 | +19.645 | D-E/2-3 | 471-C-B196 | 70
Steel Assembly | RIGID_FRAME | 7.8 | +19.755 | +20.860 | D/2-3 | 471-C-B195 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +19.755 | +20.860 | E/2-3 | 471-C-B194 | 70.0002
Steel Assembly | RIGID_FRAME | 8.2 | +19.580 | +20.860 | D-E/2-3 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +19.580 | +20.860 | D-E/2-3 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 36.9 | +18.050 | +19.502 | D/2-3 | 471-C-B136 | 160
Steel Assembly | RIGID_FRAME | 58.8 | +19.555 | +19.755 | D-E/2-3 | 471-C-B15 | 230.627
Steel Assembly | RIGID_FRAME | 221.7 | +19.504 | +19.755 | E/2-3 | 471-C-B207 | 146.1
Steel Assembly | RIGID_FRAME | 97.8 | +19.504 | +19.755 | D/2-3 | 471-C-B209 | 146.1
Steel Assembly | RIGID_FRAME | 15.8 | +17.870 | +17.940 | D-E/2-3 | 471-C-B199 | 70
Steel Assembly | RIGID_FRAME | 429.3 | +14.992 | +16.030 | E/2-3 | 471-C-B58 | 315
2 x Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | E/2-3 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +15.525 | +16.805 | E/2 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 73.8 | +15.500 | +15.700 | D-E/2-3 | 471-C-B14 | 232.362
Steel Assembly | RIGID_FRAME | 16.5 | +15.520 | +15.590 | D-E/2-3 | 471-C-B197 | 70
Steel Assembly | RIGID_FRAME | 15.5 | +15.520 | +15.590 | D-E/2-3 | 471-C-B198 | 70
Steel Assembly | RIGID_FRAME | 7.8 | +13.145 | +14.250 | D/2-3 | 471-C-B195 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +13.145 | +14.250 | E/2-3 | 471-C-B194 | 70.0002
Steel Assembly | RIGID_FRAME | 57.5 | +12.945 | +13.145 | D-E/2-3 | 471-C-B124 | 280.928
Steel Assembly | RIGID_FRAME | 8.2 | +12.970 | +14.250 | D-E/2-3 | 471-C-B204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +12.970 | +14.250 | D-E/2-3 | 471-C-B203 | 70
Steel Assembly | RIGID_FRAME | 12.8 | +12.965 | +13.035 | D-E/2-3 | 471-C-B196 | 70
Steel Assembly | RIGID_FRAME | 58.8 | +12.945 | +13.145 | D-E/2-3 | 471-C-B13 | 230.627
Steel Assembly | RIGID_FRAME | 221.7 | +12.893 | +13.145 | E/2-3 | 471-C-B208 | 146.1
Steel Assembly | RIGID_FRAME | 221.7 | +12.893 | +13.145 | D/2-3 | 471-C-B206 | 146.1
Steel Assembly | RIGID_FRAME | 11.9 | +21.374 | +21.460 | B-C/2 | 471-C-B146 | 160
Steel Assembly | RIGID_FRAME | 36.6 | +16.927 | +17.848 | B-C/2 | 471-C-B134 | 160
4 x Steel Assembly | RIGID_FRAME | 40.1 | +21.260 | +21.460 | C-D/2-3 | 471-C-B232 | 135.765
Steel Assembly | RIGID_FRAME | 175.2 | +21.260 | +21.460 | C-D/2-3 | 471-C-B72 | 447.925
Steel Assembly | RIGID_FRAME | 131.3 | +21.260 | +21.460 | C-D/2-3 | 471-C-B79 | 253.403
Steel Assembly | RIGID_FRAME | 88.4 | +21.260 | +21.460 | C-D/2-3 | 471-C-B81 | 292.047
4 x Steel Assembly | RIGID_FRAME | 40.1 | +17.850 | +18.050 | C-D/2-3 | 471-C-B232 | 135.765
Steel Assembly | RIGID_FRAME | 171.2 | +17.850 | +18.050 | C-D/2-3 | 471-C-B70 | 447.925
Steel Assembly | RIGID_FRAME | 129.1 | +17.850 | +18.050 | C-D/2-3 | 471-C-B77 | 160
Steel Assembly | RIGID_FRAME | 133.8 | +17.850 | +18.050 | C-D/2-3 | 471-C-B78 | 336.58
Steel Assembly | RIGID_FRAME | 88.4 | +17.850 | +18.050 | C-D/2-3 | 471-C-B81 | 292.047
Steel Assembly | RIGID_FRAME | 2350.1 | +12.002 | +25.803 | D/3 | 471-C-B236 | 310.6
Steel Assembly | RIGID_FRAME | 246.9 | +15.256 | +15.449 | B-C/3-4 | 471-D-C415 | 210
Steel Assembly | RIGID_FRAME | 7.7 | +69.602 | +70.720 | E/2-3 | 471-G-F304 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +69.602 | +70.720 | D-E/2-3 | 471-G-F303 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +67.402 | +68.520 | D-E/2-3 | 471-G-F303 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +67.402 | +68.520 | D/2-3 | 471-G-F304 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +64.902 | +66.020 | D-E/2-3 | 471-G-F303 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +64.902 | +66.020 | E/2-3 | 471-G-F304 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +62.143 | +63.259 | D-E/2-3 | 471-G-F301 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +62.143 | +63.259 | D/2-3 | 471-G-F302 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +59.428 | +60.544 | D-E/2-3 | 471-G-F301 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +59.428 | +60.544 | E/2-3 | 471-G-F302 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +56.713 | +57.829 | D-E/2-3 | 471-G-F301 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +56.713 | +57.829 | D/2-3 | 471-G-F302 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +54.222 | +55.336 | D-E/2-3 | 471-G-F299 | 141.699
Steel Assembly | RIGID_FRAME | 7.7 | +54.222 | +55.336 | E/2-3 | 471-G-F300 | 141.699
Steel Assembly | RIGID_FRAME | 7.7 | +52.146 | +53.260 | D-E/2-3 | 471-G-F299 | 141.711
Steel Assembly | RIGID_FRAME | 7.7 | +52.146 | +53.260 | D/2-3 | 471-G-F300 | 141.711
Steel Assembly | RIGID_FRAME | 7.7 | +49.978 | +51.092 | D-E/2-3 | 471-G-F299 | 141.713
Steel Assembly | RIGID_FRAME | 7.7 | +49.978 | +51.092 | E/2-3 | 471-G-F300 | 141.713
Steel Assembly | RIGID_FRAME | 7.7 | +45.843 | +46.956 | D-E/2-3 | 471-F-E198 | 141.991
Steel Assembly | RIGID_FRAME | 7.7 | +45.843 | +46.956 | E/2-3 | 471-F-E199 | 141.991
Steel Assembly | RIGID_FRAME | 7.7 | +43.242 | +44.359 | D-E/2-3 | 471-F-E196 | 139.526
Steel Assembly | RIGID_FRAME | 7.7 | +43.242 | +44.359 | D/2-3 | 471-F-E197 | 139.526
Steel Assembly | RIGID_FRAME | 7.7 | +40.474 | +41.591 | D-E/2-3 | 471-F-E196 | 139.543
Steel Assembly | RIGID_FRAME | 7.7 | +40.474 | +41.591 | E/2-3 | 471-F-E197 | 139.543
Steel Assembly | RIGID_FRAME | 7.7 | +37.705 | +38.822 | D-E/2-3 | 471-F-E196 | 139.543
Steel Assembly | RIGID_FRAME | 7.7 | +37.705 | +38.822 | D/2-3 | 471-F-E197 | 139.543
Steel Assembly | RIGID_FRAME | 7.7 | +35.185 | +36.298 | D-E/2-3 | 471-E-D147 | 141.579
Steel Assembly | RIGID_FRAME | 7.7 | +35.185 | +36.298 | E/2-3 | 471-E-D148 | 141.579
Steel Assembly | RIGID_FRAME | 7.7 | +34.299 | +35.412 | D-E/2-3 | 471-E-D147 | 141.579
Steel Assembly | RIGID_FRAME | 7.7 | +34.299 | +35.412 | E/2-3 | 471-E-D148 | 141.579
Steel Assembly | RIGID_FRAME | 7.7 | +32.914 | +34.027 | D-E/2-3 | 471-E-D147 | 141.579
Steel Assembly | RIGID_FRAME | 7.7 | +32.914 | +34.027 | D/2-3 | 471-E-D148 | 141.579
Steel Assembly | RIGID_FRAME | 7.7 | +27.797 | +28.912 | D-E/2-3 | 471-E-D147 | 141.312
Steel Assembly | RIGID_FRAME | 7.7 | +27.797 | +28.912 | D/2-3 | 471-E-D148 | 141.312
Steel Assembly | RIGID_FRAME | 7.7 | +25.417 | +26.531 | D-E/2-3 | 471-E-D147 | 141.245
Steel Assembly | RIGID_FRAME | 7.7 | +25.417 | +26.531 | E/2-3 | 471-E-D148 | 141.245
Steel Assembly | RIGID_FRAME | 7.7 | +22.939 | +24.053 | D-E/2-3 | 471-C-B192 | 141.27
Steel Assembly | RIGID_FRAME | 7.7 | +22.939 | +24.053 | D/2-3 | 471-C-B193 | 141.27
Steel Assembly | RIGID_FRAME | 7.7 | +16.926 | +18.042 | D-E/2-3 | 471-C-B191 | 139.995
Steel Assembly | RIGID_FRAME | 7.7 | +16.926 | +18.042 | E/2-3 | 471-C-B190 | 139.995
Steel Assembly | RIGID_FRAME | 7.7 | +14.474 | +15.591 | D-E/2-3 | 471-C-B191 | 139.826
Steel Assembly | RIGID_FRAME | 7.7 | +14.474 | +15.591 | D/2-3 | 471-C-B190 | 139.826
Steel Assembly | RIGID_FRAME | 7.7 | +11.919 | +13.035 | E/2-3 | 471-C-B190 | 139.826
Steel Assembly | RIGID_FRAME | 7.7 | +11.919 | +13.035 | D-E/2-3 | 471-C-B191 | 139.826
Steel Assembly | RIGID_FRAME | 7.7 | +10.901 | +12.017 | E/2-3 | 471-C-B190 | 139.826
Steel Assembly | RIGID_FRAME | 7.7 | +10.901 | +12.017 | D-E/2-3 | 471-C-B191 | 139.826
Steel Assembly | RIGID_FRAME | 7.7 | +13.456 | +14.572 | D-E/2-3 | 471-C-B191 | 139.826
Steel Assembly | RIGID_FRAME | 7.7 | +13.456 | +14.572 | D/2-3 | 471-C-B190 | 139.826
Steel Assembly | RIGID_FRAME | 7.7 | +16.010 | +17.126 | D-E/2-3 | 471-C-B191 | 139.995
Steel Assembly | RIGID_FRAME | 7.7 | +16.010 | +17.126 | E/2-3 | 471-C-B190 | 139.995
Steel Assembly | RIGID_FRAME | 7.7 | +18.350 | +19.464 | D-E/2-3 | 471-C-B192 | 141.532
Steel Assembly | RIGID_FRAME | 7.7 | +18.350 | +19.464 | D/2-3 | 471-C-B193 | 141.532
Steel Assembly | RIGID_FRAME | 7.7 | +21.762 | +22.876 | D-E/2-3 | 471-C-B192 | 141.27
Steel Assembly | RIGID_FRAME | 7.7 | +21.762 | +22.876 | D/2-3 | 471-C-B193 | 141.27
Steel Assembly | RIGID_FRAME | 7.7 | +24.620 | +25.734 | D-E/2-3 | 471-E-D147 | 141.245
Steel Assembly | RIGID_FRAME | 7.7 | +24.620 | +25.734 | E/2-3 | 471-E-D148 | 141.245
Steel Assembly | RIGID_FRAME | 7.7 | +26.716 | +27.830 | D-E/2-3 | 471-E-D147 | 141.312
Steel Assembly | RIGID_FRAME | 7.7 | +26.716 | +27.830 | D/2-3 | 471-E-D148 | 141.312
Steel Assembly | RIGID_FRAME | 7.7 | +32.028 | +33.141 | D-E/2-3 | 471-E-D147 | 141.579
Steel Assembly | RIGID_FRAME | 7.7 | +32.028 | +33.141 | D/2-3 | 471-E-D148 | 141.579
Steel Assembly | RIGID_FRAME | 7.7 | +36.582 | +37.699 | D-E/2-3 | 471-F-E196 | 139.543
Steel Assembly | RIGID_FRAME | 7.7 | +36.582 | +37.699 | D/2-3 | 471-F-E197 | 139.543
Steel Assembly | RIGID_FRAME | 7.7 | +39.351 | +40.468 | D-E/2-3 | 471-F-E196 | 139.543
Steel Assembly | RIGID_FRAME | 7.7 | +39.351 | +40.468 | E/2-3 | 471-F-E197 | 139.543
Steel Assembly | RIGID_FRAME | 7.7 | +42.118 | +43.235 | D-E/2-3 | 471-F-E196 | 139.526
Steel Assembly | RIGID_FRAME | 7.7 | +42.118 | +43.235 | D/2-3 | 471-F-E197 | 139.526
Steel Assembly | RIGID_FRAME | 7.7 | +44.872 | +45.985 | D-E/2-3 | 471-F-E198 | 141.991
Steel Assembly | RIGID_FRAME | 7.7 | +44.872 | +45.985 | E/2-3 | 471-F-E199 | 141.991
Steel Assembly | RIGID_FRAME | 7.7 | +47.310 | +48.423 | D-E/2-3 | 471-F-E198 | 142.013
Steel Assembly | RIGID_FRAME | 7.7 | +47.310 | +48.423 | D/2-3 | 471-F-E199 | 142.013
Steel Assembly | RIGID_FRAME | 7.7 | +48.999 | +50.112 | D-E/2-3 | 471-G-F299 | 141.713
Steel Assembly | RIGID_FRAME | 7.7 | +48.999 | +50.112 | E/2-3 | 471-G-F300 | 141.713
Steel Assembly | RIGID_FRAME | 7.7 | +51.452 | +52.565 | D-E/2-3 | 471-G-F299 | 141.711
Steel Assembly | RIGID_FRAME | 7.7 | +51.452 | +52.565 | D/2-3 | 471-G-F300 | 141.711
Steel Assembly | RIGID_FRAME | 7.7 | +53.339 | +54.452 | D-E/2-3 | 471-G-F299 | 141.699
Steel Assembly | RIGID_FRAME | 7.7 | +53.339 | +54.452 | E/2-3 | 471-G-F300 | 141.699
Steel Assembly | RIGID_FRAME | 7.7 | +55.613 | +56.729 | D-E/2-3 | 471-G-F301 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +55.613 | +56.729 | D/2-3 | 471-G-F302 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +58.327 | +59.442 | D-E/2-3 | 471-G-F301 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +58.327 | +59.442 | E/2-3 | 471-G-F302 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +61.043 | +62.159 | D-E/2-3 | 471-G-F301 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +61.043 | +62.159 | D/2-3 | 471-G-F302 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +63.766 | +64.884 | D-E/2-3 | 471-G-F303 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +63.766 | +64.884 | E/2-3 | 471-G-F304 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +66.566 | +67.684 | D-E/2-3 | 471-G-F303 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +66.566 | +67.684 | D/2-3 | 471-G-F304 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +68.766 | +69.884 | E/2-3 | 471-G-F304 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +68.766 | +69.884 | D-E/2-3 | 471-G-F303 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +30.453 | +31.567 | D-E/2-3 | 471-E-D147 | 141.605
Steel Assembly | RIGID_FRAME | 7.7 | +30.453 | +31.567 | E/2-3 | 471-E-D148 | 141.605
Steel Assembly | RIGID_FRAME | 7.7 | +29.380 | +30.493 | D-E/2-3 | 471-E-D147 | 141.605
Steel Assembly | RIGID_FRAME | 7.7 | +29.380 | +30.493 | E/2-3 | 471-E-D148 | 141.605
Steel Assembly | RIGID_FRAME | 7.7 | +20.055 | +21.169 | D-E/2-3 | 471-C-B192 | 141.532
Steel Assembly | RIGID_FRAME | 7.7 | +20.055 | +21.169 | E/2-3 | 471-C-B193 | 141.532
Steel Assembly | RIGID_FRAME | 7.7 | +68.238 | +69.356 | D-E/2-3 | 471-G-F303 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +66.038 | +67.156 | D-E/2-3 | 471-G-F303 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +63.245 | +64.360 | D-E/2-3 | 471-G-F301 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +60.530 | +61.645 | D-E/2-3 | 471-G-F301 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +57.815 | +58.930 | D-E/2-3 | 471-G-F301 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +55.106 | +56.219 | D-E/2-3 | 471-G-F299 | 141.699
Steel Assembly | RIGID_FRAME | 7.7 | +52.841 | +53.954 | D-E/2-3 | 471-G-F299 | 141.711
Steel Assembly | RIGID_FRAME | 7.7 | +50.954 | +52.067 | D-E/2-3 | 471-G-F299 | 141.713
Steel Assembly | RIGID_FRAME | 7.7 | +48.502 | +49.615 | D-E/2-3 | 471-F-E198 | 142.013
Steel Assembly | RIGID_FRAME | 7.7 | +46.815 | +47.928 | D-E/2-3 | 471-F-E198 | 141.991
Steel Assembly | RIGID_FRAME | 7.7 | +44.366 | +45.483 | D-E/2-3 | 471-F-E196 | 139.526
Steel Assembly | RIGID_FRAME | 7.7 | +41.597 | +42.714 | D-E/2-3 | 471-F-E196 | 139.543
Steel Assembly | RIGID_FRAME | 7.7 | +38.829 | +39.946 | D-E/2-3 | 471-F-E196 | 139.543
Steel Assembly | RIGID_FRAME | 7.7 | +36.070 | +37.184 | D-E/2-3 | 471-E-D147 | 141.579
Steel Assembly | RIGID_FRAME | 7.7 | +33.799 | +34.913 | D-E/2-3 | 471-E-D147 | 141.579
Steel Assembly | RIGID_FRAME | 7.7 | +31.528 | +32.642 | D-E/2-3 | 471-E-D147 | 141.605
Steel Assembly | RIGID_FRAME | 7.7 | +28.879 | +29.993 | D-E/2-3 | 471-E-D147 | 141.312
Steel Assembly | RIGID_FRAME | 7.7 | +26.214 | +27.328 | D-E/2-3 | 471-E-D147 | 141.245
Steel Assembly | RIGID_FRAME | 7.7 | +24.117 | +25.231 | D-E/2-3 | 471-C-B192 | 141.27
Steel Assembly | RIGID_FRAME | 7.7 | +21.260 | +22.374 | D-E/2-3 | 471-C-B192 | 141.532
Steel Assembly | RIGID_FRAME | 7.7 | +19.555 | +20.669 | D-E/2-3 | 471-C-B192 | 141.532
Steel Assembly | RIGID_FRAME | 7.7 | +17.843 | +18.959 | D-E/2-3 | 471-C-B191 | 139.995
Steel Assembly | RIGID_FRAME | 7.7 | +15.492 | +16.608 | D-E/2-3 | 471-C-B191 | 139.826
Steel Assembly | RIGID_FRAME | 7.7 | +15.492 | +16.608 | D/2-3 | 471-C-B190 | 139.826
Steel Assembly | RIGID_FRAME | 7.7 | +17.843 | +18.959 | E/2-3 | 471-C-B190 | 139.995
Steel Assembly | RIGID_FRAME | 7.7 | +19.555 | +20.669 | D/2-3 | 471-C-B193 | 141.532
Steel Assembly | RIGID_FRAME | 7.7 | +21.260 | +22.374 | E/2-3 | 471-C-B193 | 141.532
Steel Assembly | RIGID_FRAME | 7.7 | +24.117 | +25.231 | D/2-3 | 471-C-B193 | 141.27
Steel Assembly | RIGID_FRAME | 7.7 | +26.214 | +27.328 | E/2-3 | 471-E-D148 | 141.245
Steel Assembly | RIGID_FRAME | 7.7 | +28.879 | +29.993 | D/2-3 | 471-E-D148 | 141.312
Steel Assembly | RIGID_FRAME | 7.7 | +31.528 | +32.642 | E/2-3 | 471-E-D148 | 141.605
Steel Assembly | RIGID_FRAME | 7.7 | +33.799 | +34.913 | D/2-3 | 471-E-D148 | 141.579
Steel Assembly | RIGID_FRAME | 7.7 | +36.070 | +37.184 | E/2-3 | 471-E-D148 | 141.579
Steel Assembly | RIGID_FRAME | 7.7 | +38.829 | +39.946 | D/2-3 | 471-F-E197 | 139.543
Steel Assembly | RIGID_FRAME | 7.7 | +41.597 | +42.714 | E/2-3 | 471-F-E197 | 139.543
Steel Assembly | RIGID_FRAME | 7.7 | +44.366 | +45.483 | D/2-3 | 471-F-E197 | 139.526
Steel Assembly | RIGID_FRAME | 7.7 | +46.815 | +47.928 | E/2-3 | 471-F-E199 | 141.991
Steel Assembly | RIGID_FRAME | 7.7 | +48.502 | +49.615 | D/2-3 | 471-F-E199 | 142.013
Steel Assembly | RIGID_FRAME | 7.7 | +50.954 | +52.067 | E/2-3 | 471-G-F300 | 141.713
Steel Assembly | RIGID_FRAME | 7.7 | +52.841 | +53.954 | D/2-3 | 471-G-F300 | 141.711
Steel Assembly | RIGID_FRAME | 7.7 | +55.106 | +56.219 | E/2-3 | 471-G-F300 | 141.699
Steel Assembly | RIGID_FRAME | 7.7 | +57.815 | +58.930 | D/2-3 | 471-G-F302 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +60.530 | +61.645 | E/2-3 | 471-G-F302 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +63.245 | +64.360 | D/2-3 | 471-G-F302 | 140.453
Steel Assembly | RIGID_FRAME | 7.7 | +68.238 | +69.356 | D/2-3 | 471-G-F304 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +66.038 | +67.156 | E/2-3 | 471-G-F304 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +70.438 | +71.556 | E/2-3 | 471-G-F304 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +70.438 | +71.556 | D-E/2-3 | 471-G-F303 | 138.995
Steel Assembly | RIGID_FRAME | 2338.2 | +12.002 | +25.803 | D/2 | 471-C-B242 | 310.6
Steel Assembly | RIGID_FRAME | 2374 | +12.002 | +25.803 | E/3 | 471-C-B244 | 310.6
Steel Assembly | RIGID_FRAME | 2350.1 | +12.002 | +25.803 | E/2 | 471-C-B241 | 310.6
Steel Assembly | RIGID_FRAME | 410 | +2.394 | +3.103 | C-D/1 | 471-B-A37 | 190
Steel Assembly | RIGID_FRAME | 431.5 | +2.060 | +3.084 | C-D/2 | 471-B-A36 | 190
Steel Assembly | RIGID_FRAME | 248.4 | +5.745 | +10.189 | E/3-4 | 471-B-A219 | 219.1
Steel Assembly | RIGID_FRAME | 260.8 | +5.725 | +10.209 | E/1-2 | 471-B-A240 | 219.1
Steel Assembly | RIGID_FRAME | 235 | +5.725 | +10.154 | E/2-3 | 471-B-A239 | 219.1
Steel Assembly | RIGID_FRAME | 235.2 | +5.725 | +10.159 | E/2-3 | 471-B-A231 | 219.1
Steel Assembly | RIGID_FRAME | 283.1 | +0.108 | +5.289 | E/1-2 | 471-B-A241 | 219.1
Steel Assembly | RIGID_FRAME | 271.1 | +0.133 | +5.264 | E/3-4 | 471-B-A242 | 219.1
Steel Assembly | RIGID_FRAME | 2262.6 | +0.000 | +12.501 | C/4 | 471-B-A216 | 640.846
Steel Assembly | RIGID_FRAME | 2262.8 | +0.000 | +12.501 | C/1 | 471-B-A207 | 560
2 x Steel Assembly | RIGID_FRAME | 231 | +5.725 | +10.134 | C-D/3 | 471-B-A221 | 219.1
Steel Assembly | RIGID_FRAME | 474.3 | +9.820 | +11.002 | C-D/3 | 471-B-A21 | 636.498
Steel Assembly | RIGID_FRAME | 478.8 | +5.010 | +6.039 | C-D/3 | 471-B-A32 | 637.577
Steel Assembly | RIGID_FRAME | 2260.5 | +0.000 | +12.501 | C/3 | 471-B-A214 | 736.055
Steel Assembly | RIGID_FRAME | 2290.6 | +0.000 | +12.501 | D/1 | 471-B-A208 | 560
Steel Assembly | RIGID_FRAME | 2256.3 | +0.000 | +12.501 | D/3 | 471-B-A212 | 639.777
Steel Assembly | RIGID_FRAME | 2246.2 | +0.000 | +12.501 | E/3 | 471-B-A215 | 639.777
Steel Assembly | RIGID_FRAME | 2348.8 | +0.000 | +12.501 | E/1 | 471-B-A209 | 560
Steel Assembly | RIGID_FRAME | 73.8 | +10.390 | +10.590 | D-E/2-3 | 471-B-A4 | 232.362
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | D/2-3 | 471-B-A178 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | E/2-3 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 7.8 | +8.145 | +9.250 | D/2-3 | 471-B-A176 | 70.0002
Steel Assembly | RIGID_FRAME | 7.8 | +8.145 | +9.250 | E/2-3 | 471-B-A175 | 70.0002
Steel Assembly | RIGID_FRAME | 57.5 | +7.945 | +8.145 | D-E/2-3 | 471-B-A69 | 280.927
Steel Assembly | RIGID_FRAME | 8.2 | +7.970 | +9.250 | D-E/2-3 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +7.970 | +9.250 | D-E/2-3 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 12.8 | +7.965 | +8.035 | D-E/2-3 | 471-B-A170 | 70
Steel Assembly | RIGID_FRAME | 58.8 | +7.945 | +8.145 | D-E/2-3 | 471-B-A1 | 230.627
Steel Assembly | RIGID_FRAME | 81.5 | +5.344 | +5.700 | C-D/3-4 | 471-B-A47 | 200
Steel Assembly | RIGID_FRAME | 262.9 | +5.328 | +5.700 | C-D/3-4 | 471-B-A42 | 500.62
Steel Assembly | RIGID_FRAME | 262.9 | +5.328 | +5.700 | C-D/3-4 | 471-B-A43 | 500.62
Steel Assembly | RIGID_FRAME | 81.5 | +5.344 | +5.700 | C-D/3-4 | 471-B-A41 | 200
Steel Assembly | RIGID_FRAME | 122.4 | +2.097 | +3.062 | D-E/3 | 471-B-A184 | 305
Steel Assembly | RIGID_FRAME | 8.2 | +2.525 | +3.805 | D-E/3 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 344.9 | +9.880 | +11.026 | C/1-2 | 471-B-A29 | 315.001
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C/1-2 | 471-B-A178 | 70
2 x Steel Assembly | RIGID_FRAME | 167.5 | +10.146 | +10.339 | C-D/3-4 | 471-B-A201 | 210
Steel Assembly | RIGID_FRAME | 447.4 | +9.820 | +10.590 | C-D/4 | 471-B-A17 | 561.722
Steel Assembly | RIGID_FRAME | 223.3 | +2.448 | +2.700 | D/2-3 | 471-B-A180 | 231.1
Steel Assembly | RIGID_FRAME | 8.2 | +2.525 | +3.805 | D/3 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 225.3 | +2.449 | +2.700 | E/2-3 | 471-B-A179 | 396.628
Steel Assembly | RIGID_FRAME | 8.2 | +2.525 | +3.805 | E/3 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 162.5 | +10.146 | +10.339 | D-E/3-4 | 471-B-A205 | 210
Steel Assembly | RIGID_FRAME | 195.3 | +9.882 | +10.941 | D-E/3 | 471-B-A40 | 606.241
Steel Assembly | RIGID_FRAME | 8.2 | +2.525 | +3.805 | D/3 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 182 | +9.748 | +10.590 | D-E/4 | 471-B-A38 | 556.241
Steel Assembly | RIGID_FRAME | 8.2 | +2.525 | +3.805 | E/3 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 7.7 | +10.391 | +11.505 | D-E/2-3 | 471-B-A171 | 141.861
Steel Assembly | RIGID_FRAME | 7.7 | +9.417 | +10.531 | D-E/2-3 | 471-B-A171 | 141.861
Steel Assembly | RIGID_FRAME | 7.7 | +8.444 | +9.557 | D-E/2-3 | 471-B-A171 | 141.861
Steel Assembly | RIGID_FRAME | 7.7 | +8.444 | +9.557 | D/2-3 | 471-B-A172 | 141.861
Steel Assembly | RIGID_FRAME | 7.7 | +9.417 | +10.531 | D/2-3 | 471-B-A172 | 141.861
Steel Assembly | RIGID_FRAME | 7.7 | +10.391 | +11.505 | D/2-3 | 471-B-A172 | 141.861
Steel Assembly | RIGID_FRAME | 7.7 | +12.937 | +14.053 | E/2-3 | 471-C-B190 | 139.826
Steel Assembly | RIGID_FRAME | 7.7 | +12.937 | +14.053 | D-E/2-3 | 471-C-B191 | 139.826
Steel Assembly | RIGID_FRAME | 7.7 | +7.946 | +9.059 | D-E/2-3 | 471-B-A171 | 141.861
Steel Assembly | RIGID_FRAME | 7.7 | +6.972 | +8.085 | D-E/2-3 | 471-B-A171 | 141.861
Steel Assembly | RIGID_FRAME | 7.7 | +5.998 | +7.111 | D-E/2-3 | 471-B-A171 | 141.861
Steel Assembly | RIGID_FRAME | 7.7 | +7.946 | +9.059 | E/2-3 | 471-B-A172 | 141.861
Steel Assembly | RIGID_FRAME | 7.7 | +6.972 | +8.085 | E/2-3 | 471-B-A172 | 141.861
Steel Assembly | RIGID_FRAME | 7.7 | +5.998 | +7.111 | E/2-3 | 471-B-A172 | 141.861
Steel Assembly | RIGID_FRAME | 175.9 | +10.146 | +10.339 | D-E/1-2 | 471-B-A203 | 210
Steel Assembly | RIGID_FRAME | 195.5 | +9.882 | +10.941 | D-E/2 | 471-B-A49 | 528.533
Steel Assembly | RIGID_FRAME | 7.7 | +3.014 | +4.132 | D/2-3 | 471-B-A173 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +4.251 | +5.369 | D/2-3 | 471-B-A173 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +5.488 | +6.606 | D/2-3 | 471-B-A173 | 138.995
Steel Assembly | RIGID_FRAME | 212.4 | +9.753 | +11.084 | D-E/1 | 471-B-A45 | 602.208
Steel Assembly | RIGID_FRAME | 7.7 | +5.488 | +6.606 | D-E/2-3 | 471-B-A174 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +4.251 | +5.369 | D-E/2-3 | 471-B-A174 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +3.014 | +4.132 | D-E/2-3 | 471-B-A174 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +2.488 | +3.606 | D-E/2-3 | 471-B-A174 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +2.488 | +3.606 | E/2-3 | 471-B-A173 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +1.316 | +2.434 | E/2-3 | 471-B-A173 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +1.316 | +2.434 | D-E/2-3 | 471-B-A174 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +0.144 | +1.262 | E/2-3 | 471-B-A173 | 138.995
Steel Assembly | RIGID_FRAME | 7.7 | +0.144 | +1.262 | D-E/2-3 | 471-B-A174 | 138.995
Steel Assembly | RIGID_FRAME | 24.5 | +10.082 | +10.234 | D-E/1-2 | 471-B-A135 | 152.4
Steel Assembly | RIGID_FRAME | 24.5 | +10.082 | +10.234 | D-E/3-4 | 471-B-A135 | 152.4
Steel Assembly | RIGID_FRAME | 27.2 | +10.082 | +10.234 | D-E/3-4 | 471-B-A128 | 152.4
Steel Assembly | RIGID_FRAME | 77.4 | +10.236 | +10.590 | D-E/3-4 | 471-B-A85 | 160
Steel Assembly | RIGID_FRAME | 77.4 | +10.236 | +10.590 | D-E/3-4 | 471-B-A86 | 160
Steel Assembly | RIGID_FRAME | 70.9 | +10.236 | +10.590 | D-E/1-2 | 471-B-A81 | 160
2 x Steel Assembly | RIGID_FRAME | 35.8 | +10.082 | +10.234 | D-E/3-4 | 471-B-A133 | 152.4
Steel Assembly | RIGID_FRAME | 33.5 | +10.082 | +10.234 | C-D/3-4 | 471-B-A134 | 152.4
Steel Assembly | RIGID_FRAME | 100.1 | +10.236 | +10.590 | C-D/3-4 | 471-B-A79 | 160
3 x Steel Assembly | RIGID_FRAME | 33.5 | +10.082 | +10.234 | C-D/2-3 | 471-B-A134 | 152.4
Steel Assembly | RIGID_FRAME | 144.3 | +10.236 | +10.590 | C-D/2-3 | 471-B-A87 | 240.975
2 x Steel Assembly | RIGID_FRAME | 33.5 | +10.082 | +10.234 | C-D/1-2 | 471-B-A134 | 152.4
Steel Assembly | RIGID_FRAME | 121 | +10.236 | +10.590 | C-D/1-2 | 471-B-A253 | 160
Steel Assembly | RIGID_FRAME | 17.6 | +10.082 | +10.234 | C-D/1 | 471-B-A132 | 152.4
Steel Assembly | RIGID_FRAME | 109.1 | +10.236 | +10.590 | C-D/1-2 | 471-B-A63 | 160
Steel Assembly | RIGID_FRAME | 27.2 | +10.082 | +10.234 | C-D/1-2 | 471-B-A128 | 152.4
Steel Assembly | RIGID_FRAME | 14.6 | +10.403 | +10.483 | C-D/2-3 | 471-B-A156 | 80
Steel Assembly | RIGID_FRAME | 177.1 | +10.390 | +10.590 | C-D/2-3 | 471-B-A89 | 452.677
Steel Assembly | RIGID_FRAME | 29.1 | +10.390 | +10.590 | C-D/2-3 | 471-B-A12 | 257.401
Steel Assembly | RIGID_FRAME | 25.8 | +10.390 | +10.590 | C-D/2-3 | 471-B-A11 | 160
