Properties of the parts of a building model (IFC2X3), part 20 of 22

# IfcElementAssembly (4115)
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
2 x Steel Assembly | RIGID_FRAME | 32.4 | +10.390 | +10.590 | C-D/1-2 | 471-B-A13 | 160
2 x Steel Assembly | RIGID_FRAME | 49.3 | +10.387 | +10.590 | D-E/3-4 | 471-B-A198 | 203.2
Steel Assembly | RIGID_FRAME | 44.5 | +10.387 | +10.590 | C-D/3-4 | 471-B-A188 | 203.2
Steel Assembly | RIGID_FRAME | 44.5 | +10.387 | +10.590 | C-D/4 | 471-B-A188 | 203.2
Steel Assembly | RIGID_FRAME | 11.9 | +10.403 | +10.483 | C-D/2-3 | 471-B-A157 | 80
Steel Assembly | RIGID_FRAME | 28.4 | +10.390 | +10.590 | C-D/2-3 | 471-B-A119 | 448.649
Steel Assembly | RIGID_FRAME | 49.2 | +10.387 | +10.590 | C-D/2-3 | 471-B-A194 | 399.509
Steel Assembly | RIGID_FRAME | 8.7 | +10.403 | +10.483 | C-D/2-3 | 471-B-A163 | 80
Steel Assembly | RIGID_FRAME | 28.6 | +10.390 | +10.590 | C-D/2-3 | 471-B-A120 | 397.929
Steel Assembly | RIGID_FRAME | 11.9 | +10.403 | +10.483 | C-D/2-3 | 471-B-A158 | 80
Steel Assembly | RIGID_FRAME | 49.4 | +10.387 | +10.590 | C-D/2-3 | 471-B-A195 | 390.871
Steel Assembly | RIGID_FRAME | 8 | +10.403 | +10.483 | C-D/2-3 | 471-B-A164 | 80
Steel Assembly | RIGID_FRAME | 129.7 | +10.390 | +10.590 | C-D/2-3 | 471-B-A88 | 385.782
Steel Assembly | RIGID_FRAME | 44.7 | +10.387 | +10.590 | C-D/1 | 471-B-A193 | 203.2
2 x Steel Assembly | RIGID_FRAME | 55.2 | +10.387 | +10.590 | C-D/1-2 | 471-B-A191 | 203.2
2 x Steel Assembly | RIGID_FRAME | 44.5 | +10.387 | +10.590 | C-D/1-2 | 471-B-A188 | 203.2
Steel Assembly | RIGID_FRAME | 44.7 | +10.387 | +10.590 | C-D/1-2 | 471-B-A193 | 203.2
Steel Assembly | RIGID_FRAME | 27.1 | +10.387 | +10.590 | D-E/1-2 | 471-B-A197 | 203.2
Steel Assembly | RIGID_FRAME | 58.8 | +10.387 | +10.590 | D-E/1-2 | 471-B-A186 | 203.2
2 x Steel Assembly | RIGID_FRAME | 48.6 | +10.387 | +10.590 | D-E/1-2 | 471-B-A189 | 203.2
Steel Assembly | RIGID_FRAME | 53.9 | +10.387 | +10.590 | D-E/1-2 | 471-B-A192 | 203.2
Steel Assembly | RIGID_FRAME | 170.5 | +5.497 | +5.700 | C-D/4-5 | 471-B-A59 | 371.339
Steel Assembly | RIGID_FRAME | 53.9 | +5.497 | +5.700 | C-D/4-5 | 471-B-A58 | 160
Steel Assembly | RIGID_FRAME | 27.2 | +5.344 | +5.497 | C-D/4-5 | 471-B-A127 | 152.4
Steel Assembly | RIGID_FRAME | 53.6 | +5.500 | +5.700 | C-D/4-5 | 471-B-A60 | 313.848
Steel Assembly | RIGID_FRAME | 27.2 | +5.192 | +5.344 | B-C/3-4 | 471-D-C287 | 152.4
Steel Assembly | RIGID_FRAME | 100.1 | +5.346 | +5.700 | B-C/3-4 | 471-D-C196 | 160
Steel Assembly | RIGID_FRAME | 27.2 | +5.348 | +5.500 | C-D/4-5 | 471-B-A127 | 152.4
Steel Assembly | RIGID_FRAME | 75.1 | +5.192 | +5.344 | D-E/3-4 | 471-B-A131 | 152.4
Steel Assembly | RIGID_FRAME | 75.1 | +5.192 | +5.344 | D-E/2-3 | 471-B-A131 | 152.4
Steel Assembly | RIGID_FRAME | 27.2 | +5.192 | +5.344 | D-E/1-2 | 471-B-A130 | 152.4
Steel Assembly | RIGID_FRAME | 70.9 | +5.346 | +5.700 | D-E/1-2 | 471-B-A82 | 160
Steel Assembly | RIGID_FRAME | 16.5 | +10.410 | +10.480 | D-E/2-3 | 471-B-A167 | 70
Steel Assembly | RIGID_FRAME | 69.7 | +10.390 | +10.590 | D-E/2-3 | 471-B-A74 | 288.136
Steel Assembly | RIGID_FRAME | 15.5 | +10.410 | +10.480 | D-E/2-3 | 471-B-A168 | 70
Steel Assembly | RIGID_FRAME | 38.1 | +5.192 | +5.344 | D/1-2 | 471-B-A129 | 152.4
Steel Assembly | RIGID_FRAME | 70.9 | +5.346 | +5.700 | D-E/1-2 | 471-B-A71 | 160
Steel Assembly | RIGID_FRAME | 27.2 | +5.192 | +5.344 | C-D/1-2 | 471-B-A128 | 152.4
Steel Assembly | RIGID_FRAME | 221.7 | +7.893 | +8.145 | E/2-3 | 471-B-A181 | 146.1
Steel Assembly | RIGID_FRAME | 221.7 | +7.893 | +8.145 | D/2-3 | 471-B-A182 | 146.1
Steel Assembly | RIGID_FRAME | 109.1 | +5.346 | +5.700 | C-D/1-2 | 471-B-A76 | 160
Steel Assembly | RIGID_FRAME | 16.5 | +5.520 | +5.590 | D-E/2-3 | 471-B-A165 | 70
Steel Assembly | RIGID_FRAME | 72.1 | +5.500 | +5.700 | D-E/2-3 | 471-B-A3 | 227.107
Steel Assembly | RIGID_FRAME | 15.6 | +5.520 | +5.590 | D-E/2-3 | 471-B-A166 | 70
Steel Assembly | RIGID_FRAME | 195.5 | +4.982 | +6.051 | D-E/2 | 471-B-A55 | 527.94
Steel Assembly | RIGID_FRAME | 69.3 | +5.500 | +5.700 | D-E/2-3 | 471-B-A73 | 287.29
Steel Assembly | RIGID_FRAME | 47 | +5.497 | +5.700 | B-C/1-2 | 471-D-C358 | 203.2
Steel Assembly | RIGID_FRAME | 47 | +5.497 | +5.700 | B-C/4 | 471-D-C365 | 203.2
Steel Assembly | RIGID_FRAME | 44.7 | +5.497 | +5.700 | C-D/4 | 471-B-A190 | 203.2
Steel Assembly | RIGID_FRAME | 13.5 | +2.520 | +2.590 | D-E/2-3 | 471-B-A169 | 70
Steel Assembly | RIGID_FRAME | 58.8 | +2.500 | +2.700 | D-E/2-3 | 471-B-A2 | 233.854
Steel Assembly | RIGID_FRAME | 44.5 | +5.497 | +5.700 | C-D/4-5 | 471-B-A188 | 203.2
Steel Assembly | RIGID_FRAME | 11 | +5.513 | +5.593 | C-D/2-3 | 471-B-A147 | 80
Steel Assembly | RIGID_FRAME | 28.1 | +5.500 | +5.700 | C-D/2-3 | 471-B-A121 | 415.604
Steel Assembly | RIGID_FRAME | 48.6 | +5.497 | +5.700 | C-D/2-3 | 471-B-A196 | 374.334
Steel Assembly | RIGID_FRAME | 10.3 | +5.513 | +5.593 | C-D/2-3 | 471-B-A162 | 80
Steel Assembly | RIGID_FRAME | 28.3 | +5.500 | +5.700 | C-D/2-3 | 471-B-A122 | 429.746
Steel Assembly | RIGID_FRAME | 100.1 | +48.483 | +48.543 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +48.295 | +48.355 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +48.108 | +48.168 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +47.920 | +47.980 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +47.733 | +47.793 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +47.545 | +47.605 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +47.358 | +47.418 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +47.170 | +47.230 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +70.420 | +70.480 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +70.220 | +70.280 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +70.020 | +70.080 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +69.820 | +69.880 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +69.620 | +69.680 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +69.420 | +69.480 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +69.220 | +69.280 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +69.020 | +69.080 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +68.820 | +68.880 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +68.620 | +68.680 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +68.220 | +68.280 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +68.020 | +68.080 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +67.820 | +67.880 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +67.620 | +67.680 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +67.420 | +67.480 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +67.220 | +67.280 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +67.020 | +67.080 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +66.820 | +66.880 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +66.620 | +66.680 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +66.420 | +66.480 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +66.020 | +66.080 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +65.820 | +65.880 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +65.620 | +65.680 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +65.420 | +65.480 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +65.220 | +65.280 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +65.020 | +65.080 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +64.820 | +64.880 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +64.620 | +64.680 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +64.420 | +64.480 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +64.220 | +64.280 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +64.020 | +64.080 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +63.820 | +63.880 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +63.620 | +63.680 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +63.226 | +63.286 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +63.032 | +63.092 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +62.838 | +62.898 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +62.644 | +62.704 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +62.450 | +62.510 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +62.256 | +62.316 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +62.062 | +62.122 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +61.869 | +61.929 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +61.675 | +61.735 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +61.481 | +61.541 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +61.287 | +61.347 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +61.093 | +61.153 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +60.899 | +60.959 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +60.511 | +60.571 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +60.317 | +60.377 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +60.123 | +60.183 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +59.929 | +59.989 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +59.735 | +59.795 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +59.541 | +59.601 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +59.347 | +59.407 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +59.154 | +59.214 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +58.960 | +59.020 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +58.766 | +58.826 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +58.572 | +58.632 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +58.378 | +58.438 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +58.184 | +58.244 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +57.796 | +57.856 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +57.602 | +57.662 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +57.408 | +57.468 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +57.214 | +57.274 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +57.020 | +57.080 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +56.826 | +56.886 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +56.632 | +56.692 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +56.439 | +56.499 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +56.245 | +56.305 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +56.051 | +56.111 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +55.857 | +55.917 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +55.663 | +55.723 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +55.469 | +55.529 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +55.086 | +55.146 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +54.897 | +54.957 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +54.709 | +54.769 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +54.520 | +54.580 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +54.331 | +54.391 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +54.142 | +54.202 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +53.954 | +54.014 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +53.765 | +53.825 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +53.576 | +53.636 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +53.387 | +53.447 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +53.199 | +53.259 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +52.821 | +52.881 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +52.633 | +52.693 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +52.444 | +52.504 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +52.255 | +52.315 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +52.066 | +52.126 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +51.878 | +51.938 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +51.689 | +51.749 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +51.500 | +51.560 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +51.312 | +51.372 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +50.934 | +50.994 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +50.746 | +50.806 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +50.557 | +50.617 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +50.368 | +50.428 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +50.180 | +50.240 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +49.991 | +50.051 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +49.802 | +49.862 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +49.613 | +49.673 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +49.425 | +49.485 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +49.236 | +49.296 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +49.047 | +49.107 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +48.859 | +48.919 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +46.795 | +46.855 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +46.608 | +46.668 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +46.420 | +46.480 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +46.233 | +46.293 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +46.045 | +46.105 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +45.858 | +45.918 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +45.670 | +45.730 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +45.483 | +45.543 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +45.295 | +45.355 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +45.108 | +45.168 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +44.920 | +44.980 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +44.733 | +44.793 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +44.347 | +44.407 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +44.149 | +44.209 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +43.952 | +44.012 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +43.754 | +43.814 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +43.556 | +43.616 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +43.358 | +43.418 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +43.160 | +43.220 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +42.963 | +43.023 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +42.765 | +42.825 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +42.567 | +42.627 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +42.369 | +42.429 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +42.172 | +42.232 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +41.974 | +42.034 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +41.578 | +41.638 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +41.381 | +41.441 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +41.183 | +41.243 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +40.985 | +41.045 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +40.787 | +40.847 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +40.590 | +40.650 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +40.392 | +40.452 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +40.194 | +40.254 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +39.997 | +40.057 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +39.799 | +39.859 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +39.601 | +39.661 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +39.403 | +39.463 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +39.206 | +39.266 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +24.097 | +24.157 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +23.907 | +23.967 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +23.716 | +23.776 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +23.526 | +23.586 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +23.335 | +23.395 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +23.145 | +23.205 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +22.954 | +23.014 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +22.764 | +22.824 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +22.573 | +22.633 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +22.383 | +22.443 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +22.192 | +22.252 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +22.002 | +22.062 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +21.811 | +21.871 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +21.621 | +21.681 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +33.780 | +33.840 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +33.590 | +33.650 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +33.401 | +33.461 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +33.212 | +33.272 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +33.023 | +33.083 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +32.833 | +32.893 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +32.644 | +32.704 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +32.455 | +32.515 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +32.266 | +32.326 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +32.076 | +32.136 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +31.887 | +31.947 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +26.194 | +26.254 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +26.004 | +26.064 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +25.813 | +25.873 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +25.622 | +25.682 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +25.432 | +25.492 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +25.241 | +25.301 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +25.051 | +25.111 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +24.860 | +24.920 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +24.669 | +24.729 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +24.479 | +24.539 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +28.860 | +28.920 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +28.669 | +28.729 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +28.479 | +28.539 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +28.289 | +28.349 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +28.098 | +28.158 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +27.908 | +27.968 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +27.717 | +27.777 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +27.527 | +27.587 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +27.337 | +27.397 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +27.146 | +27.206 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +26.956 | +27.016 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +26.766 | +26.826 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +26.575 | +26.635 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +31.509 | +31.569 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +31.320 | +31.380 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +31.131 | +31.191 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +30.941 | +31.001 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +30.752 | +30.812 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +30.563 | +30.623 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +30.374 | +30.434 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +30.185 | +30.245 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +29.996 | +30.056 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +29.807 | +29.867 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +29.617 | +29.677 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +29.428 | +29.488 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +29.239 | +29.299 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +36.051 | +36.111 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +35.861 | +35.921 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +35.672 | +35.732 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +35.483 | +35.543 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +35.294 | +35.354 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +35.104 | +35.164 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +34.915 | +34.975 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +34.726 | +34.786 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +34.537 | +34.597 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +34.347 | +34.407 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +34.158 | +34.218 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +38.810 | +38.870 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +38.613 | +38.673 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +38.415 | +38.475 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +38.217 | +38.277 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +38.019 | +38.079 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +37.822 | +37.882 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +37.624 | +37.684 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +37.426 | +37.486 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +37.229 | +37.289 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +37.031 | +37.091 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +36.833 | +36.893 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +36.635 | +36.695 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +36.438 | +36.498 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +21.241 | +21.301 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +21.051 | +21.111 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +20.862 | +20.922 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +20.672 | +20.732 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +20.483 | +20.543 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +20.293 | +20.353 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +20.104 | +20.164 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +19.914 | +19.974 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly |  | 0 | +19.536 | +19.596 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +19.346 | +19.406 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +19.157 | +19.217 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +18.967 | +19.027 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +18.778 | +18.838 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +18.588 | +18.648 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +18.399 | +18.459 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +18.209 | +18.269 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly | RIGID_FRAME | 100.1 | +17.824 | +17.884 | D-E/2-3 | 471-0-010000 | 750
Steel Assembly |  | 0 | +17.628 | +17.688 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +17.432 | +17.492 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +17.237 | +17.297 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +17.041 | +17.101 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +16.845 | +16.905 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +16.649 | +16.709 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +16.453 | +16.513 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +16.257 | +16.317 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +16.062 | +16.122 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +15.866 | +15.926 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +15.473 | +15.533 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +15.277 | +15.337 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +15.080 | +15.140 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +14.884 | +14.944 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +14.687 | +14.747 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +14.491 | +14.551 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +14.294 | +14.354 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +14.098 | +14.158 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +13.901 | +13.961 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +13.705 | +13.765 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +13.508 | +13.568 | D-E/2-3 | 471-0-010003 | 750
Steel Assembly |  | 0 | +13.312 | +13.372 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +12.918 | +12.978 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +12.722 | +12.782 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +12.525 | +12.585 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +12.329 | +12.389 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +12.132 | +12.192 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +11.936 | +11.996 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +11.739 | +11.799 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +11.543 | +11.603 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +11.346 | +11.406 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +11.150 | +11.210 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +10.953 | +11.013 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +10.757 | +10.817 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +10.372 | +10.432 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +10.184 | +10.244 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +9.996 | +10.056 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +9.808 | +9.868 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +9.620 | +9.680 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +9.432 | +9.492 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +9.243 | +9.303 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +9.055 | +9.115 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +8.867 | +8.927 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +8.679 | +8.739 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +8.491 | +8.551 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +8.303 | +8.363 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +5.470 | +5.530 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +5.270 | +5.330 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +5.070 | +5.130 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +4.870 | +4.930 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +4.670 | +4.730 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +4.470 | +4.530 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +4.270 | +4.330 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +4.070 | +4.130 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +3.870 | +3.930 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +3.670 | +3.730 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +3.470 | +3.530 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +3.270 | +3.330 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +3.070 | +3.130 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +2.870 | +2.930 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly | RIGID_FRAME | 110.3 | -0.070 | +2.700 | D-E/2-3 | 471-B-A9 | 90
Steel Assembly | RIGID_FRAME | 110.3 | -0.070 | +2.700 | E/2-3 | 471-B-A10 | 90
Steel Assembly |  | 0 | +2.470 | +2.530 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +2.270 | +2.330 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +2.070 | +2.130 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +1.870 | +1.930 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +1.670 | +1.730 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +1.470 | +1.530 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +1.270 | +1.330 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +1.070 | +1.130 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +0.870 | +0.930 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +0.670 | +0.730 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +0.470 | +0.530 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +0.270 | +0.330 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +0.070 | +0.130 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +7.927 | +7.987 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +7.739 | +7.799 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +7.551 | +7.611 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +7.363 | +7.423 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +7.175 | +7.235 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +6.987 | +7.047 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +6.798 | +6.858 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +6.610 | +6.670 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +6.422 | +6.482 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +6.234 | +6.294 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +6.046 | +6.106 | D-E/2-3 | 471-0-010001 | 750
Steel Assembly |  | 0 | +5.858 | +5.918 | D-E/2-3 | 471-0-010001 | 750
2 x Steel Assembly | RIGID_FRAME | 231 | +5.725 | +10.134 | C-D/4 | 471-B-A220 | 219.1
Steel Assembly | RIGID_FRAME | 54.6 | +5.700 | +6.100 | C-D/4-5 | 471-B-A140 | 1016
Steel Assembly | RIGID_FRAME | 8.2 | +5.700 | +6.100 | C-D/4 | 471-B-A249 | 150
Steel Assembly | RIGID_FRAME | 8.2 | +5.700 | +6.100 | C/4 | 471-B-A250 | 150
Steel Assembly | RIGID_FRAME | 442.7 | +5.010 | +6.039 | C-D/4 | 471-B-A22 | 196.75
Steel Assembly | RIGID_FRAME | 44.7 | +5.497 | +5.700 | C-D/4-5 | 471-B-A193 | 203.2
Steel Assembly | RIGID_FRAME | 53.7 | +5.497 | +5.700 | D-E/1-2 | 471-B-A187 | 203.2
Steel Assembly | RIGID_FRAME | 53.9 | +5.497 | +5.700 | D-E/1-2 | 471-B-A192 | 203.2
2 x Steel Assembly | RIGID_FRAME | 157.4 | +5.256 | +5.449 | C-D/3-4 | 471-B-A202 | 210
Steel Assembly | RIGID_FRAME | 169.4 | +5.441 | +5.635 | D-E/3-4 | 471-B-A206 | 210
Steel Assembly | RIGID_FRAME | 184.7 | +4.982 | +6.051 | D-E/3 | 471-B-A44 | 399.331
Steel Assembly | RIGID_FRAME | 205 | +4.822 | +6.187 | D-E/4 | 471-B-A46 | 399.331
Steel Assembly | RIGID_FRAME | 175.9 | +5.256 | +5.449 | D-E/1-2 | 471-B-A203 | 210
Steel Assembly | RIGID_FRAME | 204.8 | +4.974 | +6.187 | D-E/1 | 471-B-A54 | 602.208
Steel Assembly | RIGID_FRAME | 161.5 | +5.256 | +5.449 | B-C/1-2 | 471-D-C417 | 210
Steel Assembly | RIGID_FRAME | 434.9 | +4.992 | +5.700 | B-C/1 | 471-D-C33 | 553.039
Steel Assembly | RIGID_FRAME | 287.8 | +5.328 | +5.700 | B-C/1-2 | 471-D-C86 | 785.73
Steel Assembly | RIGID_FRAME | 149.9 | +5.256 | +5.449 | B-C/1-2 | 471-D-C383 | 210
Steel Assembly | RIGID_FRAME | 149.2 | +5.256 | +5.449 | B-C/1-2 | 471-D-C382 | 210
Steel Assembly | RIGID_FRAME | 277.7 | +5.328 | +5.700 | B-C/1-2 | 471-D-C113 | 788.579
2 x Steel Assembly | RIGID_FRAME | 213.5 | +10.740 | +15.276 | C/1-2 | 471-C-B275 | 219.1
Steel Assembly | RIGID_FRAME | 487.5 | +5.291 | +5.700 | B-C/2 | 471-D-C487 | 210.8
Steel Assembly | RIGID_FRAME | 537.5 | +5.136 | +5.700 | B-C/3 | 471-D-C159 | 626.85
Steel Assembly | RIGID_FRAME | 67.8 | +5.256 | +5.449 | B-C/2-3 | 471-D-C379 | 210
Steel Assembly | RIGID_FRAME | 453.7 | +5.328 | +5.700 | B-C/2-3 | 471-D-C67 | 794.612
Steel Assembly | RIGID_FRAME | 147.5 | +5.328 | +5.700 | B-C/2-3 | 471-D-C85 | 798.742
Steel Assembly | RIGID_FRAME | 472.9 | +4.892 | +6.071 | C/2-3 | 471-B-A16 | 196.75
Steel Assembly | RIGID_FRAME | 87.1 | +5.256 | +5.449 | B-C/2-3 | 471-D-C375 | 210
Steel Assembly | RIGID_FRAME | 138.4 | +5.328 | +5.700 | B-C/2-3 | 471-D-C84 | 771.553
Steel Assembly | RIGID_FRAME | 92.4 | +5.256 | +5.449 | B-C/2-3 | 471-D-C374 | 210
Steel Assembly | RIGID_FRAME | 130 | +5.256 | +5.449 | B-C/2-3 | 471-D-C376 | 210
Steel Assembly | RIGID_FRAME | 146.9 | +5.328 | +5.700 | B-C/2-3 | 471-D-C101 | 792.138
Steel Assembly | RIGID_FRAME | 76.1 | +5.256 | +5.449 | B-C/2-3 | 471-D-C381 | 210
Steel Assembly | RIGID_FRAME | 81.5 | +5.256 | +5.449 | B-C/2-3 | 471-D-C380 | 210
Steel Assembly | RIGID_FRAME | 433.1 | +5.328 | +5.700 | B-C/2-3 | 471-D-C89 | 780.035
Steel Assembly | RIGID_FRAME | 164.8 | +5.328 | +5.700 | B-C/2-3 | 471-D-C104 | 801.041
Steel Assembly | RIGID_FRAME | 145.9 | +5.256 | +5.449 | B-C/2-3 | 471-D-C377 | 210
Steel Assembly | RIGID_FRAME | 158.1 | +5.328 | +5.700 | B-C/2-3 | 471-D-C103 | 792.576
Steel Assembly | RIGID_FRAME | 138.4 | +5.256 | +5.449 | B-C/2-3 | 471-D-C378 | 210
Steel Assembly | RIGID_FRAME | 149.6 | +5.256 | +5.449 | B-C/3-4 | 471-D-C384 | 210
Steel Assembly | RIGID_FRAME | 139.3 | +5.256 | +5.449 | B-C/3-4 | 471-D-C385 | 210
Steel Assembly | RIGID_FRAME | 249.7 | +5.328 | +5.700 | B-C/3-4 | 471-D-C88 | 791.805
Steel Assembly | RIGID_FRAME | 388 | +5.322 | +5.700 | B-C/4 | 471-D-C105 | 557.301
Steel Assembly | RIGID_FRAME | 140.7 | +5.256 | +5.449 | B-C/3-4 | 471-D-C386 | 210
Steel Assembly | RIGID_FRAME | 253.8 | +5.328 | +5.700 | B-C/3-4 | 471-D-C87 | 792.587
Steel Assembly | RIGID_FRAME | 102.7 | +5.500 | +5.700 | B-C/1-2 | 471-D-C236 | 160
Steel Assembly | RIGID_FRAME | 36.7 | +5.500 | +5.700 | B-C/2-3 | 471-D-C252 | 160
Steel Assembly | RIGID_FRAME | 82.5 | +5.500 | +5.700 | B-C/2-3 | 471-D-C209 | 160
Steel Assembly | RIGID_FRAME | 82.5 | +5.500 | +5.700 | B-C/2-3 | 471-D-C253 | 160
2 x Steel Assembly | RIGID_FRAME | 93.6 | +5.500 | +5.700 | B-C/3-4 | 471-D-C250 | 161
Steel Assembly | RIGID_FRAME | 83.2 | +5.500 | +5.700 | B-C/2-3 | 471-D-C164 | 205
Steel Assembly | RIGID_FRAME | 50 | +5.500 | +5.700 | B-C/2-3 | 471-D-C261 | 160
4 x Steel Assembly | RIGID_FRAME | 16.7 | +2.570 | +2.750 | B-C/1-2 | 471-D-C419 | 160
4 x Steel Assembly | RIGID_FRAME | 93.8 | +2.550 | +2.750 | B-C/1-2 | 471-D-C248 | 160
Steel Assembly | RIGID_FRAME | 93.8 | +2.550 | +2.750 | B-C/1-2 | 471-D-C224 | 160
Steel Assembly | RIGID_FRAME | 71.2 | +2.550 | +2.750 | A-B/1-2 | 471-D-C167 | 160
Steel Assembly | RIGID_FRAME | 2298.6 | +0.000 | +12.501 | C/2 | 471-B-A213 | 816.746
Steel Assembly | RIGID_FRAME | 2285 | +0.000 | +12.501 | D/2 | 471-B-A210 | 639.777
Steel Assembly | RIGID_FRAME | 2260 | +0.000 | +12.501 | E/2 | 471-B-A211 | 720.478
Steel Assembly | RIGID_FRAME | 8 | +15.614 | +15.700 | B-C/2-3 | 471-D-C296 | 160
Steel Assembly | RIGID_FRAME | 8 | +15.614 | +15.700 | B-C/2-3 | 471-D-C295 | 160
Steel Assembly | RIGID_FRAME | 38.5 | +2.750 | +4.606 | A-B/1-2 | 471-D-C371 | 620
Steel Assembly | RIGID_FRAME | 9.9 | +3.141 | +3.225 | A-B/1-2 | 471-D-C474 | 84
Steel Assembly | RIGID_FRAME | 8.2 | +2.575 | +3.855 | B/3-4 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 374.7 | +4.989 | +5.344 | E/RACK1-1 | 471-D-C96 | 307.3
Steel Assembly | RIGID_FRAME | 374.7 | +6.894 | +7.250 | E/RACK1-1 | 471-D-C96 | 307.3
Steel Assembly | RIGID_FRAME | 374.7 | +8.844 | +9.200 | E/RACK1-1 | 471-D-C96 | 307.3
Steel Assembly | RIGID_FRAME | 374.7 | +10.844 | +11.200 | E/RACK1-1 | 471-D-C96 | 307.3
Steel Assembly | RIGID_FRAME | 381.6 | +10.844 | +11.200 | C-D/RACK1-1 | 471-D-C469 | 307.3
Steel Assembly | RIGID_FRAME | 381.6 | +8.844 | +9.200 | C-D/RACK1-1 | 471-D-C471 | 307.3
Steel Assembly | RIGID_FRAME | 381.6 | +7.844 | +8.200 | C-D/RACK1-1 | 471-D-C472 | 307.3
Steel Assembly | RIGID_FRAME | 381.6 | +10.844 | +11.200 | B-C/RACK1-1 | 471-D-C469 | 307.3
Steel Assembly | RIGID_FRAME | 381.6 | +8.844 | +9.200 | B-C/RACK1-1 | 471-D-C473 | 307.3
Steel Assembly | RIGID_FRAME | 381.6 | +8.844 | +9.200 | A-B/RACK1-1 | 471-D-C106 | 307.3
Steel Assembly | RIGID_FRAME | 381.6 | +8.844 | +9.200 | A-B/RACK1-1 | 471-D-C468 | 307.3
Steel Assembly | RIGID_FRAME | 46.4 | +15.500 | +15.700 | B-C/1-2 | 471-D-C276 | 160
Steel Assembly | RIGID_FRAME | 46.4 | +15.500 | +15.700 | C/1-2 | 471-D-C276 | 160
Steel Assembly | RIGID_FRAME | 33.1 | +15.500 | +15.700 | B-C/1-2 | 471-D-C172 | 160
Steel Assembly | RIGID_FRAME | 26.1 | +10.390 | +10.590 | C-D/2-3 | 471-B-A117 | 307.949
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C/1 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C/1-2 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 444.2 | +9.843 | +10.943 | D/2-3 | 471-B-A33 | 315
3 x Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | D/2-3 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 440.1 | +9.838 | +10.943 | E/2-3 | 471-B-A39 | 315
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | D/3 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C/2 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 455.5 | +9.798 | +10.943 | C/2-3 | 471-B-A20 | 315.001
3 x Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C/2-3 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C/2 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C/3 | 471-B-A178 | 70
4 x Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | A-B/1 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | A/1 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | B/1 | 471-D-C342 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | A/2-3 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | A/1-2 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | A/2 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | A/1 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | A/2 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | A-B/3 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | B/3 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | B/3-4 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | B/3 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | B/4 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 436.7 | +5.010 | +6.041 | E/2-3 | 471-B-A31 | 315
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | E/2-3 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 438.6 | +5.010 | +6.041 | D/2-3 | 471-B-A18 | 315
3 x Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | D/2-3 | 471-B-A177 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | B-C/4 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | B/4 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | C/4 | 471-D-C343 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | B-C/1 | 471-D-C342 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | B/1 | 471-D-C343 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | C/1 | 471-D-C342 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | C-D/4-5 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | C/4-5 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | D/4-5 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 126.2 | +5.344 | +5.700 | C/4-5 | 471-B-A27 | 265.751
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | C/4-5 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | C/4 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 123.3 | +5.344 | +5.700 | D/4-5 | 471-B-A35 | 265
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | D/4-5 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | D/4 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 226.5 | +5.344 | +5.700 | D/3-4 | 471-B-A52 | 265
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | D/3-4 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | D/3 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | D/4 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | D/3 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 65.7 | +3.572 | +5.342 | D/4-5 | 471-B-A124 | 180
Steel Assembly | RIGID_FRAME | 65.7 | +3.572 | +5.342 | C/4-5 | 471-B-A124 | 180
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | D-E/4 | 471-B-A177 | 70
4 x Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C-D/4 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C/4 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 421.1 | +10.218 | +10.943 | C-D/1 | 471-B-A24 | 619.652
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | D/1 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C/1 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | E/4 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 273 | +9.838 | +10.985 | C/3-4 | 471-B-A48 | 315.001
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C/3-4 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C/3 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C/4 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | D-E/3 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | D/3 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | E/3 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 245.5 | +9.868 | +10.590 | E/3-4 | 471-B-A26 | 265
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | E/3-4 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | E/3 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | E/4 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 285.8 | +9.885 | +10.948 | E/1-2 | 471-B-A15 | 315
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | E/2 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | E/1-2 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | E/1 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | E/2 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | E/2 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 285.3 | +4.970 | +6.049 | E/1-2 | 471-B-A14 | 315
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | E/1-2 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | E/1 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | E/2 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | D-E/1 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | E/1 | 471-B-A177 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | C-D/1 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +10.415 | +11.695 | D/1 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | D-E/1 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | D/1 | 471-B-A178 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | E/1 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 474.3 | +4.991 | +6.049 | C-D/1 | 471-B-A34 | 619.652
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | C/1 | 471-B-A178 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | C-D/1 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +5.525 | +6.805 | D/1 | 471-B-A177 | 70
Steel Assembly | RIGID_FRAME | 47.3 | +11.043 | +12.298 | <A/2 | 471-D-C15 | 91
Steel Assembly | RIGID_FRAME | 65.7 | +15.922 | +17.692 | D/3-4 | 471-C-B133 | 180
Steel Assembly | RIGID_FRAME | 404.3 | +17.344 | +18.050 | C-D/3 | 471-C-B35 | 504.936
Steel Assembly | RIGID_FRAME | 432.3 | +15.008 | +16.051 | C-D/3 | 471-C-B41 | 190
Steel Assembly | RIGID_FRAME | 463.2 | +9.895 | +11.002 | C-D/2 | 471-B-A23 | 639.858
Steel Assembly | RIGID_FRAME | 459.8 | +5.010 | +6.104 | C-D/2 | 471-B-A19 | 639.858
Steel Assembly | RIGID_FRAME | 486.8 | +9.881 | +10.590 | A-B/1 | 471-D-C61 | 190
Steel Assembly | RIGID_FRAME | 442.7 | +7.140 | +8.197 | C-D/1 | 471-B-A56 | 190
Steel Assembly | RIGID_FRAME | 365.9 | +10.234 | +10.590 | B-C/1 | 471-D-C72 | 404.22
Steel Assembly | RIGID_FRAME | 1040.7 | +12.002 | +18.400 | C/1 | 471-C-B245 | 310.6
Steel Assembly | RIGID_FRAME | 121.7 | +10.281 | +10.475 | B-C/1-2 | 471-D-C390 | 210
Steel Assembly | RIGID_FRAME | 121.3 | +10.281 | +10.475 | B-C/1-2 | 471-D-C391 | 210
8 x Steel Assembly | RIGID_FRAME | 17.6 | +12.132 | +12.144 | A-B/4-5 | 471-D-C490 | 12
8 x Steel Assembly | RIGID_FRAME | 20.3 | +12.132 | +12.144 | A-B/2-3 | 471-D-C489 | 12
2 x Steel Assembly | RIGID_FRAME | 12.2 | +10.591 | +10.843 | A-B/1 | 471-D-C285 | 170
2 x Steel Assembly | RIGID_FRAME | 30.2 | +9.201 | +10.233 | A-B/1 | 471-D-C284 | 170
Steel Assembly | RIGID_FRAME | 30.2 | +9.201 | +10.233 | B-C/1 | 471-D-C284 | 170
Steel Assembly | RIGID_FRAME | 12.2 | +10.591 | +10.843 | B-C/1 | 471-D-C285 | 170
2 x Steel Assembly | RIGID_FRAME | 164.2 | +7.869 | +10.193 | C-D/1 | 471-B-A248 | 219.1
Steel Assembly | RIGID_FRAME | 66.8 | +9.201 | +10.233 | C-D/1 | 471-B-A125 | 834.064
Steel Assembly | RIGID_FRAME | 12.2 | +10.591 | +10.843 | C-D/1 | 471-B-A126 | 170
Steel Assembly | RIGID_FRAME | 21.2 | +8.201 | +8.843 | C-D/1 | 471-D-C286 | 170
2 x Steel Assembly | RIGID_FRAME | 145.6 | +5.725 | +7.463 | C-D/1 | 471-B-A225 | 219.1
Steel Assembly | RIGID_FRAME | 65.7 | +15.922 | +17.692 | C/3-4 | 471-C-B133 | 180
Steel Assembly | RIGID_FRAME | 649.6 | +12.002 | +16.000 | C/4 | 471-C-B240 | 310.6
Steel Assembly | RIGID_FRAME | 269.9 | +0.143 | +5.244 | C/3-4 | 471-B-A247 | 219.1
Steel Assembly | RIGID_FRAME | 267.6 | +4.928 | +6.097 | C/3-4 | 471-B-A51 | 190
Steel Assembly | RIGID_FRAME | 245.2 | +5.775 | +10.159 | C/3-4 | 471-B-A246 | 219.1
Steel Assembly | RIGID_FRAME | 252.7 | +10.665 | +15.269 | C/3-4 | 471-C-B276 | 219.1
Steel Assembly | RIGID_FRAME | 184.7 | +15.725 | +17.669 | C/1-2 | 471-C-B274 | 219.1
Steel Assembly | RIGID_FRAME | 260.3 | +5.730 | +10.204 | C/1-2 | 471-B-A244 | 219.1
Steel Assembly | RIGID_FRAME | 283.9 | +4.950 | +6.054 | C/1-2 | 471-B-A50 | 190
Steel Assembly | RIGID_FRAME | 281.7 | +0.117 | +5.269 | C/1-2 | 471-B-A245 | 219.1
8 x Steel Assembly | RIGID_FRAME | 17.5 | +12.132 | +12.144 | A-B/4-5 | 471-D-C488 | 12
Steel Assembly | RIGID_FRAME | 155.2 | +0.000 | +3.250 | A-B/2 | 471-D-C354 | 250
Steel Assembly | RIGID_FRAME | 155.2 | +0.000 | +3.250 | A-B/1-2 | 471-D-C356 | 250
Steel Assembly | RIGID_FRAME | 132.1 | +0.000 | +2.750 | A-B/1 | 471-D-C355 | 250
Steel Assembly | RIGID_FRAME | 1296.3 | +0.000 | +12.500 | A/1 | 471-D-C141 | 560
Steel Assembly | RIGID_FRAME | 1825.2 | +0.000 | +10.590 | D/4 | 471-B-A217 | 560
Steel Assembly | RIGID_FRAME | 1806 | +0.000 | +10.590 | E/4 | 471-B-A218 | 640.842
Steel Assembly | RIGID_FRAME | 208.8 | -0.300 | +7.123 | A-B/RACK1-1 | 471-0-010023 | 780.01
Steel Assembly | RIGID_FRAME | 211.8 | +5.500 | +12.806 | A-B/RACK1-1 | 471-0-010024 | 780.01
Steel Assembly | RIGID_FRAME | 318.3 | -0.100 | +10.185 | A-B/RACK1-1 | 471-0-010025 | 780.01
5 x Steel Assembly | RIGID_FRAME | 40.4 | +8.404 | +8.604 | A-B/RACK1-1 | 471-D-C229 | 140
Steel Assembly | RIGID_FRAME | 46.7 | +21.260 | +21.460 | C-D/2-3 | 471-C-B114 | 346.838
Steel Assembly | RIGID_FRAME | 46.6 | +21.260 | +21.460 | C-D/2-3 | 471-C-B113 | 345.692
Steel Assembly | RIGID_FRAME | 168 | +21.485 | +23.937 | C-D/3 | 471-C-B252 | 219.1
Steel Assembly | RIGID_FRAME | 168.3 | +21.485 | +23.937 | C-D/3 | 471-C-B253 | 219.1
Steel Assembly | RIGID_FRAME | 52.5 | +1.000 | +1.200 | C-D/3-4 | 471-0-010008 | 75
Steel Assembly | RIGID_FRAME | 52.7 | +1.000 | +1.200 | C-D/3-4 | 471-0-010007 | 75
Steel Assembly | RIGID_FRAME | 105.2 | +1.000 | +1.200 | C-D/3 | 471-0-010006 | 75
2 x Steel Assembly | RIGID_FRAME | 16.5 | +21.273 | +21.353 | C-D/2-3 | 471-C-B161 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +21.273 | +21.353 | C-D/2-3 | 471-C-B160 | 80
Steel Assembly | RIGID_FRAME | 21.1 | +1.000 | +1.200 | C-D/3-4 | 471-0-010005 | 75
Steel Assembly | RIGID_FRAME | 35.7 | +1.000 | +1.200 | C-D/3-4 | 471-0-010004 | 75
Steel Assembly | RIGID_FRAME | 35.7 | +1.000 | +1.200 | D/3-4 | 471-0-010004 | 75
Steel Assembly | RIGID_FRAME | 28.1 | +21.260 | +21.460 | C-D/2-3 | 471-C-B105 | 455.431
Steel Assembly | RIGID_FRAME | 27.9 | +21.260 | +21.460 | C-D/2-3 | 471-C-B82 | 447.185
Steel Assembly | RIGID_FRAME | 41.9 | +21.260 | +21.460 | C-D/2-3 | 471-C-B80 | 160
Steel Assembly | RIGID_FRAME | 15.8 | +21.273 | +21.353 | C-D/2-3 | 471-C-B184 | 80
4 x Steel Assembly | RIGID_FRAME | 17.5 | +21.273 | +21.353 | C-D/2-3 | 471-C-B165 | 80
Steel Assembly | RIGID_FRAME | 27.9 | +21.260 | +21.460 | C-D/2-3 | 471-C-B86 | 453.536
Steel Assembly | RIGID_FRAME | 27.9 | +21.260 | +21.460 | C-D/2-3 | 471-C-B87 | 446.565
2 x Steel Assembly | RIGID_FRAME | 16.3 | +21.273 | +21.353 | C-D/2-3 | 471-C-B170 | 80
Steel Assembly | RIGID_FRAME | 17.5 | +21.273 | +21.353 | C-D/2-3 | 471-C-B172 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +21.273 | +21.353 | C-D/2-3 | 471-C-B169 | 80
Steel Assembly | RIGID_FRAME | 17.1 | +21.273 | +21.353 | C-D/2-3 | 471-C-B168 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +21.273 | +21.353 | C-D/2-3 | 471-C-B167 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +21.273 | +21.353 | C-D/2-3 | 471-C-B166 | 80
Steel Assembly | RIGID_FRAME | 44.3 | +17.850 | +18.050 | C-D/2-3 | 471-C-B92 | 253.403
Steel Assembly | RIGID_FRAME | 46.6 | +17.850 | +18.050 | C-D/2-3 | 471-C-B112 | 346.838
2 x Steel Assembly | RIGID_FRAME | 46.7 | +17.850 | +18.050 | C-D/2-3 | 471-C-B114 | 346.838
Steel Assembly | RIGID_FRAME | 15.8 | +17.863 | +17.943 | C-D/2-3 | 471-C-B174 | 80
Steel Assembly | RIGID_FRAME | 15.1 | +17.863 | +17.943 | C-D/2-3 | 471-C-B177 | 80
5 x Steel Assembly | RIGID_FRAME | 17.5 | +17.863 | +17.943 | C-D/2-3 | 471-C-B165 | 80
Steel Assembly | RIGID_FRAME | 26.7 | +17.850 | +18.050 | C-D/2-3 | 471-C-B89 | 349.996
Steel Assembly | RIGID_FRAME | 46.6 | +17.850 | +18.050 | C-D/2-3 | 471-C-B113 | 345.692
Steel Assembly | RIGID_FRAME | 27.9 | +17.850 | +18.050 | C-D/2-3 | 471-C-B86 | 453.536
Steel Assembly | RIGID_FRAME | 28.1 | +17.850 | +18.050 | C-D/2-3 | 471-C-B84 | 465.643
Steel Assembly | RIGID_FRAME | 27.9 | +17.850 | +18.050 | C-D/2-3 | 471-C-B87 | 446.565
Steel Assembly | RIGID_FRAME | 44.5 | +17.850 | +18.050 | C-D/2-3 | 471-C-B90 | 243.318
Steel Assembly | RIGID_FRAME | 27.9 | +17.850 | +18.050 | C-D/2-3 | 471-C-B83 | 447.622
4 x Steel Assembly | RIGID_FRAME | 16.3 | +17.863 | +17.943 | C-D/2-3 | 471-C-B170 | 80
Steel Assembly | RIGID_FRAME | 17.1 | +17.863 | +17.943 | C-D/2-3 | 471-C-B173 | 80
Steel Assembly | RIGID_FRAME | 17.5 | +17.863 | +17.943 | C-D/2-3 | 471-C-B172 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +17.863 | +17.943 | C-D/2-3 | 471-C-B169 | 80
Steel Assembly | RIGID_FRAME | 17.1 | +17.863 | +17.943 | C-D/2-3 | 471-C-B168 | 80
2 x Steel Assembly | RIGID_FRAME | 17.6 | +17.863 | +17.943 | C-D/2-3 | 471-C-B167 | 80
Steel Assembly | RIGID_FRAME | 17.6 | +17.863 | +17.943 | C-D/2-3 | 471-C-B166 | 80
7 x Steel Assembly | RIGID_FRAME | 102.7 | +12.300 | +12.500 | A-B/1-2 | 471-D-C212 | 160
Steel Assembly | RIGID_FRAME | 102.7 | +5.500 | +5.700 | A-B/1-2 | 471-D-C259 | 160
Steel Assembly | RIGID_FRAME | 343.9 | +2.394 | +2.756 | B-C/4 | 471-D-C125 | 196.75
Steel Assembly | RIGID_FRAME | 352.2 | +2.394 | +2.750 | B-C/3 | 471-D-C124 | 203.5
Steel Assembly | RIGID_FRAME | 4.2 | +21.500 | +21.600 | B-C/2-3 | 471-0-010034 | 6
Steel Assembly | RIGID_FRAME | 2.1 | +22.105 | +22.155 | B-C/2-3 | 471-0-010033 | 6
Steel Assembly | RIGID_FRAME | 3.3 | +22.565 | +22.590 | B-C/2-3 | 471-0-010030 | 25
Steel Assembly | RIGID_FRAME | 13.1 | +17.863 | +17.943 | C-D/1-2 | 471-C-B155 | 80
Steel Assembly | RIGID_FRAME | 28.1 | +17.850 | +18.050 | C-D/1-2 | 471-C-B107 | 399.223
Steel Assembly | RIGID_FRAME | 11.1 | +17.863 | +17.943 | C-D/1-2 | 471-C-B154 | 80
Steel Assembly | RIGID_FRAME | 13 | +17.863 | +17.943 | C-D/1-2 | 471-C-B163 | 80
Steel Assembly | RIGID_FRAME | 28.3 | +17.850 | +18.050 | C-D/1-2 | 471-C-B108 | 423.144
Steel Assembly | RIGID_FRAME | 11 | +17.863 | +17.943 | C-D/1-2 | 471-C-B153 | 80
Steel Assembly | RIGID_FRAME | 27.9 | +17.850 | +18.050 | C-D/1-2 | 471-C-B109 | 374.295
2 x Steel Assembly | RIGID_FRAME | 64.7 | +17.850 | +18.050 | D-E/1-2 | 471-C-B126 | 160
Steel Assembly | RIGID_FRAME | 93.8 | +15.500 | +15.700 | B-C/3-4 | 471-D-C255 | 160
Steel Assembly | RIGID_FRAME | 62.2 | +15.500 | +15.700 | B-C/3-4 | 471-D-C202 | 160
Steel Assembly | RIGID_FRAME | 17 | +15.513 | +15.593 | C-D/2-3 | 471-C-B149 | 80
3 x Steel Assembly | RIGID_FRAME | 46.7 | +15.500 | +15.700 | C-D/2-3 | 471-C-B128 | 335.616
5 x Steel Assembly | RIGID_FRAME | 16.8 | +15.513 | +15.593 | C-D/2-3 | 471-C-B148 | 80
Steel Assembly | RIGID_FRAME | 15.8 | +15.513 | +15.593 | C-D/2-3 | 471-C-B147 | 80
Steel Assembly | RIGID_FRAME | 46.8 | +15.500 | +15.700 | C-D/2-3 | 471-C-B130 | 327.562
2 x Steel Assembly | RIGID_FRAME | 46.7 | +15.500 | +15.700 | C-D/2-3 | 471-C-B129 | 335.616
Steel Assembly | RIGID_FRAME | 149.7 | +15.500 | +15.700 | B-C/1-2 | 471-D-C171 | 160
Steel Assembly | RIGID_FRAME | 274.3 | +10.146 | +10.339 | C-D/1-2 | 471-B-A204 | 210
2 x Steel Assembly | RIGID_FRAME | 387.8 | +0.194 | +5.313 | C/2-3 | 471-B-A252 | 273.1
2 x Steel Assembly | RIGID_FRAME | 354.8 | +5.725 | +10.144 | C/2-3 | 471-B-A251 | 273.1
Steel Assembly | RIGID_FRAME | 343.6 | +10.615 | +15.319 | C/2-3 | 471-C-B256 | 219.1
Steel Assembly | RIGID_FRAME | 219 | +21.485 | +23.927 | C/2-3 | 471-C-B249 | 219.1
Steel Assembly | RIGID_FRAME | 210 | +21.462 | +23.960 | C/2-3 | 471-C-B277 | 254
2 x Steel Assembly | RIGID_FRAME | 255 | +5.750 | +10.204 | A-B/1 | 471-D-C429 | 219.1
Steel Assembly | RIGID_FRAME | 284.5 | +21.485 | +23.937 | D/2-3 | 471-C-B260 | 219.1
Steel Assembly | RIGID_FRAME | 334.3 | +24.343 | +28.699 | D/2-3 | 471-E-D186 | 219.1
Steel Assembly | RIGID_FRAME | 299.2 | +18.075 | +21.079 | D/2-3 | 471-C-B266 | 219.1
2 x Steel Assembly | RIGID_FRAME | 235.2 | +5.725 | +10.159 | D/2-3 | 471-B-A231 | 219.1
2 x Steel Assembly | RIGID_FRAME | 260.6 | +0.175 | +5.319 | D/2-3 | 471-B-A230 | 219.1
Steel Assembly | RIGID_FRAME | 343.6 | +10.615 | +15.319 | D/2-3 | 471-C-B256 | 219.1
Steel Assembly | RIGID_FRAME | 422.7 | +14.992 | +16.035 | D/2-3 | 471-C-B64 | 190
Steel Assembly | RIGID_FRAME | 221.5 | +10.234 | +10.590 | D/3-4 | 471-B-A28 | 190
Steel Assembly | RIGID_FRAME | 241.9 | +10.234 | +10.590 | D/1-2 | 471-B-A25 | 190
Steel Assembly | RIGID_FRAME | 241.9 | +15.344 | +15.700 | D/1-2 | 471-C-B37 | 190
Steel Assembly | RIGID_FRAME | 241.9 | +5.344 | +5.700 | D/1-2 | 471-B-A30 | 190
2 x Steel Assembly | RIGID_FRAME | 15.8 | +10.403 | +10.483 | C-D/2-3 | 471-B-A148 | 80
Steel Assembly | RIGID_FRAME | 46.8 | +10.390 | +10.590 | C-D/2-3 | 471-B-A105 | 337.988
Steel Assembly | RIGID_FRAME | 47 | +10.390 | +10.590 | C-D/2-3 | 471-B-A110 | 327.903
Steel Assembly | RIGID_FRAME | 46.8 | +10.390 | +10.590 | C-D/2-3 | 471-B-A106 | 337.988
Steel Assembly | RIGID_FRAME | 129.1 | +10.390 | +10.590 | C-D/2-3 | 471-B-A92 | 160
Steel Assembly | RIGID_FRAME | 47.3 | +10.390 | +10.590 | C-D/2-3 | 471-B-A114 | 317.706
Steel Assembly | RIGID_FRAME | 47.3 | +10.390 | +10.590 | C-D/2-3 | 471-B-A115 | 317.706
Steel Assembly | RIGID_FRAME | 47.2 | +10.390 | +10.590 | C-D/2-3 | 471-B-A113 | 319.723
Steel Assembly | RIGID_FRAME | 27.9 | +10.390 | +10.590 | C-D/2-3 | 471-B-A97 | 453.536
Steel Assembly | RIGID_FRAME | 28.1 | +10.390 | +10.590 | C-D/2-3 | 471-B-A99 | 465.643
Steel Assembly | RIGID_FRAME | 27.9 | +10.390 | +10.590 | C-D/2-3 | 471-B-A98 | 447.622
Steel Assembly | RIGID_FRAME | 28.3 | +10.390 | +10.590 | C-D/2-3 | 471-B-A123 | 472.715
Steel Assembly | RIGID_FRAME | 88.4 | +10.390 | +10.590 | C-D/2-3 | 471-B-A95 | 292.047
Steel Assembly | RIGID_FRAME | 46.7 | +10.390 | +10.590 | C-D/2-3 | 471-B-A111 | 346.838
Steel Assembly | RIGID_FRAME | 46.6 | +10.390 | +10.590 | C-D/2-3 | 471-B-A109 | 345.692
Steel Assembly | RIGID_FRAME | 27.9 | +10.390 | +10.590 | C-D/2-3 | 471-B-A100 | 446.565
Steel Assembly | RIGID_FRAME | 47.2 | +5.500 | +5.700 | C-D/2-3 | 471-B-A112 | 319.723
