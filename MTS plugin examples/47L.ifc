Properties of the parts of a building model (IFC2X3), part 6 of 22

# IfcDiscreteAccessory: END PLATE (3408)
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x END PLATE | FL10*70 | +58.020 | +58.030 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
END PLATE | PLT12*94 | +21.116 | +21.448 | 4 | 8 | 2.9 | 0 | 24.8 | 0.1 | 94 | 12 | 331.6 | pb-53 | 0.0725552 | 0.0725552 | 0.001128 | 0.000374045 | 0.000374045
4 x END PLATE | PLT12*94 | +21.166 | +21.454 | 4 | 8 | 2.6 | 0 | 24.8 | 0.1 | 94 | 12 | 288 | pb-51 | 0.063312 | 0.063312 | 0.001128 | 0.000324864 | 0.000324864
2 x END PLATE | FL10*70 | +68.450 | +68.460 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | PLT16*220 | +21.110 | +21.454 | 5 | 8 | 9.5 | 0 | 17.8 | 0.2 | 220 | 16 | 343.6 | pc-373 | 0.169219 | 0.169219 | 0.00352 | 0.00120947 | 0.00120947
3 x END PLATE | PLT20*190 | +5.350 | +5.694 | 5 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-57 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +21.110 | +21.775 | 5 | 8 | 19.7 | 0 | 14.4 | 0.3 | 190 | 20 | 664.6 | pc-53 | 0.286732 | 0.286732 | 0.0038 | 0.00252548 | 0.00252548
END PLATE | PLT20*190 | +28.524 | +29.074 | 6 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pd-15 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +21.110 | +21.454 | 5 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-51 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +23.762 | +24.312 | 5 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-50 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
4 x END PLATE | PLT12*74 | +5.606 | +5.680 | 5 | 8 | 1 | 0 | 26.5 | 0 | 74 | 12 | 140 | pc-103 | 0.025856 | 0.025856 | 0.00168 | 0.00012432 | 0.00012432
2 x END PLATE | PLT16*160 | +5.350 | +5.694 | 5 | 99 | 6.8 | 0 | 18.3 | 0.1 | 159.9 | 16 | 343.6 | pc-375 | 0.126067 | 0.126067 | 0.00256 | 0.000879616 | 0.000879616
2 x END PLATE | PLT16*160 | +5.370 | +5.694 | 5 | 99 | 6.5 | 0 | 18.3 | 0.1 | 159.9 | 16 | 324 | pc-374 | 0.119168 | 0.119168 | 0.00256 | 0.00082944 | 0.00082944
2 x END PLATE | FL12*150 | +5.520 | +5.670 | 5 | 8 | 1.9 | 0 | 24.8 | 0 | 140 | 12 | 140 | pc-117 | 0.04896 | 0.04896 | 0.00168 | 0.000252 | 0.000252
2 x END PLATE | PLT12*74 | +12.406 | +12.480 | 5 | 8 | 1 | 0 | 26.5 | 0 | 74 | 12 | 140 | pc-103 | 0.025856 | 0.025856 | 0.00168 | 0.00012432 | 0.00012432
END PLATE | PLT16*160 | +12.150 | +12.494 | 5 | 99 | 6.8 | 0 | 18.3 | 0.1 | 159.9 | 16 | 344 | pc-375 | 0.126208 | 0.126208 | 0.00256 | 0.00088064 | 0.00088064
2 x END PLATE | FL12*150 | +12.320 | +12.470 | 5 | 8 | 1.9 | 0 | 24.8 | 0 | 140 | 12 | 140 | pc-117 | 0.04896 | 0.04896 | 0.00168 | 0.000252 | 0.000252
END PLATE | PLT16*160 | +12.170 | +12.494 | 5 | 99 | 6.5 | 0 | 18.3 | 0.1 | 159.9 | 16 | 324 | pc-374 | 0.119168 | 0.119168 | 0.00256 | 0.00082944 | 0.00082944
36 x END PLATE | PLT12*160 | +12.306 | +12.470 | 5 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pc-114 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
END PLATE | PLT20*190 | +12.150 | +12.494 | 5 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-45 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +5.350 | +5.900 | 5 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-35 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
8 x END PLATE | PLT12*160 | +15.346 | +15.358 | 5 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pc-107 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
END PLATE | PLT12*164 | +15.506 | +15.670 | 5 | 99 | 2.7 | 0 | 24.3 | 0.1 | 164 | 12 | 175 | pc-109 | 0.065536 | 0.065536 | 0.0021 | 0.0003444 | 0.0003444
END PLATE | FL12*180 | +15.506 | +15.670 | 5 | 99 | 2.8 | 0 | 24.3 | 0.1 | 164 | 12 | 164 | pc-110 | 0.067296 | 0.067296 | 0.00216 | 0.00035424 | 0.00035424
2 x END PLATE | PLT12*152.2 | +5.503 | +5.655 | 5 | 8 | 2.3 | 0 | 24.4 | 0.1 | 152.2 | 12 | 160 | pc-111 | 0.0561968 | 0.0561968 | 0.00192 | 0.000292224 | 0.000292224
4 x END PLATE | PLT10*140 | +7.956 | +8.144 | 5 | 8 | 2.1 | 0 | 28.7 | 0.1 | 140 | 10 | 188 | pc-143 | 0.0592 | 0.0592 | 0.0014 | 0.0002632 | 0.0002632
4 x END PLATE | PLT10*104 | +7.956 | +8.144 | 5 | 8 | 1.5 | 0 | 29.2 | 0 | 104 | 10 | 188 | pc-142 | 0.044944 | 0.044944 | 0.00104 | 0.00019552 | 0.00019552
2 x END PLATE | PLT12*160 | +5.700 | +5.712 | 5 | 8 | 4 | 0 | 23.8 | 0.1 | 159.9 | 12 | 265 | pc-112 | 0.095 | 0.095 | 0.00192 | 0.0005088 | 0.0005088
2 x END PLATE | FL12*200 | +5.700 | +5.712 | 5 | 8 | 2.9 | 0 | 24.1 | 0.1 | 159.9 | 12 | 160 | pc-113 | 0.07264 | 0.07264 | 0.00192 | 0.000384 | 0.000384
32 x END PLATE | FL16*200 | +5.350 | +5.694 | 5 | 8 | 8.5 | 0 | 17.9 | 0.2 | 200 | 16 | 343.6 | pc-370 | 0.154835 | 0.154835 | 0.0032 | 0.00109952 | 0.00109952
3 x END PLATE | FL12*150 | +5.720 | +5.870 | 5 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pc-115 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
2 x END PLATE | FL12*200 | +56.588 | +56.600 | 8 | 8 | 3.4 | 0 | 24 | 0.1 | 200 | 12 | 219.9 | pf-33 | 0.0813096 | 0.09808 | 0.00264 | 0.00043425 | 0.000528
3 x END PLATE | FL12*150 | +55.305 | +55.317 | 8 | 8 | 2.7 | 0 | 24.3 | 0.1 | 149.9 | 12 | 188 | pf-52 | 0.064512 | 0.064512 | 0.0018 | 0.0003384 | 0.0003384
3 x END PLATE | FL12*150 | +55.307 | +55.319 | 8 | 8 | 2.7 | 0 | 24.3 | 0.1 | 149.9 | 12 | 188 | pf-32 | 0.064512 | 0.064512 | 0.0018 | 0.0003384 | 0.0003384
2 x END PLATE | PLT12*78 | +56.696 | +56.774 | 8 | 8 | 1.5 | 0 | 25.8 | 0 | 78 | 12 | 190 | pf-41 | 0.036072 | 0.036072 | 0.00228 | 0.00017784 | 0.00017784
2 x END PLATE | FL12*200 | +56.588 | +56.600 | 8 | 8 | 2.9 | 0 | 24.1 | 0.1 | 200 | 12 | 200 | pf-31 | 0.0730578 | 0.0896 | 0.0024 | 0.000386025 | 0.00048
END PLATE | FL12*200 | +56.588 | +56.600 | 8 | 8 | 2.9 | 0 | 24.1 | 0.1 | 200 | 12 | 200 | pf-30 | 0.0730578 | 0.0896 | 0.0024 | 0.000386025 | 0.00048
END PLATE | FL12*200 | +56.588 | +56.600 | 8 | 8 | 2.9 | 0 | 24.1 | 0.1 | 200 | 12 | 200 | pf-29 | 0.0730578 | 0.0896 | 0.0024 | 0.000386025 | 0.00048
2 x END PLATE | PLT12*78 | +37.996 | +38.074 | 7 | 8 | 1.5 | 0 | 25.8 | 0 | 78 | 12 | 190 | pe-50 | 0.036072 | 0.036072 | 0.00228 | 0.00017784 | 0.00017784
2 x END PLATE | FL12*150 | +36.272 | +36.284 | 7 | 8 | 2.7 | 0 | 24.3 | 0.1 | 149.9 | 12 | 188 | pe-61 | 0.064512 | 0.064512 | 0.0018 | 0.0003384 | 0.0003384
4 x END PLATE | FL12*200 | +37.888 | +37.900 | 7 | 8 | 2.9 | 0 | 24.1 | 0.1 | 200 | 12 | 200 | pe-35 | 0.0730578 | 0.0896 | 0.0024 | 0.000386025 | 0.00048
2 x END PLATE | FL12*150 | +36.272 | +36.284 | 7 | 8 | 2.7 | 0 | 24.3 | 0.1 | 149.9 | 12 | 188 | pe-34 | 0.064512 | 0.064512 | 0.0018 | 0.0003384 | 0.0003384
5 x END PLATE | FL16*200 | +12.144 | +12.494 | 5 | 8 | 8.8 | 0 | 17.9 | 0.2 | 200 | 16 | 349.6 | pc-230 | 0.157439 | 0.157439 | 0.0032 | 0.00111881 | 0.00111881
END PLATE | FL16*200 | +12.144 | +12.494 | 5 | 8 | 8.8 | 0 | 17.9 | 0.2 | 200 | 16 | 349.6 | pc-369 | 0.157439 | 0.157439 | 0.0032 | 0.00111881 | 0.00111881
16 x END PLATE | FL20*180 | +12.150 | +12.494 | 5 | 8 | 9.7 | 0 | 14.8 | 0.1 | 180 | 20 | 343.6 | pc-38 | 0.14464 | 0.14464 | 0.0036 | 0.00123696 | 0.00123696
2 x END PLATE | PLT20*190 | +12.144 | +12.494 | 5 | 8 | 10.5 | 0 | 14.8 | 0.2 | 190 | 20 | 349.6 | pc-43 | 0.154432 | 0.154432 | 0.0038 | 0.00132848 | 0.00132848
9 x END PLATE | FL20*180 | +12.144 | +12.494 | 5 | 8 | 9.9 | 0 | 14.8 | 0.1 | 180 | 20 | 349.6 | pc-42 | 0.14704 | 0.14704 | 0.0036 | 0.00125856 | 0.00125856
END PLATE | FL20*180 | +12.150 | +12.494 | 5 | 8 | 9.7 | 0 | 14.8 | 0.1 | 180 | 20 | 343.6 | pc-44 | 0.14464 | 0.14464 | 0.0036 | 0.00123696 | 0.00123696
END PLATE | PLT16*330 | +12.144 | +12.494 | 5 | 8 | 14.4 | 0 | 17.5 | 0.3 | 330 | 16 | 349.6 | pc-237 | 0.252502 | 0.252502 | 0.00528 | 0.00184603 | 0.00184603
4 x END PLATE | PLT12*160 | +60.541 | +60.705 | 8 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pf-44 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
17 x END PLATE | PLT12*160 | +70.456 | +70.620 | 8 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pf-44 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
END PLATE | FL12*150 | +70.470 | +70.620 | 8 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pf-45 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
4 x END PLATE | PLT12*160 | +68.256 | +68.420 | 8 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pf-44 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
24 x END PLATE | PLT12*160 | +66.056 | +66.220 | 8 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pf-44 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
END PLATE | FL12*150 | +66.070 | +66.220 | 8 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pf-45 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
3 x END PLATE | PLT16*238 | +14.850 | +15.300 | 5 | 8 | 13.5 | 0 | 17.7 | 0.2 | 238 | 16 | 450 | pc-409 | 0.236216 | 0.236216 | 0.003808 | 0.0017136 | 0.0017136
END PLATE | PLT16*238 | +14.850 | +15.450 | 5 | 8 | 18 | 0 | 17.5 | 0.3 | 238 | 16 | 600 | pc-412 | 0.312416 | 0.312416 | 0.003808 | 0.0022848 | 0.0022848
END PLATE | PLT16*238 | +14.850 | +15.400 | 5 | 8 | 16.4 | 0 | 17.5 | 0.3 | 238 | 16 | 550 | pc-411 | 0.287016 | 0.287016 | 0.003808 | 0.0020944 | 0.0020944
END PLATE | PLT16*238 | +14.750 | +15.300 | 5 | 8 | 16.4 | 0 | 17.5 | 0.3 | 238 | 16 | 550 | pc-411 | 0.287016 | 0.287016 | 0.003808 | 0.0020944 | 0.0020944
2 x END PLATE | PLT16*238 | +18.250 | +18.700 | 5 | 8 | 13.5 | 0 | 17.7 | 0.2 | 238 | 16 | 450 | pc-409 | 0.236216 | 0.236216 | 0.003808 | 0.0017136 | 0.0017136
END PLATE | PLT20*190 | +11.944 | +12.494 | 5 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-22 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +12.150 | +12.700 | 5 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-21 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
3 x END PLATE | PLT20*190 | +11.944 | +12.494 | 5 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-20 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +12.150 | +12.700 | 5 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-19 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
5 x END PLATE | PLT20*190 | +12.150 | +12.494 | 5 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-36 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +11.944 | +12.700 | 5 | 99 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pc-14 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
4 x END PLATE | PLT20*190 | +12.150 | +12.494 | 5 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-36 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +12.150 | +12.700 | 5 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-19 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
3 x END PLATE | PLT20*190 | +19.122 | +19.466 | 5 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-41 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
4 x END PLATE | PLT12*160 | +57.826 | +57.990 | 8 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pf-44 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
4 x END PLATE | PLT12*160 | +52.846 | +53.010 | 8 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pf-44 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
3 x END PLATE | FL12*150 | +57.840 | +57.990 | 8 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pf-46 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
END PLATE | FL12*150 | +57.840 | +57.990 | 8 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pf-58 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
2 x END PLATE | PLT20*190 | +16.894 | +17.444 | 5 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-34 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
2 x END PLATE | PLT20*190 | +17.100 | +17.444 | 5 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-58 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
2 x END PLATE | PLT20*190 | +17.100 | +17.444 | 5 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-58 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*210 | +19.016 | +19.572 | 5 | 8 | 18.3 | 0 | 14.4 | 0.3 | 210 | 20 | 556 | pc-13 | 0.26416 | 0.26416 | 0.0042 | 0.0023352 | 0.0023352
16 x END PLATE | PLT12*160 | +55.111 | +55.275 | 8 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pf-44 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
END PLATE | PLT20*190 | +18.866 | +19.466 | 5 | 99 | 18 | 0 | 14.4 | 0.3 | 190 | 20 | 599.6 | pc-18 | 0.259432 | 0.259432 | 0.0038 | 0.00227848 | 0.00227848
END PLATE | PLT20*190 | +18.886 | +19.466 | 5 | 99 | 17.3 | 0 | 14.4 | 0.3 | 190 | 20 | 579.6 | pc-17 | 0.251032 | 0.251032 | 0.0038 | 0.00220248 | 0.00220248
3 x END PLATE | PLT20*190 | +15.350 | +15.694 | 5 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-11 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +15.114 | +15.920 | 5 | 99 | 23.9 | 0 | 14.4 | 0.3 | 190 | 20 | 805.6 | pc-9 | 0.345952 | 0.345952 | 0.0038 | 0.00306128 | 0.00306128
END PLATE | PLT20*210 | +15.350 | +15.694 | 5 | 8 | 11.3 | 0 | 14.8 | 0.2 | 210 | 20 | 343.6 | pc-40 | 0.166456 | 0.166456 | 0.0042 | 0.00144312 | 0.00144312
3 x END PLATE | PLT20*190 | +15.350 | +15.694 | 5 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-57 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
3 x END PLATE | FL12*150 | +52.860 | +53.010 | 8 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pf-46 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
END PLATE | FL12*150 | +52.860 | +53.010 | 8 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pf-58 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
2 x END PLATE | FL10*70 | +51.153 | +51.163 | 8 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pf-67 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
4 x END PLATE | PLT12*160 | +50.959 | +51.123 | 8 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pf-44 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
2 x END PLATE | FL10*70 | +47.013 | +47.023 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
4 x END PLATE | PLT12*160 | +46.819 | +46.983 | 7 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pe-53 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
17 x END PLATE | PLT12*160 | +44.381 | +44.545 | 7 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pe-53 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
2 x END PLATE | FL10*70 | +41.806 | +41.816 | 7 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pe-69 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
4 x END PLATE | PLT12*160 | +41.612 | +41.776 | 7 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pe-53 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
5 x END PLATE | PLT12*160 | +38.844 | +39.008 | 7 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pe-53 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
4 x END PLATE | FL20*180 | +65.900 | +66.244 | 8 | 99 | 9.7 | 0 | 14.8 | 0.1 | 180 | 20 | 344 | pf-23 | 0.1448 | 0.1448 | 0.0036 | 0.0012384 | 0.0012384
4 x END PLATE | FL20*180 | +70.300 | +70.644 | 8 | 99 | 9.7 | 0 | 14.8 | 0.1 | 180 | 20 | 344 | pf-23 | 0.1448 | 0.1448 | 0.0036 | 0.0012384 | 0.0012384
4 x END PLATE | FL20*180 | +63.100 | +63.444 | 8 | 99 | 9.7 | 0 | 14.8 | 0.1 | 180 | 20 | 344 | pf-23 | 0.1448 | 0.1448 | 0.0036 | 0.0012384 | 0.0012384
4 x END PLATE | FL20*180 | +54.955 | +55.299 | 8 | 99 | 9.7 | 0 | 14.8 | 0.1 | 180 | 20 | 344 | pf-23 | 0.1448 | 0.1448 | 0.0036 | 0.0012384 | 0.0012384
4 x END PLATE | FL20*180 | +48.350 | +48.694 | 7 | 99 | 9.7 | 0 | 14.8 | 0.1 | 180 | 20 | 344 | pe-29 | 0.1448 | 0.1448 | 0.0036 | 0.0012384 | 0.0012384
4 x END PLATE | FL20*180 | +44.225 | +44.569 | 7 | 99 | 9.7 | 0 | 14.8 | 0.1 | 180 | 20 | 344 | pe-29 | 0.1448 | 0.1448 | 0.0036 | 0.0012384 | 0.0012384
4 x END PLATE | FL20*180 | +35.920 | +36.264 | 6 | 99 | 9.7 | 0 | 14.8 | 0.1 | 180 | 20 | 344 | pd-19 | 0.1448 | 0.1448 | 0.0036 | 0.0012384 | 0.0012384
4 x END PLATE | FL20*180 | +28.730 | +29.074 | 6 | 99 | 9.7 | 0 | 14.8 | 0.1 | 180 | 20 | 344 | pd-19 | 0.1448 | 0.1448 | 0.0036 | 0.0012384 | 0.0012384
5 x END PLATE | PLT20*190 | +44.225 | +44.569 | 7 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pe-27 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
19 x END PLATE | PLT12*160 | +36.076 | +36.240 | 6 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pd-33 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
2 x END PLATE | FL10*70 | +33.999 | +34.009 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
4 x END PLATE | PLT12*160 | +33.805 | +33.969 | 6 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pd-33 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
4 x END PLATE | PLT12*160 | +31.534 | +31.698 | 6 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pd-33 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
2 x END PLATE | PLT20*190 | +47.011 | +47.355 | 7 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pe-27 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | FL16*200 | +36.271 | +36.287 | 7 | 8 | 6.1 | 0 | 18.1 | 0.1 | 200 | 16 | 242.2 | pe-191 | 0.11103 | 0.11103 | 0.0032 | 0.00077504 | 0.00077504
2 x END PLATE | FL16*200 | +38.665 | +38.681 | 7 | 8 | 12.1 | 0.1 | 17.7 | 0.2 | 200 | 16 | 482.7 | pe-164 | 0.214926 | 0.214926 | 0.0032 | 0.00154464 | 0.00154464
17 x END PLATE | PLT12*160 | +28.886 | +29.050 | 6 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pd-33 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
END PLATE | FL16*200 | +55.306 | +55.322 | 8 | 8 | 6.1 | 0 | 18.1 | 0.1 | 200 | 16 | 242.2 | pf-199 | 0.11103 | 0.11103 | 0.0032 | 0.00077504 | 0.00077504
END PLATE | FL16*200 | +57.647 | +57.663 | 8 | 8 | 12.1 | 0.1 | 17.7 | 0.2 | 200 | 16 | 482.7 | pf-226 | 0.214926 | 0.214926 | 0.0032 | 0.00154464 | 0.00154464
2 x END PLATE | FL16*200 | +29.081 | +29.097 | 6 | 8 | 6.1 | 0 | 18.1 | 0.1 | 200 | 16 | 242.2 | pd-126 | 0.11103 | 0.11103 | 0.0032 | 0.00077504 | 0.00077504
2 x END PLATE | FL16*200 | +31.355 | +31.371 | 6 | 8 | 12.1 | 0.1 | 17.7 | 0.2 | 200 | 16 | 482.7 | pd-161 | 0.214926 | 0.214926 | 0.0032 | 0.00154464 | 0.00154464
2 x END PLATE | FL10*70 | +26.415 | +26.425 | 6 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pd-51 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL16*200 | +63.451 | +63.467 | 8 | 8 | 6.1 | 0 | 18.1 | 0.1 | 200 | 16 | 242.2 | pf-199 | 0.11103 | 0.11103 | 0.0032 | 0.00077504 | 0.00077504
2 x END PLATE | FL16*200 | +65.877 | +65.893 | 8 | 8 | 12.1 | 0.1 | 17.7 | 0.2 | 200 | 16 | 482.7 | pf-226 | 0.214926 | 0.214926 | 0.0032 | 0.00154464 | 0.00154464
4 x END PLATE | PLT12*160 | +26.221 | +26.385 | 6 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pd-33 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
END PLATE | PLT20*190 | +28.524 | +29.280 | 6 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pd-13 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
2 x END PLATE | PLT20*190 | +70.094 | +70.644 | 8 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-10 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
2 x END PLATE | PLT20*190 | +63.100 | +63.650 | 8 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-9 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
2 x END PLATE | FL12*180 | +68.522 | +68.822 | 8 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pf-51 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | FL12*180 | +70.280 | +70.292 | 8 | 8 | 5.1 | 0.1 | 23.5 | 0.1 | 180 | 12 | 300 | pf-48 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
14 x END PLATE | PLT12*160 | +70.456 | +70.620 | 8 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pf-44 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
2 x END PLATE | PLT12*145 | +70.475 | +70.620 | 8 | 8 | 2.2 | 0 | 24.6 | 0.1 | 145 | 12 | 160 | pf-49 | 0.05372 | 0.05372 | 0.00192 | 0.0002784 | 0.0002784
2 x END PLATE | FL12*150 | +70.470 | +70.620 | 8 | 99 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pf-46 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
END PLATE | PLT12*160 | +64.268 | +64.568 | 8 | 8 | 4.5 | 0 | 23.8 | 0.1 | 159.9 | 12 | 300 | pf-47 | 0.107041 | 0.107041 | 0.00192 | 0.000576005 | 0.000576005
END PLATE | FL12*180 | +65.880 | +65.892 | 8 | 8 | 5.1 | 0.1 | 23.5 | 0.1 | 180 | 12 | 300 | pf-48 | 0.11952 | 0.11952 | 0.00216 | 0.000648001 | 0.000648001
END PLATE | PLT20*190 | +54.955 | +55.505 | 8 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-7 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +48.350 | +48.900 | 7 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pe-21 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +54.955 | +55.299 | 8 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pf-19 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +54.749 | +55.299 | 8 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-5 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
2 x END PLATE | PLT20*190 | +44.225 | +44.775 | 7 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pe-13 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +48.350 | +48.694 | 7 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pe-9 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +48.144 | +48.694 | 7 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pe-20 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +62.894 | +63.444 | 8 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-10 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +44.019 | +44.569 | 7 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pe-15 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +35.714 | +36.264 | 6 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pd-8 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +35.920 | +36.470 | 6 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pd-7 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +35.714 | +36.470 | 6 | 99 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pd-11 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
2 x END PLATE | PLT16*160 | +65.924 | +66.220 | 8 | 8 | 5.9 | 0 | 18.4 | 0.1 | 159.9 | 16 | 295.6 | pf-258 | 0.109171 | 0.109171 | 0.00256 | 0.000756736 | 0.000756736
32 x END PLATE | FL12*150 | +66.070 | +66.220 | 8 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pf-46 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
7 x END PLATE | PLT12*160 | +66.056 | +66.220 | 8 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pf-44 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
END PLATE | PLT20*190 | +54.955 | +55.299 | 8 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pf-18 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +54.719 | +55.525 | 8 | 99 | 23.9 | 0 | 14.4 | 0.3 | 190 | 20 | 805.6 | pf-4 | 0.345952 | 0.345952 | 0.0038 | 0.00306128 | 0.00306128
END PLATE | PLT20*190 | +48.350 | +48.694 | 7 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pe-7 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +48.144 | +48.694 | 7 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pe-19 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +48.350 | +48.920 | 7 | 99 | 17 | 0 | 14.4 | 0.2 | 190 | 20 | 569.6 | pe-18 | 0.246832 | 0.246832 | 0.0038 | 0.00216448 | 0.00216448
END PLATE | PLT20*190 | +44.019 | +44.569 | 7 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pe-14 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
2 x END PLATE | PLT20*190 | +31.378 | +31.928 | 6 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pd-6 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
5 x END PLATE | PLT20*190 | +31.378 | +31.722 | 6 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pd-16 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
4 x END PLATE | PLT20*190 | +38.688 | +39.032 | 7 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pe-27 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
2 x END PLATE | PLT20*190 | +38.688 | +39.238 | 7 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pe-13 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
2 x END PLATE | PLT20*190 | +52.484 | +53.240 | 8 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pf-17 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
7 x END PLATE | PLT20*190 | +52.690 | +53.034 | 8 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pf-21 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
4 x END PLATE | PLT20*190 | +57.670 | +58.220 | 8 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-9 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
5 x END PLATE | PLT20*190 | +57.670 | +58.014 | 8 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pf-21 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
5 x END PLATE | PLT20*190 | +65.900 | +66.244 | 8 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pf-21 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
4 x END PLATE | PLT20*190 | +65.900 | +66.450 | 8 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-9 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
2 x END PLATE | FL12*150 | +66.070 | +66.220 | 8 | 99 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pf-46 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
END PLATE | PLT20*190 | +62.894 | +63.444 | 8 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-13 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
7 x END PLATE | PLT20*190 | +70.300 | +70.644 | 8 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pf-21 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +70.094 | +70.644 | 8 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-12 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +65.694 | +66.450 | 8 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pf-16 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +62.894 | +63.444 | 8 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-12 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +63.100 | +63.650 | 8 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-11 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +57.464 | +58.220 | 8 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pf-16 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +52.484 | +53.240 | 8 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pf-16 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +44.225 | +44.775 | 7 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pe-12 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +44.019 | +44.569 | 7 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pe-11 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +38.482 | +39.238 | 7 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pe-6 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +35.714 | +36.264 | 6 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pd-5 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +35.920 | +36.470 | 6 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pd-4 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +31.172 | +31.928 | 6 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pd-13 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +54.749 | +55.299 | 8 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-6 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +54.955 | +55.505 | 8 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-1 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +48.350 | +48.900 | 7 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pe-3 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +48.144 | +48.694 | 7 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pe-17 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
2 x END PLATE | FL12*180 | +61.322 | +61.622 | 8 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pf-51 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | FL12*180 | +63.080 | +63.092 | 8 | 8 | 5.1 | 0.1 | 23.5 | 0.1 | 180 | 12 | 300 | pf-48 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | PLT12*145 | +63.275 | +63.420 | 8 | 8 | 2.2 | 0 | 24.6 | 0.1 | 145 | 12 | 160 | pf-49 | 0.05372 | 0.05372 | 0.00192 | 0.0002784 | 0.0002784
2 x END PLATE | PLT12*160 | +55.108 | +55.275 | 8 | 8 | 2.5 | 0 | 24.3 | 0.1 | 159.9 | 12 | 167.2 | pf-55 | 0.0613568 | 0.0613568 | 0.00192 | 0.000321024 | 0.000321024
8 x END PLATE | FL12*150 | +55.125 | +55.275 | 8 | 99 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pf-46 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
28 x END PLATE | FL12*150 | +55.125 | +55.275 | 8 | 8 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pf-46 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
END PLATE | PLT20*190 | +65.900 | +66.244 | 8 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pf-20 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +65.694 | +66.450 | 8 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pf-15 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
2 x END PLATE | PLT20*190 | +70.094 | +70.644 | 8 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-10 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +65.900 | +66.244 | 8 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pf-22 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
3 x END PLATE | PLT20*190 | +65.694 | +66.450 | 8 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pf-14 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
6 x END PLATE | PLT20*190 | +63.100 | +63.444 | 8 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pf-21 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +62.894 | +63.650 | 8 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pf-15 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
4 x END PLATE | PLT20*190 | +57.464 | +58.220 | 8 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pf-14 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
2 x END PLATE | PLT20*190 | +52.690 | +53.240 | 8 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-9 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
2 x END PLATE | PLT20*190 | +52.484 | +53.240 | 8 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pf-14 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +44.225 | +44.569 | 7 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pe-28 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
2 x END PLATE | PLT20*190 | +44.019 | +44.775 | 7 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pe-4 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
2 x END PLATE | PLT20*190 | +38.482 | +39.258 | 7 | 8 | 23.1 | 0 | 14.4 | 0.3 | 190 | 20 | 775.6 | pe-5 | 0.333352 | 0.333352 | 0.0038 | 0.00294728 | 0.00294728
END PLATE | PLT20*190 | +38.688 | +39.032 | 7 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pe-28 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
2 x END PLATE | PLT20*190 | +38.482 | +39.238 | 7 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pe-4 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
5 x END PLATE | PLT20*190 | +35.920 | +36.264 | 6 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pd-16 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
2 x END PLATE | PLT20*190 | +35.714 | +36.470 | 6 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pd-11 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
2 x END PLATE | PLT16*170 | +33.547 | +34.199 | 6 | 8 | 14 | 0 | 17.8 | 0.2 | 169.9 | 16 | 651.5 | pd-122 | 0.247798 | 0.247798 | 0.00272 | 0.00177208 | 0.00177208
2 x END PLATE | PLT16*170 | +41.354 | +42.006 | 7 | 8 | 14 | 0 | 17.8 | 0.2 | 169.9 | 16 | 651.5 | pe-143 | 0.247798 | 0.247798 | 0.00272 | 0.00177208 | 0.00177208
2 x END PLATE | PLT16*170 | +46.561 | +47.213 | 7 | 8 | 14 | 0 | 17.8 | 0.2 | 169.9 | 16 | 651.5 | pe-143 | 0.247798 | 0.247798 | 0.00272 | 0.00177208 | 0.00177208
2 x END PLATE | PLT16*170 | +50.701 | +51.353 | 8 | 8 | 14 | 0 | 17.8 | 0.2 | 169.9 | 16 | 651.5 | pf-212 | 0.247798 | 0.247798 | 0.00272 | 0.00177208 | 0.00177208
2 x END PLATE | PLT16*170 | +60.283 | +60.935 | 8 | 8 | 14 | 0 | 17.8 | 0.2 | 169.9 | 16 | 651.5 | pf-212 | 0.247798 | 0.247798 | 0.00272 | 0.00177208 | 0.00177208
END PLATE | PLT16*170 | +67.998 | +68.650 | 8 | 8 | 14 | 0 | 17.8 | 0.2 | 169.9 | 16 | 651.5 | pf-212 | 0.247798 | 0.247798 | 0.00272 | 0.00177208 | 0.00177208
END PLATE | PLT16*170 | +67.999 | +68.650 | 8 | 8 | 14 | 0 | 17.8 | 0.2 | 169.9 | 16 | 651.5 | pf-212 | 0.247798 | 0.247798 | 0.00272 | 0.00177208 | 0.00177208
2 x END PLATE | PLT20*190 | +38.688 | +39.258 | 7 | 8 | 17 | 0 | 14.4 | 0.2 | 190 | 20 | 569.6 | pe-10 | 0.246832 | 0.246832 | 0.0038 | 0.00216448 | 0.00216448
END PLATE | PLT20*190 | +35.920 | +36.264 | 6 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pd-18 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
4 x END PLATE | PLT20*190 | +28.730 | +29.074 | 6 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pd-16 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
2 x END PLATE | PLT20*190 | +28.524 | +29.280 | 6 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pd-11 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
3 x END PLATE | PLT20*190 | +28.730 | +29.074 | 6 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pd-18 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
2 x END PLATE | PLT20*190 | +31.378 | +31.948 | 6 | 8 | 17 | 0 | 14.4 | 0.2 | 190 | 20 | 569.6 | pd-3 | 0.246832 | 0.246832 | 0.0038 | 0.00216448 | 0.00216448
2 x END PLATE | PLT20*190 | +31.172 | +31.928 | 6 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pd-11 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
2 x END PLATE | PLT20*190 | +31.172 | +31.948 | 6 | 8 | 23.1 | 0 | 14.4 | 0.3 | 190 | 20 | 775.6 | pd-12 | 0.333352 | 0.333352 | 0.0038 | 0.00294728 | 0.00294728
2 x END PLATE | PLT20*190 | +54.749 | +55.299 | 8 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pf-5 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +54.749 | +55.505 | 8 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pf-3 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
2 x END PLATE | PLT20*190 | +54.955 | +55.299 | 8 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pf-18 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
2 x END PLATE | PLT20*190 | +54.955 | +55.299 | 8 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pf-19 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +54.749 | +55.505 | 8 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pf-2 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
4 x END PLATE | PLT20*190 | +48.144 | +48.900 | 7 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pe-24 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
2 x END PLATE | PLT20*190 | +48.350 | +48.694 | 7 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pe-8 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +48.144 | +48.900 | 7 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pe-25 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
END PLATE | PLT20*190 | +48.144 | +48.900 | 7 | 8 | 22.5 | 0 | 14.4 | 0.3 | 190 | 20 | 755.6 | pe-23 | 0.324952 | 0.324952 | 0.0038 | 0.00287128 | 0.00287128
2 x END PLATE | PLT16*170 | +33.753 | +33.993 | 6 | 8 | 5.1 | 0 | 18.4 | 0.1 | 169.9 | 16 | 239.5 | pd-124 | 0.094534 | 0.094534 | 0.00272 | 0.00065144 | 0.00065144
2 x END PLATE | PLT16*170 | +41.560 | +41.800 | 7 | 8 | 5.1 | 0 | 18.4 | 0.1 | 169.9 | 16 | 239.5 | pe-190 | 0.094534 | 0.094534 | 0.00272 | 0.00065144 | 0.00065144
2 x END PLATE | PLT16*170 | +46.767 | +47.007 | 7 | 8 | 5.1 | 0 | 18.4 | 0.1 | 169.9 | 16 | 239.5 | pe-190 | 0.094534 | 0.094534 | 0.00272 | 0.00065144 | 0.00065144
2 x END PLATE | PLT16*170 | +50.907 | +51.147 | 8 | 8 | 5.1 | 0 | 18.4 | 0.1 | 169.9 | 16 | 239.5 | pf-200 | 0.094534 | 0.094534 | 0.00272 | 0.00065144 | 0.00065144
2 x END PLATE | PLT16*170 | +60.489 | +60.729 | 8 | 8 | 5.1 | 0 | 18.4 | 0.1 | 169.9 | 16 | 239.5 | pf-200 | 0.094534 | 0.094534 | 0.00272 | 0.00065144 | 0.00065144
2 x END PLATE | PLT16*170 | +68.204 | +68.444 | 8 | 8 | 5.1 | 0 | 18.4 | 0.1 | 169.9 | 16 | 239.5 | pf-200 | 0.094534 | 0.094534 | 0.00272 | 0.00065144 | 0.00065144
END PLATE | PLT12*160 | +70.350 | +70.620 | 8 | 99 | 4.1 | 0 | 23.8 | 0.1 | 159.9 | 12 | 270 | pf-27 | 0.09672 | 0.09672 | 0.00192 | 0.0005184 | 0.0005184
14 x END PLATE | PLT12*160 | +55.111 | +55.275 | 8 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pf-44 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
END PLATE | PLT12*160 | +55.005 | +55.275 | 8 | 99 | 4.1 | 0 | 23.8 | 0.1 | 159.9 | 12 | 270 | pf-27 | 0.09672 | 0.09672 | 0.00192 | 0.0005184 | 0.0005184
2 x END PLATE | FL12*180 | +53.177 | +53.477 | 8 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pf-51 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | FL12*180 | +54.935 | +54.947 | 8 | 8 | 5.1 | 0.1 | 23.5 | 0.1 | 180 | 12 | 300 | pf-48 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | PLT12*145 | +55.130 | +55.275 | 8 | 8 | 2.2 | 0 | 24.6 | 0.1 | 145 | 12 | 160 | pf-49 | 0.05372 | 0.05372 | 0.00192 | 0.0002784 | 0.0002784
2 x END PLATE | FL12*180 | +46.067 | +46.367 | 7 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pe-58 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
2 x END PLATE | FL12*180 | +48.332 | +48.344 | 7 | 8 | 5.1 | 0.1 | 23.5 | 0.1 | 180 | 12 | 300 | pe-57 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
END PLATE | FL16*200 | +55.306 | +55.322 | 8 | 8 | 6.1 | 0 | 18.1 | 0.1 | 200 | 16 | 242.2 | pf-198 | 0.11103 | 0.11103 | 0.0032 | 0.00077504 | 0.00077504
END PLATE | FL16*200 | +57.648 | +57.664 | 8 | 8 | 12.1 | 0.1 | 17.7 | 0.2 | 200 | 16 | 482.7 | pf-226 | 0.214926 | 0.214926 | 0.0032 | 0.00154464 | 0.00154464
END PLATE | FL20*180 | +48.322 | +48.342 | 7 | 8 | 14.9 | 0.1 | 14.6 | 0.2 | 180 | 20 | 530 | pe-2 | 0.219202 | 0.219202 | 0.0036 | 0.00190802 | 0.00190802
END PLATE | PLT20*190 | +45.211 | +45.741 | 7 | 8 | 15.8 | 0 | 14.6 | 0.2 | 190 | 20 | 530 | pe-1 | 0.230202 | 0.230202 | 0.0038 | 0.00201402 | 0.00201402
END PLATE | FL16*200 | +36.271 | +36.287 | 7 | 8 | 6.1 | 0 | 18.1 | 0.1 | 200 | 16 | 242.2 | pe-189 | 0.11103 | 0.11103 | 0.0032 | 0.00077504 | 0.00077504
END PLATE | PLT12*160 | +35.920 | +36.264 | 6 | 8 | 5.1 | 0 | 23.6 | 0.1 | 159.9 | 12 | 343.6 | pd-46 | 0.122038 | 0.122038 | 0.00192 | 0.000659712 | 0.000659712
5 x END PLATE | PLT12*160 | +44.381 | +44.569 | 7 | 8 | 2.8 | 0 | 24.3 | 0.1 | 159.9 | 12 | 188 | pe-59 | 0.068512 | 0.068512 | 0.00192 | 0.00036096 | 0.00036096
END PLATE | PLT16*188 | +44.381 | +44.569 | 7 | 8 | 4.5 | 0 | 18.6 | 0.1 | 188 | 16 | 190 | pe-188 | 0.083536 | 0.083536 | 0.00304 | 0.00057152 | 0.00057152
END PLATE | PLT12*124 | +44.361 | +44.373 | 7 | 8 | 3.4 | 0 | 24.1 | 0.1 | 124 | 12 | 300 | pe-32 | 0.0845767 | 0.0845767 | 0.001488 | 0.000446404 | 0.000446404
END PLATE | PLT12*160 | +43.442 | +43.742 | 7 | 8 | 4.5 | 0 | 23.8 | 0.1 | 159.9 | 12 | 300 | pe-60 | 0.107041 | 0.107041 | 0.00192 | 0.000576005 | 0.000576005
END PLATE | PLT16*160 | +44.275 | +44.545 | 7 | 8 | 5.4 | 0 | 18.4 | 0.1 | 159.9 | 16 | 270 | pe-173 | 0.10016 | 0.10016 | 0.00256 | 0.0006912 | 0.0006912
5 x END PLATE | PLT12*160 | +70.456 | +70.644 | 8 | 8 | 2.8 | 0 | 24.3 | 0.1 | 159.9 | 12 | 188 | pf-57 | 0.068512 | 0.068512 | 0.00192 | 0.00036096 | 0.00036096
END PLATE | PLT16*188 | +70.456 | +70.644 | 8 | 8 | 4.5 | 0 | 18.6 | 0.1 | 188 | 16 | 190 | pf-197 | 0.083536 | 0.083536 | 0.00304 | 0.00057152 | 0.00057152
END PLATE | PLT12*124 | +70.436 | +70.448 | 8 | 8 | 3.4 | 0 | 24.1 | 0.1 | 124 | 12 | 300 | pf-26 | 0.0845767 | 0.0845767 | 0.001488 | 0.000446404 | 0.000446404
END PLATE | PLT12*160 | +69.517 | +69.817 | 8 | 8 | 4.5 | 0 | 23.8 | 0.1 | 159.9 | 12 | 300 | pf-59 | 0.107041 | 0.107041 | 0.00192 | 0.000576005 | 0.000576005
END PLATE | PLT16*160 | +70.350 | +70.620 | 8 | 8 | 5.4 | 0 | 18.4 | 0.1 | 159.9 | 16 | 270 | pf-257 | 0.10016 | 0.10016 | 0.00256 | 0.0006912 | 0.0006912
5 x END PLATE | PLT12*160 | +55.111 | +55.299 | 8 | 8 | 2.8 | 0 | 24.3 | 0.1 | 159.9 | 12 | 188 | pf-57 | 0.068512 | 0.068512 | 0.00192 | 0.00036096 | 0.00036096
END PLATE | PLT16*188 | +55.111 | +55.299 | 8 | 8 | 4.5 | 0 | 18.6 | 0.1 | 188 | 16 | 190 | pf-197 | 0.083536 | 0.083536 | 0.00304 | 0.00057152 | 0.00057152
END PLATE | PLT12*124 | +55.091 | +55.103 | 8 | 8 | 3.4 | 0 | 24.1 | 0.1 | 124 | 12 | 300 | pf-26 | 0.0845767 | 0.0845767 | 0.001488 | 0.000446404 | 0.000446404
END PLATE | PLT12*160 | +54.172 | +54.472 | 8 | 8 | 4.5 | 0 | 23.8 | 0.1 | 159.9 | 12 | 300 | pf-59 | 0.107041 | 0.107041 | 0.00192 | 0.000576005 | 0.000576005
END PLATE | PLT16*160 | +55.005 | +55.275 | 8 | 8 | 5.4 | 0 | 18.4 | 0.1 | 159.9 | 16 | 270 | pf-257 | 0.10016 | 0.10016 | 0.00256 | 0.0006912 | 0.0006912
END PLATE | PLT16*188 | +63.256 | +63.444 | 8 | 8 | 4.5 | 0 | 18.6 | 0.1 | 188 | 16 | 190 | pf-197 | 0.083536 | 0.083536 | 0.00304 | 0.00057152 | 0.00057152
END PLATE | PLT12*124 | +63.236 | +63.248 | 8 | 8 | 3.4 | 0 | 24.1 | 0.1 | 124 | 12 | 300 | pf-26 | 0.0845767 | 0.0845767 | 0.001488 | 0.000446404 | 0.000446404
END PLATE | PLT12*160 | +62.317 | +62.617 | 8 | 8 | 4.5 | 0 | 23.8 | 0.1 | 159.9 | 12 | 300 | pf-59 | 0.107041 | 0.107041 | 0.00192 | 0.000576005 | 0.000576005
END PLATE | FL12*200 | +63.256 | +63.425 | 8 | 8 | 3.2 | 0 | 24 | 0.1 | 168.9 | 12 | 169 | pf-25 | 0.076456 | 0.076456 | 0.0024 | 0.0004056 | 0.0004056
END PLATE | FL16*200 | +63.150 | +63.425 | 8 | 8 | 6.8 | 0 | 18.1 | 0.1 | 200 | 16 | 274.9 | pf-259 | 0.1252 | 0.1252 | 0.0032 | 0.00088 | 0.00088
5 x END PLATE | PLT12*160 | +38.844 | +39.032 | 7 | 8 | 2.8 | 0 | 24.3 | 0.1 | 159.9 | 12 | 188 | pe-59 | 0.068512 | 0.068512 | 0.00192 | 0.00036096 | 0.00036096
END PLATE | PLT16*188 | +38.844 | +39.032 | 7 | 8 | 4.5 | 0 | 18.6 | 0.1 | 188 | 16 | 190 | pe-188 | 0.083536 | 0.083536 | 0.00304 | 0.00057152 | 0.00057152
END PLATE | PLT12*124 | +38.824 | +38.836 | 7 | 8 | 3.4 | 0 | 24.1 | 0.1 | 124 | 12 | 300 | pe-32 | 0.0845767 | 0.0845767 | 0.001488 | 0.000446404 | 0.000446404
END PLATE | PLT12*160 | +37.905 | +38.205 | 7 | 8 | 4.5 | 0 | 23.8 | 0.1 | 159.9 | 12 | 300 | pe-60 | 0.107041 | 0.107041 | 0.00192 | 0.000576005 | 0.000576005
END PLATE | PLT16*160 | +38.738 | +39.008 | 7 | 8 | 5.4 | 0 | 18.4 | 0.1 | 159.9 | 16 | 270 | pe-173 | 0.10016 | 0.10016 | 0.00256 | 0.0006912 | 0.0006912
2 x END PLATE | PLT20*190 | +48.350 | +48.694 | 7 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pe-7 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
12 x END PLATE | PLT12*160 | +48.506 | +48.670 | 7 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pe-53 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
16 x END PLATE | FL12*180 | +48.506 | +48.694 | 7 | 8 | 3.2 | 0 | 24 | 0.1 | 180 | 12 | 188 | pe-55 | 0.076512 | 0.076512 | 0.00216 | 0.00040608 | 0.00040608
2 x END PLATE | FL12*150 | +48.520 | +48.670 | 7 | 99 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pe-54 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
2 x END PLATE | FL12*180 | +42.447 | +42.747 | 7 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pe-58 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
13 x END PLATE | PLT12*160 | +44.381 | +44.545 | 7 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pe-53 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
2 x END PLATE | PLT12*145 | +44.400 | +44.545 | 7 | 8 | 2.2 | 0 | 24.6 | 0.1 | 145 | 12 | 160 | pe-56 | 0.05372 | 0.05372 | 0.00192 | 0.0002784 | 0.0002784
END PLATE | PLT12*160 | +44.275 | +44.545 | 7 | 8 | 4.1 | 0 | 23.8 | 0.1 | 159.9 | 12 | 270 | pe-31 | 0.09672 | 0.09672 | 0.00192 | 0.0005184 | 0.0005184
16 x END PLATE | FL12*180 | +44.381 | +44.569 | 7 | 8 | 3.2 | 0 | 24 | 0.1 | 180 | 12 | 188 | pe-55 | 0.076512 | 0.076512 | 0.00216 | 0.00040608 | 0.00040608
2 x END PLATE | FL12*150 | +44.395 | +44.545 | 7 | 99 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pe-54 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
5 x END PLATE | PLT12*160 | +36.076 | +36.264 | 6 | 8 | 2.8 | 0 | 24.3 | 0.1 | 159.9 | 12 | 188 | pd-34 | 0.068512 | 0.068512 | 0.00192 | 0.00036096 | 0.00036096
END PLATE | PLT16*188 | +36.076 | +36.264 | 6 | 8 | 4.5 | 0 | 18.6 | 0.1 | 188 | 16 | 190 | pd-125 | 0.083536 | 0.083536 | 0.00304 | 0.00057152 | 0.00057152
END PLATE | PLT12*124 | +36.056 | +36.068 | 6 | 8 | 3.4 | 0 | 24.1 | 0.1 | 124 | 12 | 300 | pd-21 | 0.0845767 | 0.0845767 | 0.001488 | 0.000446404 | 0.000446404
END PLATE | PLT12*160 | +35.147 | +35.447 | 6 | 8 | 4.5 | 0 | 23.8 | 0.1 | 159.9 | 12 | 300 | pd-35 | 0.107041 | 0.107041 | 0.00192 | 0.000576005 | 0.000576005
END PLATE | PLT16*160 | +35.970 | +36.240 | 6 | 8 | 5.4 | 0 | 18.4 | 0.1 | 159.9 | 16 | 270 | pd-151 | 0.10016 | 0.10016 | 0.00256 | 0.0006912 | 0.0006912
6 x END PLATE | FL12*150 | +36.090 | +36.240 | 6 | 99 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pd-36 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
END PLATE | PLT12*160 | +36.073 | +36.264 | 6 | 8 | 2.9 | 0 | 24.3 | 0.1 | 159.9 | 12 | 191.2 | pd-42 | 0.0696128 | 0.0696128 | 0.00192 | 0.000367104 | 0.000367104
END PLATE | PLT12*160 | +36.073 | +36.240 | 6 | 8 | 2.5 | 0 | 24.3 | 0.1 | 159.9 | 12 | 167.2 | pd-43 | 0.0613568 | 0.0613568 | 0.00192 | 0.000321024 | 0.000321024
2 x END PLATE | FL12*180 | +34.142 | +34.442 | 6 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pd-39 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
13 x END PLATE | PLT12*160 | +36.076 | +36.240 | 6 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pd-33 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
2 x END PLATE | PLT12*145 | +36.095 | +36.240 | 6 | 8 | 2.2 | 0 | 24.6 | 0.1 | 145 | 12 | 160 | pd-37 | 0.05372 | 0.05372 | 0.00192 | 0.0002784 | 0.0002784
END PLATE | PLT12*160 | +35.970 | +36.240 | 6 | 8 | 4.1 | 0 | 23.8 | 0.1 | 159.9 | 12 | 270 | pd-20 | 0.09672 | 0.09672 | 0.00192 | 0.0005184 | 0.0005184
16 x END PLATE | FL12*180 | +36.076 | +36.264 | 6 | 8 | 3.2 | 0 | 24 | 0.1 | 180 | 12 | 188 | pd-38 | 0.076512 | 0.076512 | 0.00216 | 0.00040608 | 0.00040608
2 x END PLATE | FL12*180 | +26.952 | +27.252 | 6 | 8 | 5.1 | 0 | 23.5 | 0.1 | 180 | 12 | 300 | pd-39 | 0.119521 | 0.119521 | 0.00216 | 0.000648006 | 0.000648006
13 x END PLATE | PLT12*160 | +28.886 | +29.050 | 6 | 99 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pd-33 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
2 x END PLATE | PLT12*145 | +28.905 | +29.050 | 6 | 8 | 2.2 | 0 | 24.6 | 0.1 | 145 | 12 | 160 | pd-37 | 0.05372 | 0.05372 | 0.00192 | 0.0002784 | 0.0002784
END PLATE | PLT12*160 | +28.780 | +29.050 | 6 | 8 | 4.1 | 0 | 23.8 | 0.1 | 159.9 | 12 | 270 | pd-20 | 0.09672 | 0.09672 | 0.00192 | 0.0005184 | 0.0005184
16 x END PLATE | FL12*180 | +28.886 | +29.074 | 6 | 8 | 3.2 | 0 | 24 | 0.1 | 180 | 12 | 188 | pd-38 | 0.076512 | 0.076512 | 0.00216 | 0.00040608 | 0.00040608
2 x END PLATE | FL12*150 | +28.900 | +29.050 | 6 | 99 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pd-36 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
5 x END PLATE | PLT12*160 | +28.886 | +29.074 | 6 | 8 | 2.8 | 0 | 24.3 | 0.1 | 159.9 | 12 | 188 | pd-34 | 0.068512 | 0.068512 | 0.00192 | 0.00036096 | 0.00036096
END PLATE | PLT16*188 | +28.886 | +29.074 | 6 | 8 | 4.5 | 0 | 18.6 | 0.1 | 188 | 16 | 190 | pd-125 | 0.083536 | 0.083536 | 0.00304 | 0.00057152 | 0.00057152
END PLATE | PLT12*124 | +28.866 | +28.878 | 6 | 8 | 3.4 | 0 | 24.1 | 0.1 | 124 | 12 | 300 | pd-21 | 0.0845767 | 0.0845767 | 0.001488 | 0.000446404 | 0.000446404
END PLATE | PLT12*160 | +27.957 | +28.257 | 6 | 8 | 4.5 | 0 | 23.8 | 0.1 | 159.9 | 12 | 300 | pd-35 | 0.107041 | 0.107041 | 0.00192 | 0.000576005 | 0.000576005
END PLATE | PLT16*160 | +28.780 | +29.050 | 6 | 8 | 5.4 | 0 | 18.4 | 0.1 | 159.9 | 16 | 270 | pd-151 | 0.10016 | 0.10016 | 0.00256 | 0.0006912 | 0.0006912
7 x END PLATE | PLT12*160 | +5.346 | +5.358 | 5 | 8 | 3.2 | 0 | 24 | 0.1 | 159.9 | 12 | 212 | pc-107 | 0.076768 | 0.076768 | 0.00192 | 0.00040704 | 0.00040704
END PLATE | PLT12*160 | +15.503 | +15.670 | 5 | 8 | 2.5 | 0 | 24.3 | 0.1 | 159.9 | 12 | 167.2 | pc-120 | 0.0613568 | 0.0613568 | 0.00192 | 0.000321024 | 0.000321024
2 x END PLATE | FL12*150 | +5.520 | +5.670 | 5 | 99 | 2.3 | 0 | 24.4 | 0.1 | 149.9 | 12 | 160 | pc-115 | 0.05544 | 0.05544 | 0.00192 | 0.000288 | 0.000288
11 x END PLATE | PLT12*160 | +5.503 | +5.670 | 5 | 8 | 2.5 | 0 | 24.3 | 0.1 | 159.9 | 12 | 167.2 | pc-120 | 0.0613568 | 0.0613568 | 0.00192 | 0.000321024 | 0.000321024
3 x END PLATE | PLT12*160 | +5.503 | +5.670 | 5 | 99 | 2.5 | 0 | 24.3 | 0.1 | 159.9 | 12 | 167.2 | pc-120 | 0.0613568 | 0.0613568 | 0.00192 | 0.000321024 | 0.000321024
END PLATE | PLT20*190 | +10.004 | +10.790 | 5 | 8 | 23.5 | 0 | 14.4 | 0.3 | 190 | 20 | 785.6 | pc-7 | 0.337552 | 0.337552 | 0.0038 | 0.00298528 | 0.00298528
3 x END PLATE | PLT20*190 | +10.240 | +10.584 | 5 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-57 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
6 x END PLATE | PLT20*190 | +2.400 | +2.744 | 5 | 8 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-57 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
2 x END PLATE | PLT20*190 | +5.350 | +5.950 | 5 | 99 | 18 | 0 | 14.4 | 0.3 | 190 | 20 | 599.6 | pc-33 | 0.259432 | 0.259432 | 0.0038 | 0.00227848 | 0.00227848
3 x END PLATE | PLT20*190 | +5.114 | +5.694 | 5 | 99 | 17.3 | 0 | 14.4 | 0.3 | 190 | 20 | 579.6 | pc-32 | 0.251032 | 0.251032 | 0.0038 | 0.00220248 | 0.00220248
2 x END PLATE | PLT20*190 | +5.114 | +5.920 | 5 | 99 | 23.9 | 0 | 14.4 | 0.3 | 190 | 20 | 805.6 | pc-6 | 0.345952 | 0.345952 | 0.0038 | 0.00306128 | 0.00306128
END PLATE | PLT20*190 | +5.350 | +5.694 | 5 | 99 | 10.2 | 0 | 14.8 | 0.2 | 190 | 20 | 343.6 | pc-57 | 0.151912 | 0.151912 | 0.0038 | 0.00130568 | 0.00130568
END PLATE | PLT20*190 | +5.350 | +5.900 | 5 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-27 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT12*78 | +2.611 | +2.689 | 5 | 8 | 1.1 | 0 | 26.2 | 0 | 78 | 12 | 148 | pc-102 | 0.028512 | 0.028512 | 0.001776 | 0.000138528 | 0.000138528
END PLATE | PLT12*78 | +2.611 | +2.689 | 5 | 8 | 1.1 | 0 | 26.2 | 0 | 78 | 12 | 148 | pc-101 | 0.028512 | 0.028512 | 0.001776 | 0.000138528 | 0.000138528
2 x END PLATE | FL12*150 | +3.070 | +3.220 | 5 | 8 | 1.9 | 0 | 24.8 | 0 | 140 | 12 | 140 | pc-117 | 0.04896 | 0.04896 | 0.00168 | 0.000252 | 0.000252
3 x END PLATE | FL12*150 | +11.020 | +11.170 | 5 | 8 | 1.9 | 0 | 24.8 | 0 | 140 | 12 | 140 | pc-117 | 0.04896 | 0.04896 | 0.00168 | 0.000252 | 0.000252
3 x END PLATE | PLT16*140 | +10.874 | +11.170 | 5 | 8 | 5.1 | 0 | 18.6 | 0.1 | 140 | 16 | 295.6 | pc-379 | 0.0967072 | 0.0967072 | 0.00224 | 0.000662144 | 0.000662144
2 x END PLATE | FL16*200 | +10.946 | +11.170 | 5 | 8 | 5.6 | 0 | 18.3 | 0.1 | 200 | 16 | 223.9 | pc-381 | 0.103168 | 0.103168 | 0.0032 | 0.0007168 | 0.0007168
END PLATE | PLT12*140 | +5.306 | +5.470 | 5 | 8 | 2.2 | 0 | 24.6 | 0.1 | 140 | 12 | 164 | pc-108 | 0.053216 | 0.053216 | 0.00168 | 0.00027552 | 0.00027552
END PLATE | PLT12*160 | +5.306 | +5.470 | 5 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pc-114 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
8 x END PLATE | PLT16*140 | +5.174 | +5.470 | 5 | 8 | 5.1 | 0 | 18.6 | 0.1 | 140 | 16 | 295.6 | pc-379 | 0.0967072 | 0.0967072 | 0.00224 | 0.000662144 | 0.000662144
3 x END PLATE | FL12*150 | +5.320 | +5.470 | 5 | 8 | 1.9 | 0 | 24.8 | 0 | 140 | 12 | 140 | pc-117 | 0.04896 | 0.04896 | 0.00168 | 0.000252 | 0.000252
4 x END PLATE | PLT12*160 | +11.006 | +11.170 | 5 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pc-114 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
5 x END PLATE | PLT16*170 | +10.827 | +10.843 | 5 | 8 | 3.6 | 0 | 18.9 | 0.1 | 169.9 | 16 | 170 | pc-266 | 0.06868 | 0.06868 | 0.00272 | 0.0004624 | 0.0004624
5 x END PLATE | PLT16*170 | +9.201 | +9.217 | 5 | 8 | 3.6 | 0 | 18.9 | 0.1 | 169.9 | 16 | 170 | pc-266 | 0.06868 | 0.06868 | 0.00272 | 0.0004624 | 0.0004624
2 x END PLATE | PLT16*160 | +9.850 | +10.194 | 5 | 8 | 6.8 | 0 | 18.3 | 0.1 | 159.9 | 16 | 343.6 | pc-236 | 0.126067 | 0.126067 | 0.00256 | 0.000879616 | 0.000879616
2 x END PLATE | PLT16*170 | +11.201 | +11.217 | 5 | 8 | 3.6 | 0 | 18.9 | 0.1 | 169.9 | 16 | 170 | pc-266 | 0.06868 | 0.06868 | 0.00272 | 0.0004624 | 0.0004624
2 x END PLATE | PLT12*160 | +11.850 | +12.194 | 5 | 8 | 5.1 | 0 | 23.6 | 0.1 | 159.9 | 12 | 343.6 | pc-65 | 0.122038 | 0.122038 | 0.00192 | 0.000659712 | 0.000659712
8 x END PLATE | FL16*200 | +10.850 | +11.194 | 5 | 8 | 8.5 | 0 | 17.9 | 0.2 | 200 | 16 | 343.6 | pc-228 | 0.154835 | 0.154835 | 0.0032 | 0.00109952 | 0.00109952
6 x END PLATE | PLT12*160 | +10.396 | +10.560 | 5 | 8 | 2.5 | 0 | 24.4 | 0.1 | 159.9 | 12 | 164 | pc-114 | 0.060256 | 0.060256 | 0.00192 | 0.00031488 | 0.00031488
2 x END PLATE | FL10*70 | +11.565 | +11.677 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +12.298 | +12.409 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +10.833 | +10.944 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +14.100 | +14.110 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +14.416 | +14.530 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +15.488 | +15.602 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +13.888 | +14.002 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +12.744 | +12.858 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
END PLATE | FL20*200 | +5.350 | +5.900 | 5 | 8 | 17.3 | 0 | 14.4 | 0.2 | 200 | 20 | 549.6 | pc-49 | 0.249824 | 0.249824 | 0.004 | 0.0021984 | 0.0021984
4 x END PLATE | PLT20*190 | +5.144 | +5.694 | 5 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-31 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
4 x END PLATE | PLT20*190 | +5.350 | +5.900 | 5 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-27 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
3 x END PLATE | PLT20*190 | +11.944 | +12.494 | 5 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-15 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +11.944 | +12.494 | 5 | 99 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-16 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +5.144 | +5.694 | 5 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-31 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | PLT20*190 | +11.944 | +12.494 | 5 | 8 | 16.4 | 0 | 14.4 | 0.2 | 190 | 20 | 549.6 | pc-15 | 0.238432 | 0.238432 | 0.0038 | 0.00208848 | 0.00208848
END PLATE | FL20*200 | +12.150 | +12.494 | 5 | 8 | 10.9 | 0 | 14.8 | 0.2 | 200 | 20 | 343.6 | pc-39 | 0.159184 | 0.159184 | 0.004 | 0.0013744 | 0.0013744
2 x END PLATE | FL16*200 | +5.370 | +5.694 | 5 | 8 | 8.1 | 0 | 17.9 | 0.1 | 200 | 16 | 324 | pc-380 | 0.146381 | 0.146381 | 0.0032 | 0.0010369 | 0.0010369
END PLATE | FL10*70 | +12.500 | +12.510 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +10.100 | +10.110 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +7.900 | +7.910 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
END PLATE | FL10*70 | +5.700 | +5.710 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +2.700 | +2.710 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +4.252 | +4.366 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +6.852 | +6.966 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +9.052 | +9.166 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +11.352 | +11.466 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +10.416 | +10.530 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +8.216 | +8.330 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +6.016 | +6.130 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +3.016 | +3.130 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +12.288 | +12.402 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +9.888 | +10.002 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +7.688 | +7.802 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +5.488 | +5.602 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +1.640 | +1.754 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +0.792 | +0.906 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | +2.488 | +2.602 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL10*70 | -0.056 | +0.058 | 5 | 8 | 1 | 0 | 30.6 | 0 | 70 | 10 | 170 | pc-127 | 0.0286 | 0.0286 | 0.0017 | 0.000119 | 0.000119
2 x END PLATE | FL16*200 | +15.702 | +15.718 | 4 | 8 | 6.1 | 0 | 18.1 | 0.1 | 200 | 16 | 242.2 | pb-213 | 0.11103 | 0.11103 | 0.0032 | 0.00077504 | 0.00077504
2 x END PLATE | FL16*200 | +17.676 | +17.692 | 4 | 8 | 11.5 | 0.1 | 17.8 | 0.2 | 200 | 16 | 458.2 | pb-208 | 0.204342 | 0.204342 | 0.0032 | 0.00146624 | 0.00146624
13 x END PLATE | FL12*70 | +21.266 | +21.454 | 4 | 8 | 1.3 | 0 | 26.2 | 0 | 70 | 12 | 188 | pb-44 | 0.032512 | 0.032512 | 0.00084 | 0.00015792 | 0.00015792
2 x END PLATE | PLT12*94 | +21.110 | +21.454 | 4 | 8 | 2.9 | 0 | 24.8 | 0.1 | 94 | 12 | 343.6 | pb-52 | 0.0750992 | 0.0750992 | 0.001128 | 0.000387581 | 0.000387581
