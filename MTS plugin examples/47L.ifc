Properties of the parts of a building model (IFC2X3), part 12 of 22

# IfcDiscreteAccessory: PLATE (5205)
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
PLATE | PLT16*321.7 | +15.200 | +15.522 | 5 | 99 | 17.5 | 0 | 17.3 | 0.3 | 321.7 | 16 | 511.2 | pc-271 | 0.302235 | 0.164452 | 0.000256 | 0.00222158 | 0.00222158
2 x PLATE | PLT10*94.5 | +15.026 | +15.219 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +14.931 | +15.319 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*340.3 | +15.004 | +15.344 | 5 | 99 | 15.8 | 0 | 17.5 | 0.3 | 340.3 | 16 | 466.6 | pc-294 | 0.275152 | 0.158779 | 0.000256 | 0.00201698 | 0.00201698
2 x PLATE | PLT10*94.5 | +12.626 | +12.819 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +12.525 | +12.914 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*340.3 | +12.500 | +12.840 | 5 | 99 | 15.1 | 0 | 17.5 | 0.3 | 340.3 | 16 | 466.6 | pc-295 | 0.263806 | 0.158779 | 0.000256 | 0.00192881 | 0.00192881
2 x PLATE | PLT10*94.5 | +11.760 | +11.873 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +11.576 | +12.069 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*351.4 | +11.764 | +12.144 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 351.5 | 16 | 380 | pc-296 | 0.233929 | 0.133532 | 0.000256 | 0.00170771 | 0.00170771
2 x PLATE | PLT10*94.5 | +12.658 | +12.836 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +12.525 | +12.961 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*351.3 | +12.500 | +12.851 | 5 | 99 | 14.9 | 0 | 17.5 | 0.3 | 351.3 | 16 | 454.2 | pc-297 | 0.261533 | 0.159543 | 0.000256 | 0.00191399 | 0.00191399
4 x PLATE | PLT10*94.5 | +11.800 | +11.946 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +11.638 | +12.119 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*336.1 | +11.796 | +12.144 | 5 | 99 | 11.1 | 0 | 17.7 | 0.2 | 336.1 | 16 | 348.3 | pc-298 | 0.196171 | 0.117071 | 0.000256 | 0.00141913 | 0.00141913
PLATE | PLT16*336.1 | +11.796 | +12.144 | 5 | 99 | 11.1 | 0 | 17.7 | 0.2 | 336.1 | 16 | 348.3 | pc-298 | 0.19617 | 0.117071 | 0.000256 | 0.00141913 | 0.00141913
8 x PLATE | PLT10*94.5 | +5.899 | +6.044 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +5.725 | +6.207 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*336.1 | +5.700 | +6.048 | 5 | 99 | 11.1 | 0 | 17.7 | 0.2 | 336.1 | 16 | 348.3 | pc-298 | 0.19617 | 0.117071 | 0.000256 | 0.00141913 | 0.00141913
PLATE | PLT16*336.1 | +5.700 | +6.048 | 5 | 99 | 11.6 | 0 | 17.7 | 0.2 | 336.1 | 16 | 348.3 | pc-299 | 0.203324 | 0.117071 | 0.000256 | 0.0014742 | 0.0014742
2 x PLATE | PLT10*94.5 | +5.972 | +6.084 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +5.775 | +6.268 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*351.4 | +5.700 | +6.080 | 5 | 99 | 13.7 | 0 | 17.5 | 0.2 | 351.5 | 16 | 380 | pc-287 | 0.240075 | 0.133532 | 0.000256 | 0.00175553 | 0.00175553
4 x PLATE | PLT10*94.5 | +5.888 | +6.044 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +5.725 | +6.197 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*351.6 | +5.700 | +6.052 | 5 | 99 | 12.4 | 0 | 17.5 | 0.2 | 351.6 | 16 | 364.2 | pc-288 | 0.215684 | 0.128046 | 0.000256 | 0.00156787 | 0.00156787
2 x PLATE | PLT10*94.5 | +5.896 | +6.044 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +5.725 | +6.205 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*342.7 | +5.700 | +6.049 | 5 | 99 | 11.5 | 0 | 17.7 | 0.2 | 342.8 | 16 | 349.3 | pc-289 | 0.202959 | 0.11971 | 0.000256 | 0.00147115 | 0.00147115
2 x PLATE | PLT10*94.5 | +9.890 | +10.038 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +9.730 | +10.209 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*342.7 | +9.885 | +10.234 | 5 | 99 | 11.3 | 0 | 17.7 | 0.2 | 342.8 | 16 | 349.3 | pc-290 | 0.199902 | 0.11971 | 0.000256 | 0.0014475 | 0.0014475
2 x PLATE | PLT10*94.5 | +10.705 | +10.901 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +10.615 | +10.987 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*335 | +10.590 | +10.925 | 5 | 99 | 16.7 | 0 | 17.5 | 0.3 | 335 | 16 | 512 | pc-291 | 0.287709 | 0.171542 | 0.000256 | 0.00210862 | 0.00210862
4 x PLATE | PLT10*94.5 | +11.800 | +11.956 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +11.647 | +12.119 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*351.6 | +11.793 | +12.144 | 5 | 99 | 12.1 | 0 | 17.5 | 0.2 | 351.6 | 16 | 364.2 | pc-292 | 0.211951 | 0.128046 | 0.000256 | 0.00153899 | 0.00153899
2 x PLATE | PLT10*94.5 | +11.833 | +12.029 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +11.747 | +12.119 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*335 | +11.809 | +12.144 | 5 | 99 | 16.7 | 0 | 17.5 | 0.3 | 335 | 16 | 512 | pc-291 | 0.287709 | 0.171542 | 0.000256 | 0.00210862 | 0.00210862
4 x PLATE | PLT10*94.5 | +12.712 | +12.841 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +12.525 | +13.016 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*340 | +12.500 | +12.840 | 5 | 99 | 11.6 | 0 | 17.7 | 0.2 | 340 | 16 | 349.7 | pc-293 | 0.203664 | 0.118918 | 0.000256 | 0.00147667 | 0.00147667
3 x PLATE | PLT10*94.5 | +14.998 | +15.127 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +14.823 | +15.314 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT10*94.5 | +14.998 | +15.127 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | PLT16*345.4 | +14.999 | +15.344 | 5 | 99 | 25.2 | 0 | 17.2 | 0.3 | 345.4 | 16 | 680.7 | pc-399 | 0.430126 | 0.235131 | 0.000256 | 0.00320582 | 0.00320582
2 x PLATE | PLT10*94.5 | +15.841 | +16.028 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +15.725 | +16.137 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*346.6 | +15.700 | +16.047 | 5 | 99 | 17.6 | 0 | 17.3 | 0.3 | 346.6 | 16 | 517.9 | pc-283 | 0.30415 | 0.179503 | 0.000256 | 0.00223729 | 0.00223729
2 x PLATE | PLT10*94.5 | +18.409 | +18.612 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +18.357 | +18.661 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*257.7 | +18.239 | +18.692 | 5 | 99 | 11.1 | 0 | 17.7 | 0.2 | 257.7 | 16 | 452.1 | pc-284 | 0.197355 | 0.116504 | 0.000256 | 0.0014197 | 0.0014197
2 x PLATE | PLT10*94.5 | +18.799 | +18.986 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +18.689 | +19.101 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*336.6 | +18.780 | +19.116 | 5 | 99 | 16.7 | 0 | 17.3 | 0.3 | 336.6 | 16 | 497.6 | pc-285 | 0.289519 | 0.167481 | 0.000256 | 0.00212606 | 0.00212606
2 x PLATE | PLT10*94.5 | +18.847 | +19.050 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +18.797 | +19.101 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-383 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*299.2 | +18.817 | +19.116 | 5 | 99 | 14.4 | 0 | 17.5 | 0.3 | 299.2 | 16 | 432.2 | pc-286 | 0.251676 | 0.129317 | 0.000256 | 0.00183635 | 0.00183635
2 x PLATE | PLT10*343 | +19.123 | +19.466 | 5 | 99 | 17.2 | 0 | 26.6 | 0.5 | 343 | 10 | 640 | pc-132 | 0.4587 | 0.21952 | 0.0001 | 0.0021952 | 0.0021952
2 x PLATE | PLT10*82.1 | +19.128 | +19.460 | 5 | 99 | 2.1 | 0 | 29.2 | 0.1 | 82.1 | 10 | 331.6 | pc-199 | 0.062097 | 0.0272244 | 0.0001 | 0.000269994 | 0.000269994
2 x PLATE | PLT8*132.2 | +50.978 | +51.144 | 8 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166 | pf-279 | 0.0483663 | 0.0219452 | 0.000064 | 0.000174662 | 0.000174662
2 x PLATE | FL10*70 | +50.808 | +50.946 | 8 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pf-71 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
2 x PLATE | PLT8*132.2 | +46.838 | +47.004 | 7 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166 | pe-195 | 0.0483663 | 0.0219452 | 0.000064 | 0.000174662 | 0.000174662
2 x PLATE | FL10*70 | +46.668 | +46.806 | 7 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pe-74 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
2 x PLATE | PLT8*132.2 | +41.631 | +41.797 | 7 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166 | pe-195 | 0.0483663 | 0.0219452 | 0.000064 | 0.000174662 | 0.000174662
2 x PLATE | FL10*70 | +41.461 | +41.599 | 7 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pe-74 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
2 x PLATE | PLT8*132.2 | +33.824 | +33.990 | 6 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166 | pd-169 | 0.0483663 | 0.0219452 | 0.000064 | 0.000174662 | 0.000174662
2 x PLATE | PLT10*94.5 | +69.952 | +70.118 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +69.810 | +70.269 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*353 | +69.941 | +70.294 | 8 | 99 | 13.1 | 0 | 17.5 | 0.2 | 353 | 16 | 398 | pf-234 | 0.230776 | 0.140503 | 0.000256 | 0.0016816 | 0.0016816
2 x PLATE | PLT10*94.5 | +68.626 | +68.792 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +68.626 | +68.792 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +68.475 | +68.934 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*353 | +68.450 | +68.803 | 8 | 99 | 13.1 | 0 | 17.5 | 0.2 | 353 | 16 | 398 | pf-234 | 0.230778 | 0.140505 | 0.000256 | 0.00168162 | 0.00168162
4 x PLATE | PLT10*94.5 | +67.855 | +68.018 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +67.710 | +68.173 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.8 | +67.846 | +68.198 | 8 | 99 | 12.9 | 0 | 17.5 | 0.2 | 352.8 | 16 | 386.5 | pf-235 | 0.224416 | 0.13637 | 0.000256 | 0.00163346 | 0.00163346
4 x PLATE | PLT10*94.5 | +65.550 | +65.698 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +65.390 | +65.869 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*343.1 | +65.545 | +65.894 | 8 | 99 | 11.3 | 0 | 17.7 | 0.2 | 343.1 | 16 | 349.4 | pf-236 | 0.200128 | 0.119869 | 0.000256 | 0.00144922 | 0.00144922
2 x PLATE | PLT10*94.5 | +66.430 | +66.593 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +66.430 | +66.593 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +66.275 | +66.739 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.8 | +66.250 | +66.603 | 8 | 99 | 12.9 | 0 | 17.5 | 0.2 | 352.8 | 16 | 386.5 | pf-235 | 0.224414 | 0.136369 | 0.000256 | 0.00163344 | 0.00163344
4 x PLATE | PLT10*94.5 | +62.750 | +62.901 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +62.592 | +63.069 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*349.7 | +62.744 | +63.094 | 8 | 99 | 11.6 | 0 | 17.7 | 0.2 | 349.8 | 16 | 350.2 | pf-237 | 0.203849 | 0.122472 | 0.000256 | 0.00147749 | 0.00147749
2 x PLATE | PLT10*94.5 | +63.646 | +63.794 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +63.646 | +63.794 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +63.475 | +63.955 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*343.1 | +63.450 | +63.799 | 8 | 99 | 11.3 | 0 | 17.7 | 0.2 | 343.1 | 16 | 349.4 | pf-236 | 0.200126 | 0.119868 | 0.000256 | 0.00144921 | 0.00144921
4 x PLATE | PLT10*94.5 | +60.139 | +60.287 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +59.978 | +60.458 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*342 | +60.134 | +60.483 | 8 | 99 | 11.3 | 0 | 17.7 | 0.2 | 342 | 16 | 349.3 | pf-238 | 0.199523 | 0.119443 | 0.000256 | 0.00144462 | 0.00144462
4 x PLATE | PLT10*94.5 | +60.929 | +61.079 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +60.760 | +61.237 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*349.7 | +60.735 | +61.085 | 8 | 99 | 11.6 | 0 | 17.7 | 0.2 | 349.8 | 16 | 350.2 | pf-237 | 0.203849 | 0.122472 | 0.000256 | 0.00147749 | 0.00147749
4 x PLATE | PLT10*94.5 | +57.320 | +57.471 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +57.162 | +57.639 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*349.4 | +57.314 | +57.664 | 8 | 99 | 11.6 | 0 | 17.7 | 0.2 | 349.4 | 16 | 350.2 | pf-237 | 0.203677 | 0.122352 | 0.000256 | 0.00147618 | 0.00147618
2 x PLATE | PLT10*94.5 | +58.217 | +58.364 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +58.217 | +58.364 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +58.045 | +58.525 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*342 | +58.020 | +58.369 | 8 | 99 | 11.3 | 0 | 17.7 | 0.2 | 342 | 16 | 349.3 | pf-238 | 0.199524 | 0.119444 | 0.000256 | 0.00144463 | 0.00144463
4 x PLATE | PLT10*94.5 | +54.607 | +54.771 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +54.462 | +54.924 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.9 | +54.596 | +54.949 | 8 | 99 | 12.9 | 0 | 17.5 | 0.2 | 353 | 16 | 390.4 | pf-239 | 0.226541 | 0.13776 | 0.000256 | 0.00164955 | 0.00164955
4 x PLATE | PLT10*94.5 | +55.499 | +55.649 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +55.330 | +55.808 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*349.4 | +55.305 | +55.655 | 8 | 99 | 11.6 | 0 | 17.7 | 0.2 | 349.4 | 16 | 350.2 | pf-237 | 0.203678 | 0.122353 | 0.000256 | 0.00147619 | 0.00147619
2 x PLATE | PLT10*94.5 | +52.347 | +52.523 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +52.218 | +52.659 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352 | +52.332 | +52.684 | 8 | 99 | 14.7 | 0 | 17.5 | 0.3 | 352 | 16 | 440.6 | pf-240 | 0.254124 | 0.155085 | 0.000256 | 0.00185807 | 0.00185807
4 x PLATE | PLT10*94.5 | +53.219 | +53.383 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +53.065 | +53.527 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.9 | +53.040 | +53.393 | 8 | 99 | 12.9 | 0 | 17.5 | 0.2 | 353 | 16 | 390.4 | pf-239 | 0.226543 | 0.137761 | 0.000256 | 0.00164957 | 0.00164957
4 x PLATE | PLT10*94.5 | +50.557 | +50.713 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +50.404 | +50.876 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*351.5 | +50.550 | +50.901 | 8 | 99 | 11.9 | 0 | 17.5 | 0.2 | 351.5 | 16 | 362.5 | pf-241 | 0.211022 | 0.127414 | 0.000256 | 0.00153194 | 0.00153194
4 x PLATE | PLT10*94.5 | +51.315 | +51.491 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +51.178 | +51.619 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352 | +51.153 | +51.505 | 8 | 99 | 14.7 | 0 | 17.5 | 0.3 | 352 | 16 | 440.6 | pf-240 | 0.254124 | 0.155085 | 0.000256 | 0.00185807 | 0.00185807
2 x PLATE | PLT10*94.5 | +48.011 | +48.193 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +47.892 | +48.319 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*349.8 | +47.995 | +48.344 | 7 | 99 | 15.8 | 0 | 17.5 | 0.3 | 349.8 | 16 | 476.9 | pe-152 | 0.273857 | 0.166815 | 0.000256 | 0.00200694 | 0.00200694
2 x PLATE | PLT10*94.5 | +48.889 | +49.044 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +48.889 | +49.044 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +48.725 | +49.198 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*351.5 | +48.700 | +49.051 | 7 | 99 | 11.9 | 0 | 17.5 | 0.2 | 351.5 | 16 | 362.5 | pe-151 | 0.211023 | 0.127415 | 0.000256 | 0.00153195 | 0.00153195
4 x PLATE | PLT10*94.5 | +46.417 | +46.573 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +46.264 | +46.736 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*351.6 | +46.410 | +46.761 | 7 | 99 | 12.1 | 0 | 17.5 | 0.2 | 351.6 | 16 | 363.8 | pe-153 | 0.211746 | 0.127907 | 0.000256 | 0.00153743 | 0.00153743
4 x PLATE | PLT10*94.5 | +47.164 | +47.346 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +47.038 | +47.465 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*349.8 | +47.013 | +47.363 | 7 | 99 | 15.8 | 0 | 17.5 | 0.3 | 349.8 | 16 | 476.9 | pe-152 | 0.273857 | 0.166815 | 0.000256 | 0.00200694 | 0.00200694
4 x PLATE | PLT10*94.5 | +43.875 | +44.024 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +43.716 | +44.194 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*345.7 | +43.870 | +44.219 | 7 | 99 | 11.5 | 0 | 17.7 | 0.2 | 345.7 | 16 | 349.7 | pe-154 | 0.201569 | 0.12088 | 0.000256 | 0.00146017 | 0.00146017
2 x PLATE | PLT10*94.5 | +44.763 | +44.919 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +44.763 | +44.919 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +44.600 | +45.072 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*351.6 | +44.575 | +44.927 | 7 | 99 | 12.1 | 0 | 17.5 | 0.2 | 351.6 | 16 | 363.8 | pe-153 | 0.211747 | 0.127908 | 0.000256 | 0.00153744 | 0.00153744
4 x PLATE | PLT10*94.5 | +42.001 | +42.150 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +41.831 | +42.310 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*345.7 | +41.806 | +42.156 | 7 | 99 | 11.5 | 0 | 17.7 | 0.2 | 345.7 | 16 | 349.7 | pe-154 | 0.201569 | 0.12088 | 0.000256 | 0.00146017 | 0.00146017
4 x PLATE | PLT10*94.5 | +41.210 | +41.357 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +41.048 | +41.529 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*338.3 | +41.206 | +41.554 | 7 | 99 | 11.1 | 0 | 17.7 | 0.2 | 338.3 | 16 | 348.7 | pe-155 | 0.197431 | 0.117965 | 0.000256 | 0.00142871 | 0.00142871
4 x PLATE | PLT10*94.5 | +38.338 | +38.487 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +38.178 | +38.657 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*344.7 | +38.333 | +38.682 | 7 | 99 | 11.3 | 0 | 17.7 | 0.2 | 344.7 | 16 | 349.6 | pe-156 | 0.201026 | 0.1205 | 0.000256 | 0.00145605 | 0.00145605
2 x PLATE | PLT10*94.5 | +39.236 | +39.382 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +39.236 | +39.382 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +39.063 | +39.544 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*338.3 | +39.038 | +39.387 | 7 | 99 | 11.1 | 0 | 17.7 | 0.2 | 338.3 | 16 | 348.7 | pe-155 | 0.197432 | 0.117966 | 0.000256 | 0.00142872 | 0.00142872
4 x PLATE | PLT10*94.5 | +35.571 | +35.735 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +35.426 | +35.889 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.9 | +35.562 | +35.914 | 6 | 99 | 12.9 | 0 | 17.5 | 0.2 | 353 | 16 | 388.3 | pd-144 | 0.225426 | 0.137032 | 0.000256 | 0.00164111 | 0.00164111
4 x PLATE | PLT10*94.5 | +36.466 | +36.614 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +36.295 | +36.774 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*344.7 | +36.270 | +36.620 | 6 | 99 | 11.3 | 0 | 17.7 | 0.2 | 344.7 | 16 | 349.6 | pd-143 | 0.201026 | 0.1205 | 0.000256 | 0.00145605 | 0.00145605
4 x PLATE | PLT10*94.5 | +33.404 | +33.564 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +33.255 | +33.722 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.5 | +33.395 | +33.747 | 6 | 99 | 12.4 | 0 | 17.5 | 0.2 | 352.5 | 16 | 377.6 | pd-145 | 0.219464 | 0.1331 | 0.000256 | 0.00159595 | 0.00159595
4 x PLATE | PLT10*94.5 | +34.178 | +34.342 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +34.024 | +34.487 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.9 | +33.999 | +34.352 | 6 | 99 | 12.9 | 0 | 17.5 | 0.2 | 353 | 16 | 388.3 | pd-144 | 0.225426 | 0.137032 | 0.000256 | 0.00164111 | 0.00164111
4 x PLATE | PLT10*94.5 | +31.028 | +31.180 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +30.871 | +31.347 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*350.6 | +31.022 | +31.372 | 6 | 99 | 11.6 | 0 | 17.7 | 0.2 | 350.6 | 16 | 353.1 | pd-146 | 0.205768 | 0.123804 | 0.000256 | 0.00149207 | 0.00149207
2 x PLATE | PLT10*94.5 | +31.911 | +32.072 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +31.911 | +32.072 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +31.753 | +32.220 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.5 | +31.728 | +32.080 | 6 | 99 | 12.4 | 0 | 17.5 | 0.2 | 352.5 | 16 | 377.6 | pd-145 | 0.219466 | 0.133101 | 0.000256 | 0.00159596 | 0.00159596
4 x PLATE | PLT10*94.5 | +28.380 | +28.532 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +28.223 | +28.699 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*350.5 | +28.374 | +28.724 | 6 | 99 | 11.6 | 0 | 17.7 | 0.2 | 350.4 | 16 | 352.1 | pd-147 | 0.205188 | 0.123402 | 0.000256 | 0.00148766 | 0.00148766
2 x PLATE | PLT10*94.5 | +29.272 | +29.424 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +29.272 | +29.424 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +29.105 | +29.581 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*350.6 | +29.080 | +29.431 | 6 | 99 | 11.6 | 0 | 17.7 | 0.2 | 350.6 | 16 | 353.1 | pd-146 | 0.205769 | 0.123805 | 0.000256 | 0.00149207 | 0.00149207
4 x PLATE | PLT10*94.5 | +26.608 | +26.759 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +26.440 | +26.917 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*350.5 | +26.415 | +26.765 | 6 | 99 | 11.6 | 0 | 17.7 | 0.2 | 350.4 | 16 | 352.1 | pd-147 | 0.205188 | 0.123402 | 0.000256 | 0.00148766 | 0.00148766
4 x PLATE | PLT10*94.5 | +65.553 | +65.723 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +65.416 | +65.869 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.9 | +65.541 | +65.894 | 8 | 99 | 13.7 | 0 | 17.5 | 0.2 | 353 | 16 | 412 | pf-244 | 0.23851 | 0.145432 | 0.000256 | 0.0017401 | 0.0017401
PLATE | PLT16*352.9 | +65.541 | +65.894 | 8 | 99 | 13.7 | 0 | 17.5 | 0.2 | 353 | 16 | 412 | pf-244 | 0.238511 | 0.145432 | 0.000256 | 0.0017401 | 0.0017401
2 x PLATE | PLT10*94.5 | +63.621 | +63.791 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +63.621 | +63.791 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +63.475 | +63.928 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.9 | +63.450 | +63.803 | 8 | 99 | 32.2 | 0 | 16.9 | 0.5 | 353 | 16 | 824.1 | pf-272 | 0.546359 | 0.29086 | 0.000256 | 0.00409707 | 0.00409707
4 x PLATE | PLT10*94.5 | +57.324 | +57.496 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +57.190 | +57.639 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.8 | +57.312 | +57.664 | 8 | 99 | 14 | 0 | 17.5 | 0.2 | 352.8 | 16 | 420.1 | pf-245 | 0.242912 | 0.148191 | 0.000256 | 0.00177338 | 0.00177338
2 x PLATE | PLT10*94.5 | +55.473 | +55.645 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +55.473 | +55.645 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +55.330 | +55.780 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.8 | +55.305 | +55.658 | 8 | 99 | 32.9 | 0 | 16.9 | 0.6 | 352.8 | 16 | 840.1 | pf-271 | 0.558717 | 0.296384 | 0.000256 | 0.0041916 | 0.0041916
7 x PLATE | PLT10*94.5 | +54.616 | +54.797 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +54.496 | +54.924 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*350.1 | +54.599 | +54.949 | 8 | 99 | 15.6 | 0 | 17.5 | 0.3 | 350.1 | 16 | 472.9 | pf-233 | 0.271681 | 0.165543 | 0.000256 | 0.00199053 | 0.00199053
7 x PLATE | PLT10*94.5 | +53.192 | +53.374 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT10*94.5 | +53.192 | +53.374 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
4 x PLATE | FL16*250 | +53.065 | +53.493 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*350.1 | +53.040 | +53.390 | 8 | 99 | 37.6 | 0 | 16.9 | 0.6 | 350.1 | 16 | 945.8 | pf-269 | 0.637518 | 0.331089 | 0.000256 | 0.00479365 | 0.00479365
4 x PLATE | PLT10*94.5 | +44.792 | +44.934 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +44.615 | +45.100 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*361.9 | +44.575 | +44.937 | 7 | 99 | 26.4 | 0 | 17.2 | 0.5 | 361.9 | 16 | 681.3 | pe-187 | 0.450689 | 0.246562 | 0.000256 | 0.00336687 | 0.00336687
4 x PLATE | PLT10*94.5 | +48.001 | +48.142 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +47.835 | +48.319 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*346.8 | +47.998 | +48.344 | 7 | 99 | 11.6 | 0 | 17.7 | 0.2 | 346.8 | 16 | 349.3 | pe-159 | 0.203782 | 0.121124 | 0.000256 | 0.00147726 | 0.00147726
7 x PLATE | PLT10*94.5 | +48.906 | +49.043 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +48.725 | +49.212 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
4 x PLATE | PLT16*344.2 | +48.700 | +49.044 | 7 | 99 | 11.9 | 0 | 17.7 | 0.2 | 344.2 | 16 | 356.2 | pe-158 | 0.207669 | 0.12262 | 0.000256 | 0.00150701 | 0.00150701
PLATE | PLT10*94.5 | +48.906 | +49.043 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
8 x PLATE | PLT10*94.5 | +52.342 | +52.478 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +52.172 | +52.659 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*344.2 | +52.340 | +52.684 | 8 | 99 | 26.3 | 0 | 17.2 | 0.3 | 344.2 | 16 | 712.4 | pf-270 | 0.449396 | 0.245239 | 0.000256 | 0.00335278 | 0.00335278
8 x PLATE | PLT10*94.5 | +58.239 | +58.356 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +58.045 | +58.538 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
4 x PLATE | PLT16*332.8 | +58.020 | +58.353 | 8 | 99 | 11.3 | 0 | 17.7 | 0.2 | 332.8 | 16 | 341.3 | pf-242 | 0.198122 | 0.113607 | 0.000256 | 0.00143464 | 0.00143464
8 x PLATE | PLT10*94.5 | +62.758 | +62.875 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +62.577 | +63.069 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*332.8 | +62.762 | +63.094 | 8 | 99 | 24.4 | 0 | 17.2 | 0.3 | 332.8 | 16 | 683.3 | pf-268 | 0.418315 | 0.227422 | 0.000256 | 0.0031126 | 0.0031126
8 x PLATE | PLT10*94.5 | +66.457 | +66.592 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +66.275 | +66.763 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
4 x PLATE | PLT16*343.7 | +66.250 | +66.594 | 8 | 99 | 11.6 | 0 | 17.7 | 0.2 | 343.7 | 16 | 353.3 | pf-243 | 0.205996 | 0.121437 | 0.000256 | 0.00149429 | 0.00149429
6 x PLATE | PLT10*94.5 | +69.952 | +70.087 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +69.781 | +70.269 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT10*94.5 | +69.952 | +70.087 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT16*343.7 | +69.951 | +70.294 | 8 | 99 | 26 | 0 | 17.2 | 0.3 | 343.7 | 16 | 706.7 | pf-267 | 0.444694 | 0.242875 | 0.000256 | 0.00331671 | 0.00331671
4 x PLATE | FL12*80 | +52.696 | +53.028 | 8 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pf-38 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
2 x PLATE | FL16*250 | +38.205 | +38.657 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-141 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.9 | +38.330 | +38.682 | 7 | 99 | 13.7 | 0 | 17.5 | 0.2 | 353 | 16 | 415 | pe-178 | 0.240136 | 0.146454 | 0.000256 | 0.00175239 | 0.00175239
2 x PLATE | PLT10*94.5 | +36.440 | +36.611 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +36.295 | +36.747 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-141 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.9 | +36.270 | +36.623 | 6 | 99 | 32.4 | 0 | 16.9 | 0.6 | 353 | 16 | 830 | pd-120 | 0.550935 | 0.292908 | 0.000256 | 0.00413207 | 0.00413207
4 x PLATE | PLT10*94.5 | +31.033 | +31.206 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +30.900 | +31.347 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-127 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.6 | +31.020 | +31.372 | 6 | 99 | 14.1 | 0 | 17.5 | 0.2 | 352.6 | 16 | 426.1 | pd-155 | 0.246202 | 0.150233 | 0.000256 | 0.00179824 | 0.00179824
PLATE | PLT16*352.6 | +31.020 | +31.372 | 6 | 99 | 14.1 | 0 | 17.5 | 0.2 | 352.6 | 16 | 426.1 | pd-155 | 0.246202 | 0.150233 | 0.000256 | 0.00179823 | 0.00179823
2 x PLATE | PLT10*94.5 | +29.246 | +29.419 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +29.246 | +29.419 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +29.105 | +29.552 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-127 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.6 | +29.080 | +29.433 | 6 | 99 | 33.5 | 0 | 16.9 | 0.6 | 352.6 | 16 | 852.1 | pd-119 | 0.567893 | 0.300467 | 0.000256 | 0.00426178 | 0.00426178
8 x PLATE | PLT10*94.5 | +35.572 | +35.706 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +35.401 | +35.889 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-127 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*342.7 | +35.572 | +35.914 | 6 | 99 | 25.6 | 0 | 17.2 | 0.3 | 342.8 | 16 | 697 | pd-118 | 0.43679 | 0.238883 | 0.000256 | 0.00325606 | 0.00325606
2 x PLATE | PLT10*94.5 | +31.987 | +32.120 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
6 x PLATE | PLT10*94.5 | +31.987 | +32.120 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +31.803 | +32.292 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-127 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*348.5 | +31.728 | +32.121 | 6 | 99 | 13.5 | 0 | 17.5 | 0.2 | 348.5 | 16 | 392.7 | pd-154 | 0.235443 | 0.136867 | 0.000256 | 0.00171911 | 0.00171911
2 x PLATE | PLT16*348.5 | +31.728 | +32.121 | 6 | 99 | 13.5 | 0 | 17.5 | 0.2 | 348.5 | 16 | 392.7 | pd-154 | 0.235442 | 0.136866 | 0.000256 | 0.00171911 | 0.00171911
8 x PLATE | PLT10*94.5 | +39.308 | +39.424 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +39.113 | +39.606 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-141 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
4 x PLATE | PLT16*339.5 | +39.038 | +39.420 | 7 | 99 | 13.1 | 0 | 17.5 | 0.2 | 339.5 | 16 | 382.3 | pe-177 | 0.229194 | 0.1298 | 0.000256 | 0.0016716 | 0.0016716
8 x PLATE | PLT10*94.5 | +43.883 | +44.000 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +43.701 | +44.194 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-141 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*332.3 | +43.887 | +44.219 | 7 | 99 | 24.2 | 0 | 17.2 | 0.3 | 332.3 | 16 | 679.1 | pe-185 | 0.414931 | 0.225645 | 0.000256 | 0.00308665 | 0.00308665
4 x PLATE | PLT10*94.5 | +48.042 | +48.242 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +47.969 | +48.319 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*327.7 | +48.017 | +48.344 | 7 | 99 | 18.9 | 0 | 17.3 | 0.3 | 327.7 | 16 | 588.3 | pe-157 | 0.327728 | 0.192763 | 0.000256 | 0.00240942 | 0.00240942
3 x PLATE | PLT10*94.5 | +47.463 | +47.663 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +47.386 | +47.736 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT10*94.5 | +47.463 | +47.663 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT16*327.7 | +47.361 | +47.688 | 7 | 99 | 46.1 | 0 | 16.9 | 0.8 | 327.7 | 16 | 1176.6 | pe-186 | 0.781054 | 0.385527 | 0.000256 | 0.00587878 | 0.00587878
PLATE | PLT16*350.5 | +28.374 | +28.724 | 6 | 99 | 11.6 | 0 | 17.7 | 0.2 | 350.4 | 16 | 352.1 | pd-147 | 0.205187 | 0.123402 | 0.000256 | 0.00148765 | 0.00148765
2 x PLATE | PLT10*94.5 | +48.011 | +48.193 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT16*352 | +51.153 | +51.505 | 8 | 99 | 14.7 | 0 | 17.5 | 0.3 | 352 | 16 | 440.6 | pf-240 | 0.254125 | 0.155085 | 0.000256 | 0.00185807 | 0.00185807
2 x PLATE | PLT10*94.5 | +52.347 | +52.523 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT16*352 | +52.332 | +52.684 | 8 | 99 | 14.7 | 0 | 17.5 | 0.3 | 352 | 16 | 440.6 | pf-240 | 0.254124 | 0.155084 | 0.000256 | 0.00185806 | 0.00185806
PLATE | PLT16*349.4 | +55.305 | +55.655 | 8 | 99 | 11.6 | 0 | 17.7 | 0.2 | 349.4 | 16 | 350.2 | pf-237 | 0.203655 | 0.122337 | 0.000256 | 0.00147602 | 0.00147602
PLATE | PLT16*352.9 | +54.596 | +54.949 | 8 | 99 | 12.9 | 0 | 17.5 | 0.2 | 353 | 16 | 390.4 | pf-239 | 0.226542 | 0.137761 | 0.000256 | 0.00164956 | 0.00164956
2 x PLATE | PLT16*350.1 | +53.040 | +53.390 | 8 | 99 | 15.6 | 0 | 17.5 | 0.3 | 350.1 | 16 | 472.9 | pf-233 | 0.271683 | 0.165544 | 0.000256 | 0.00199055 | 0.00199055
PLATE | PLT10*94.5 | +54.616 | +54.797 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | PLT16*350.1 | +54.599 | +54.949 | 8 | 99 | 37.6 | 0 | 16.9 | 0.6 | 350.1 | 16 | 945.8 | pf-269 | 0.637518 | 0.331089 | 0.000256 | 0.00479365 | 0.00479365
PLATE | PLT16*341.6 | +58.020 | +58.369 | 8 | 99 | 11.3 | 0 | 17.7 | 0.2 | 341.6 | 16 | 349.3 | pf-238 | 0.19927 | 0.119292 | 0.000256 | 0.00144269 | 0.00144269
PLATE | PLT16*349.9 | +57.314 | +57.664 | 8 | 99 | 11.6 | 0 | 17.7 | 0.2 | 349.9 | 16 | 350.2 | pf-237 | 0.203942 | 0.122511 | 0.000256 | 0.0014782 | 0.0014782
PLATE | PLT16*342.1 | +60.134 | +60.483 | 8 | 99 | 11.3 | 0 | 17.7 | 0.2 | 342.1 | 16 | 349.3 | pf-238 | 0.199543 | 0.119457 | 0.000256 | 0.00144477 | 0.00144477
2 x PLATE | PLT10*94.5 | +69.952 | +70.118 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL12*80 | +47.017 | +47.349 | 7 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pe-45 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
6 x PLATE | PLT10*94.5 | +69.960 | +70.141 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +69.840 | +70.269 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*350.3 | +69.944 | +70.294 | 8 | 99 | 15.5 | 0 | 17.5 | 0.3 | 350.3 | 16 | 469.2 | pf-227 | 0.269697 | 0.164379 | 0.000256 | 0.00197557 | 0.00197557
6 x PLATE | PLT10*94.5 | +66.403 | +66.584 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +66.275 | +66.705 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*350.3 | +66.250 | +66.600 | 8 | 99 | 15.5 | 0 | 17.5 | 0.3 | 350.3 | 16 | 469.2 | pf-227 | 0.269701 | 0.164381 | 0.000256 | 0.0019756 | 0.0019756
2 x PLATE | PLT10*94.5 | +65.528 | +65.716 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +65.420 | +65.830 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*318 | +65.509 | +65.877 | 8 | 99 | 12.4 | 0 | 17.5 | 0.2 | 318 | 16 | 368.8 | pf-246 | 0.215088 | 0.117251 | 0.000256 | 0.00156394 | 0.00156394
2 x PLATE | PLT10*94.5 | +63.589 | +63.777 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +63.475 | +63.884 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*346 | +63.450 | +63.796 | 8 | 99 | 17.3 | 0 | 17.3 | 0.3 | 346 | 16 | 525.1 | pf-247 | 0.299828 | 0.181688 | 0.000256 | 0.00220262 | 0.00220262
6 x PLATE | PLT10*94.5 | +62.754 | +62.924 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +62.617 | +63.069 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.9 | +62.741 | +63.094 | 8 | 99 | 13.7 | 0 | 17.5 | 0.2 | 353 | 16 | 413.5 | pf-229 | 0.239318 | 0.14594 | 0.000256 | 0.00174621 | 0.00174621
6 x PLATE | PLT10*94.5 | +58.191 | +58.361 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +58.045 | +58.498 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.9 | +58.020 | +58.373 | 8 | 99 | 13.7 | 0 | 17.5 | 0.2 | 353 | 16 | 413.5 | pf-229 | 0.239318 | 0.14594 | 0.000256 | 0.00174621 | 0.00174621
2 x PLATE | PLT10*94.5 | +57.314 | +57.503 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +57.210 | +57.613 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*314.1 | +57.294 | +57.648 | 8 | 99 | 11.6 | 0 | 17.7 | 0.2 | 314.1 | 16 | 354.2 | pf-248 | 0.205755 | 0.111261 | 0.000256 | 0.00149294 | 0.00149294
5 x PLATE | PLT10*94.5 | +54.646 | +54.845 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +54.570 | +54.924 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*328.8 | +54.621 | +54.949 | 8 | 99 | 26.4 | 0 | 17.2 | 0.5 | 328.8 | 16 | 774.8 | pf-249 | 0.454204 | 0.254741 | 0.000256 | 0.00337082 | 0.00337082
2 x PLATE | PLT10*94.5 | +55.440 | +55.629 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +55.330 | +55.733 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*344.2 | +55.305 | +55.649 | 8 | 99 | 18.5 | 0 | 17.3 | 0.3 | 344.2 | 16 | 546.2 | pf-250 | 0.32006 | 0.188021 | 0.000256 | 0.00235734 | 0.00235734
6 x PLATE | PLT10*94.5 | +52.351 | +52.532 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +52.231 | +52.659 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
3 x PLATE | PLT16*350 | +52.334 | +52.684 | 8 | 99 | 15.6 | 0 | 17.5 | 0.3 | 349.9 | 16 | 473.3 | pf-233 | 0.271885 | 0.165663 | 0.000256 | 0.00199207 | 0.00199207
4 x PLATE | PLT10*94.5 | +53.145 | +53.343 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +53.065 | +53.419 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*328.8 | +53.040 | +53.369 | 8 | 99 | 24.4 | 0 | 17.2 | 0.3 | 328.8 | 16 | 756.6 | pf-251 | 0.422542 | 0.248777 | 0.000256 | 0.00312536 | 0.00312536
6 x PLATE | PLT10*94.5 | +48.852 | +49.034 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +48.725 | +49.153 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*350 | +48.700 | +49.050 | 7 | 99 | 16.2 | 0 | 17.5 | 0.3 | 349.9 | 16 | 473.3 | pe-150 | 0.278863 | 0.165664 | 0.000256 | 0.00204631 | 0.00204631
6 x PLATE | PLT10*94.5 | +48.013 | +48.196 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +47.897 | +48.319 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
3 x PLATE | PLT16*348.9 | +47.995 | +48.344 | 7 | 99 | 16.2 | 0 | 17.5 | 0.3 | 348.9 | 16 | 488.7 | pe-146 | 0.280227 | 0.170513 | 0.000256 | 0.00205496 | 0.00205496
6 x PLATE | PLT10*94.5 | +44.723 | +44.907 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +44.600 | +45.022 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
3 x PLATE | PLT16*348.9 | +44.575 | +44.924 | 7 | 99 | 16.2 | 0 | 17.5 | 0.3 | 348.9 | 16 | 488.7 | pe-146 | 0.280227 | 0.170513 | 0.000256 | 0.00205496 | 0.00205496
6 x PLATE | PLT10*94.5 | +43.878 | +44.047 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +43.740 | +44.194 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
3 x PLATE | PLT16*353 | +43.866 | +44.219 | 7 | 99 | 13.7 | 0 | 17.5 | 0.2 | 353 | 16 | 408.9 | pe-145 | 0.236758 | 0.144324 | 0.000256 | 0.00172686 | 0.00172686
6 x PLATE | PLT10*94.5 | +39.210 | +39.379 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +39.063 | +39.518 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
3 x PLATE | PLT16*353 | +39.038 | +39.391 | 7 | 99 | 13.7 | 0 | 17.5 | 0.2 | 353 | 16 | 408.9 | pe-145 | 0.236758 | 0.144324 | 0.000256 | 0.00172686 | 0.00172686
2 x PLATE | PLT10*94.5 | +38.326 | +38.515 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +38.221 | +38.626 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*315.5 | +38.306 | +38.665 | 7 | 99 | 11.9 | 0 | 17.5 | 0.2 | 315.4 | 16 | 359.1 | pe-149 | 0.208937 | 0.11329 | 0.000256 | 0.00151715 | 0.00151715
2 x PLATE | PLT10*94.5 | +36.406 | +36.595 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +36.295 | +36.700 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*344.8 | +36.270 | +36.615 | 6 | 99 | 17.6 | 0 | 17.3 | 0.3 | 344.7 | 16 | 538.7 | pd-142 | 0.307088 | 0.185765 | 0.000256 | 0.00225728 | 0.00225728
6 x PLATE | PLT10*94.5 | +35.579 | +35.758 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +35.456 | +35.889 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*350.9 | +35.563 | +35.914 | 6 | 99 | 15.1 | 0 | 17.5 | 0.3 | 350.9 | 16 | 459.9 | pd-135 | 0.26463 | 0.161387 | 0.000256 | 0.00193735 | 0.00193735
6 x PLATE | PLT10*94.5 | +31.884 | +32.063 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +31.753 | +32.187 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*350.9 | +31.728 | +32.079 | 6 | 99 | 15.1 | 0 | 17.5 | 0.3 | 350.9 | 16 | 459.9 | pd-135 | 0.264629 | 0.161387 | 0.000256 | 0.00193735 | 0.00193735
2 x PLATE | PLT10*94.5 | +31.021 | +31.211 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +30.918 | +31.320 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*314.2 | +31.001 | +31.355 | 6 | 99 | 11.6 | 0 | 17.7 | 0.2 | 314.2 | 16 | 354.2 | pd-141 | 0.20584 | 0.111315 | 0.000256 | 0.00149358 | 0.00149358
2 x PLATE | PLT10*94.5 | +29.215 | +29.404 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +29.105 | +29.508 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*344.2 | +29.080 | +29.424 | 6 | 99 | 18 | 0 | 17.3 | 0.3 | 344.2 | 16 | 546 | pd-140 | 0.311018 | 0.18796 | 0.000256 | 0.00228686 | 0.00228686
6 x PLATE | PLT10*94.5 | +28.387 | +28.565 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +28.261 | +28.699 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
3 x PLATE | PLT16*351.7 | +28.373 | +28.724 | 6 | 99 | 14.7 | 0 | 17.5 | 0.3 | 351.8 | 16 | 446.8 | pd-133 | 0.257515 | 0.157134 | 0.000256 | 0.00188367 | 0.00188367
2 x PLATE | PLT10*94.5 | +38.347 | +38.540 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +38.252 | +38.641 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*332.3 | +38.326 | +38.665 | 7 | 99 | 12.1 | 0 | 17.5 | 0.2 | 332.3 | 16 | 339.8 | pe-148 | 0.211259 | 0.112915 | 0.000256 | 0.00153538 | 0.00153538
2 x PLATE | PLT10*94.5 | +57.335 | +57.528 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +57.241 | +57.628 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*330.7 | +57.313 | +57.647 | 8 | 99 | 11.9 | 0 | 17.5 | 0.2 | 330.7 | 16 | 334.4 | pf-256 | 0.207665 | 0.110574 | 0.000256 | 0.00150792 | 0.00150792
2 x PLATE | PLT10*94.5 | +31.039 | +31.233 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +30.946 | +31.331 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*339.1 | +31.016 | +31.355 | 6 | 99 | 12.9 | 0 | 17.5 | 0.2 | 339.1 | 16 | 354.5 | pd-139 | 0.225767 | 0.120184 | 0.000256 | 0.00164611 | 0.00164611
2 x PLATE | PLT10*94.5 | +65.568 | +65.760 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +65.471 | +65.862 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*307.7 | +65.546 | +65.878 | 8 | 99 | 10.9 | 0 | 17.7 | 0.2 | 307.8 | 16 | 331.5 | pf-252 | 0.191198 | 0.101997 | 0.000256 | 0.00138214 | 0.00138214
2 x PLATE | PLT8*132.2 | +26.240 | +26.406 | 6 | 8 | 1.5 | 0 | 35.3 | 0 | 132.2 | 8 | 166 | pd-169 | 0.0483663 | 0.0219452 | 0.000064 | 0.000174662 | 0.000174662
2 x PLATE | PLT10*94.5 | +63.577 | +63.769 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +63.475 | +63.866 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*340.9 | +63.450 | +63.791 | 8 | 99 | 18.3 | 0 | 17.3 | 0.3 | 340.9 | 16 | 559 | pf-253 | 0.316877 | 0.190552 | 0.000256 | 0.00233038 | 0.00233038
2 x PLATE | PLT16*352.9 | +62.741 | +63.094 | 8 | 99 | 13.7 | 0 | 17.5 | 0.2 | 353 | 16 | 413.5 | pf-229 | 0.23933 | 0.145948 | 0.000256 | 0.0017463 | 0.0017463
2 x PLATE | PLT16*352.9 | +58.020 | +58.373 | 8 | 99 | 13.7 | 0 | 17.5 | 0.2 | 353 | 16 | 412.9 | pf-229 | 0.238933 | 0.145707 | 0.000256 | 0.00174329 | 0.00174329
2 x PLATE | PLT10*94.5 | +55.430 | +55.623 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +55.330 | +55.717 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*339.8 | +55.305 | +55.645 | 8 | 99 | 18.6 | 0 | 17.3 | 0.3 | 339.8 | 16 | 572.5 | pf-254 | 0.324091 | 0.194527 | 0.000256 | 0.00238467 | 0.00238467
PLATE | PLT10*94.5 | +54.646 | +54.845 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | PLT16*328.8 | +54.621 | +54.949 | 8 | 99 | 25.1 | 0 | 17.2 | 0.3 | 328.8 | 16 | 774.8 | pf-255 | 0.432709 | 0.254741 | 0.000256 | 0.00320209 | 0.00320209
2 x PLATE | PLT16*350 | +48.700 | +49.050 | 7 | 99 | 15.6 | 0 | 17.5 | 0.3 | 349.9 | 16 | 473.3 | pe-147 | 0.271886 | 0.165664 | 0.000256 | 0.00199208 | 0.00199208
2 x PLATE | PLT10*94.5 | +36.396 | +36.589 | 7 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pe-70 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +36.295 | +36.685 | 7 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pe-165 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*340.6 | +36.270 | +36.611 | 6 | 99 | 19.2 | 0 | 17.3 | 0.3 | 340.6 | 16 | 589 | pd-138 | 0.333952 | 0.200648 | 0.000256 | 0.00245944 | 0.00245944
PLATE | PLT16*350.9 | +35.563 | +35.914 | 6 | 99 | 15.1 | 0 | 17.5 | 0.3 | 350.9 | 16 | 459.9 | pd-135 | 0.264629 | 0.161387 | 0.000256 | 0.00193735 | 0.00193735
