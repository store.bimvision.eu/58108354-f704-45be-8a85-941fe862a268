Properties of the parts of a building model (IFC2X3), part 15 of 22

# IfcDiscreteAccessory: PLATE (5205)
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
6 x PLATE | PLT10*94.5 | +15.856 | +16.035 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +15.856 | +16.035 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
4 x PLATE | FL16*250 | +15.725 | +16.158 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
4 x PLATE | PLT16*350.9 | +15.700 | +16.051 | 4 | 99 | 15.1 | 0 | 17.5 | 0.3 | 350.9 | 16 | 460.5 | pb-168 | 0.264974 | 0.161591 | 0.000256 | 0.00193995 | 0.00193995
8 x PLATE | PLT10*94.5 | +17.359 | +17.539 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +17.236 | +17.669 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*350.9 | +17.344 | +17.694 | 4 | 99 | 36.5 | 0 | 16.9 | 0.6 | 350.9 | 16 | 921 | pb-189 | 0.619435 | 0.323181 | 0.000256 | 0.00465562 | 0.00465562
7 x PLATE | PLT10*94.5 | +23.621 | +23.789 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT10*94.5 | +23.621 | +23.789 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
4 x PLATE | FL16*250 | +23.482 | +23.937 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353 | +23.609 | +23.962 | 4 | 99 | 13.5 | 0 | 17.5 | 0.2 | 353 | 16 | 406.4 | pb-171 | 0.235402 | 0.143464 | 0.000256 | 0.0017166 | 0.0017166
PLATE | PLT16*353 | +23.609 | +23.962 | 4 | 99 | 13.5 | 0 | 17.5 | 0.2 | 353 | 16 | 406 | pb-171 | 0.235184 | 0.143325 | 0.000256 | 0.00171495 | 0.00171495
2 x PLATE | PLT10*94.5 | +28.381 | +28.511 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +28.207 | +28.697 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-127 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
6 x PLATE | PLT10*94.5 | +28.382 | +28.511 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT16*342.7 | +28.382 | +28.724 | 6 | 99 | 25 | 0 | 17.2 | 0.3 | 342.8 | 16 | 680.9 | pd-117 | 0.426145 | 0.233352 | 0.000256 | 0.00317472 | 0.00317472
8 x PLATE | PLT10*94.5 | +24.589 | +24.719 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
4 x PLATE | FL16*250 | +24.403 | +24.893 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-127 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*346.6 | +24.318 | +24.719 | 4 | 99 | 14 | 0 | 17.5 | 0.2 | 346.6 | 16 | 400.7 | pb-169 | 0.244094 | 0.138858 | 0.000256 | 0.00178571 | 0.00178571
PLATE | PLT16*346.2 | +24.318 | +24.719 | 4 | 99 | 14 | 0 | 17.5 | 0.2 | 346.2 | 16 | 400.6 | pb-169 | 0.243853 | 0.138692 | 0.000256 | 0.00178386 | 0.00178386
4 x PLATE | PLT10*94.5 | +23.618 | +23.764 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +23.456 | +23.937 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*337.6 | +23.614 | +23.962 | 4 | 99 | 11.1 | 0 | 17.7 | 0.2 | 337.6 | 16 | 348.5 | pb-224 | 0.197004 | 0.117663 | 0.000256 | 0.00142547 | 0.00142547
4 x PLATE | PLT10*94.5 | +21.658 | +21.804 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +21.485 | +21.966 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*337.6 | +21.460 | +21.809 | 4 | 99 | 11.1 | 0 | 17.7 | 0.2 | 337.6 | 16 | 348.5 | pb-224 | 0.197004 | 0.117663 | 0.000256 | 0.00142547 | 0.00142547
2 x PLATE | PLT10*94.5 | +24.495 | +24.660 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +24.495 | +24.660 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +24.343 | +24.803 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*353 | +24.318 | +24.671 | 4 | 99 | 13.1 | 0 | 17.5 | 0.2 | 353 | 16 | 395.9 | pb-225 | 0.229593 | 0.139747 | 0.000256 | 0.00167265 | 0.00167265
2 x PLATE | PLT10*94.5 | +18.208 | +18.386 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +18.208 | +18.386 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +18.075 | +18.512 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*351.4 | +18.050 | +18.401 | 4 | 99 | 14.9 | 0 | 17.5 | 0.3 | 351.5 | 16 | 451.5 | pb-222 | 0.260097 | 0.158685 | 0.000256 | 0.00190315 | 0.00190315
PLATE | PLT10*94.5 | +20.770 | +20.952 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | PLT10*94.5 | +20.770 | +20.952 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +20.650 | +21.079 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*350.2 | +20.754 | +21.104 | 4 | 99 | 15.6 | 0 | 17.5 | 0.3 | 350.3 | 16 | 470.9 | pb-223 | 0.270657 | 0.164943 | 0.000256 | 0.00198281 | 0.00198281
2 x PLATE | PLT10*94.5 | +10.783 | +10.934 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +10.783 | +10.934 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +10.615 | +11.092 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*350.5 | +10.590 | +10.941 | 3 | 99 | 11.6 | 0 | 17.7 | 0.2 | 350.4 | 16 | 352.6 | pa-169 | 0.205449 | 0.123583 | 0.000256 | 0.00148964 | 0.00148964
6 x PLATE | PLT10*94.5 | +17.351 | +17.512 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +17.203 | +17.669 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.6 | +17.342 | +17.694 | 4 | 99 | 12.6 | 0 | 17.5 | 0.2 | 352.6 | 16 | 379.8 | pb-217 | 0.220665 | 0.133897 | 0.000256 | 0.00160505 | 0.00160505
2 x PLATE | PLT10*94.5 | +5.889 | +6.044 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | PLT10*94.5 | +5.889 | +6.044 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +5.725 | +6.198 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*351.4 | +5.700 | +6.051 | 3 | 99 | 11.9 | 0 | 17.5 | 0.2 | 351.5 | 16 | 361.6 | pa-167 | 0.210533 | 0.12708 | 0.000256 | 0.00152823 | 0.00152823
4 x PLATE | PLT10*94.5 | +9.890 | +10.049 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +9.740 | +10.209 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.1 | +9.882 | +10.234 | 3 | 99 | 12.4 | 0 | 17.5 | 0.2 | 352.1 | 16 | 370.9 | pa-168 | 0.215734 | 0.130604 | 0.000256 | 0.00156767 | 0.00156767
4 x PLATE | PLT10*94.5 | +0.378 | +0.532 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +0.213 | +0.687 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*349.2 | +0.040 | +0.539 | 3 | 99 | 15.1 | 0 | 17.5 | 0.3 | 349.2 | 16 | 498.8 | pa-164 | 0.264167 | 0.174199 | 0.000256 | 0.00193023 | 0.00193023
4 x PLATE | PLT10*94.5 | +4.986 | +5.128 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +4.820 | +5.304 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*341.8 | +4.982 | +5.344 | 3 | 99 | 11.9 | 0 | 17.5 | 0.2 | 341.8 | 16 | 362 | pa-166 | 0.209481 | 0.123719 | 0.000256 | 0.0015208 | 0.0015208
4 x PLATE | PLT10*94.5 | +15.000 | +15.155 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +14.846 | +15.319 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*351.4 | +14.993 | +15.344 | 4 | 99 | 11.9 | 0 | 17.7 | 0.2 | 351.5 | 16 | 361.1 | pb-220 | 0.21025 | 0.126887 | 0.000256 | 0.00152608 | 0.00152608
4 x PLATE | PLT10*94.5 | +15.883 | +16.044 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
3 x PLATE | FL16*250 | +15.725 | +16.191 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.6 | +15.700 | +16.053 | 4 | 99 | 12.6 | 0 | 17.5 | 0.2 | 352.6 | 16 | 379.8 | pb-217 | 0.220665 | 0.133897 | 0.000256 | 0.00160505 | 0.00160505
4 x PLATE | PLT10*94.5 | +19.167 | +19.345 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +19.042 | +19.478 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*351.4 | +19.152 | +19.503 | 4 | 99 | 14.9 | 0 | 17.5 | 0.3 | 351.5 | 16 | 451.5 | pb-222 | 0.260097 | 0.158685 | 0.000256 | 0.00190315 | 0.00190315
4 x PLATE | PLT10*94.5 | +19.908 | +20.089 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +19.780 | +20.209 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*350.2 | +19.755 | +20.105 | 4 | 99 | 15.6 | 0 | 17.5 | 0.3 | 350.3 | 16 | 470.9 | pb-223 | 0.270657 | 0.164943 | 0.000256 | 0.00198281 | 0.00198281
4 x PLATE | PLT10*94.5 | +25.821 | +25.987 | 6 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pd-52 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +25.679 | +26.138 | 6 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pd-121 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*353 | +25.811 | +26.164 | 6 | 99 | 13.1 | 0 | 17.5 | 0.2 | 353 | 16 | 396.2 | pd-132 | 0.229747 | 0.13984 | 0.000256 | 0.00167382 | 0.00167382
4 x PLATE | PLT10*94.5 | +2.917 | +3.059 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +2.740 | +3.224 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*341.8 | +2.700 | +3.062 | 3 | 99 | 11.9 | 0 | 17.5 | 0.2 | 341.8 | 16 | 362 | pa-166 | 0.209481 | 0.123719 | 0.000256 | 0.0015208 | 0.0015208
4 x PLATE | PLT10*94.5 | +2.104 | +2.258 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +1.949 | +2.423 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*351.1 | +2.097 | +2.449 | 3 | 99 | 11.9 | 0 | 17.7 | 0.2 | 351.1 | 16 | 358.4 | pa-165 | 0.208755 | 0.125863 | 0.000256 | 0.00151474 | 0.00151474
4 x PLATE | PLT10*94.5 | +7.549 | +7.704 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +7.395 | +7.868 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*351.4 | +7.542 | +7.893 | 3 | 99 | 11.9 | 0 | 17.5 | 0.2 | 351.5 | 16 | 361.6 | pa-167 | 0.210533 | 0.12708 | 0.000256 | 0.00152823 | 0.00152823
2 x PLATE | PLT10*94.5 | +8.331 | +8.489 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +8.331 | +8.489 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +8.170 | +8.640 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*352.1 | +8.145 | +8.497 | 3 | 99 | 12.4 | 0 | 17.5 | 0.2 | 352.1 | 16 | 370.9 | pa-168 | 0.215734 | 0.130605 | 0.000256 | 0.00156768 | 0.00156768
4 x PLATE | PLT10*94.5 | +13.334 | +13.489 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +13.170 | +13.643 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*351.4 | +13.145 | +13.496 | 4 | 99 | 11.9 | 0 | 17.7 | 0.2 | 351.5 | 16 | 361.1 | pb-220 | 0.21025 | 0.126887 | 0.000256 | 0.00152608 | 0.00152608
4 x PLATE | PLT10*94.5 | +12.549 | +12.701 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +12.392 | +12.868 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*350.5 | +12.543 | +12.893 | 4 | 99 | 11.6 | 0 | 17.7 | 0.2 | 350.4 | 16 | 352.6 | pb-221 | 0.205449 | 0.123583 | 0.000256 | 0.00148964 | 0.00148964
PLATE | PLT16*353 | +23.609 | +23.962 | 4 | 99 | 13.5 | 0 | 17.5 | 0.2 | 353 | 16 | 406.2 | pb-171 | 0.235293 | 0.143394 | 0.000256 | 0.00171577 | 0.00171577
PLATE | PLT16*353 | +23.609 | +23.962 | 4 | 99 | 13.5 | 0 | 17.5 | 0.2 | 353 | 16 | 406.2 | pb-171 | 0.235293 | 0.143394 | 0.000256 | 0.00171578 | 0.00171578
4 x PLATE | PLT10*94.5 | +20.760 | +20.917 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +20.608 | +21.079 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT16*351.7 | +20.753 | +21.104 | 4 | 99 | 12.1 | 0 | 17.5 | 0.2 | 351.8 | 16 | 365.4 | pb-170 | 0.212667 | 0.128533 | 0.000256 | 0.00154442 | 0.00154442
3 x PLATE | PLT10*94.5 | +18.238 | +18.394 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT10*94.5 | +18.238 | +18.394 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +18.075 | +18.547 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*351.7 | +18.050 | +18.402 | 4 | 99 | 27.7 | 0 | 16.9 | 0.5 | 351.8 | 16 | 730.9 | pb-191 | 0.472548 | 0.257065 | 0.000256 | 0.00353179 | 0.00353179
2 x PLATE | PLT10*94.5 | +21.633 | +21.802 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | PLT16*353 | +21.460 | +21.813 | 4 | 99 | 31.6 | 0 | 16.9 | 0.5 | 353 | 16 | 812.4 | pb-190 | 0.537296 | 0.286788 | 0.000256 | 0.00402771 | 0.00402771
PLATE | PLT16*346.4 | +24.318 | +24.719 | 4 | 99 | 14 | 0 | 17.5 | 0.2 | 346.4 | 16 | 400.6 | pb-169 | 0.243973 | 0.138775 | 0.000256 | 0.00178479 | 0.00178479
PLATE | PLT16*346.4 | +24.318 | +24.719 | 4 | 99 | 14 | 0 | 17.5 | 0.2 | 346.4 | 16 | 400.6 | pb-169 | 0.243973 | 0.138775 | 0.000256 | 0.00178478 | 0.00178478
PLATE | PLT16*342.7 | +28.382 | +28.724 | 6 | 99 | 25 | 0 | 17.2 | 0.3 | 342.8 | 16 | 680.9 | pd-117 | 0.426117 | 0.233315 | 0.000256 | 0.0031745 | 0.0031745
4 x PLATE | PLT10*94.5 | +9.894 | +10.021 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +9.718 | +10.209 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*338.9 | +9.895 | +10.234 | 3 | 99 | 26.9 | 0 | 17.2 | 0.5 | 339 | 16 | 735.1 | pa-143 | 0.460261 | 0.249149 | 0.000256 | 0.00343444 | 0.00343444
4 x PLATE | PLT10*94.5 | +5.978 | +6.105 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +5.790 | +6.281 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*342.5 | +5.700 | +6.104 | 3 | 99 | 14 | 0 | 17.5 | 0.2 | 342.5 | 16 | 403.9 | pa-203 | 0.242913 | 0.138338 | 0.000256 | 0.00177636 | 0.00177636
PLATE | PLT16*342.5 | +5.700 | +6.104 | 3 | 99 | 14 | 0 | 17.5 | 0.2 | 342.5 | 16 | 403.9 | pa-203 | 0.242952 | 0.138367 | 0.000256 | 0.00177667 | 0.00177667
8 x PLATE | PLT20*140 | +2.395 | +2.415 | 3 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pa-42 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
8 x PLATE | PLT20*140 | +2.730 | +2.750 | 3 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pa-42 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
4 x PLATE | PLT10*94.5 | +2.057 | +2.176 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +1.877 | +2.369 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*334.2 | +2.060 | +2.394 | 3 | 99 | 12.6 | 0 | 17.7 | 0.2 | 334.2 | 16 | 443.1 | pa-202 | 0.222307 | 0.148084 | 0.000256 | 0.00161106 | 0.00161106
3 x PLATE | PLT10*94.5 | +2.968 | +3.087 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +2.775 | +3.268 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*334.2 | +2.750 | +3.084 | 3 | 99 | 12.6 | 0 | 17.7 | 0.2 | 334.2 | 16 | 443.1 | pa-202 | 0.222307 | 0.148084 | 0.000256 | 0.00161106 | 0.00161106
PLATE | PLT16*334.2 | +2.060 | +2.394 | 3 | 99 | 12.6 | 0 | 17.7 | 0.2 | 334.2 | 16 | 443 | pa-202 | 0.222285 | 0.148061 | 0.000256 | 0.0016109 | 0.0016109
PLATE | PLT10*94.5 | +2.968 | +3.087 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | PLT16*334.2 | +2.750 | +3.084 | 3 | 99 | 12.6 | 0 | 17.7 | 0.2 | 334.2 | 16 | 443 | pa-202 | 0.222285 | 0.148061 | 0.000256 | 0.0016109 | 0.0016109
2 x PLATE | PLT10*94.5 | +0.618 | +0.737 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192427 | 0.0001 | 0.000145656 | 0.000328269
6 x PLATE | PLT8*47.2 | +5.614 | +5.691 | 3 | 8 | 0.2 | 0 | 40.5 | 0 | 47.2 | 8 | 77.5 | pa-229 | 0.00901591 | 0.003658 | 0.000064 | 0.000028364 | 0.000028364
2 x PLATE | PLT8*74.5 | +5.614 | +5.689 | 3 | 8 | 0.4 | 0 | 38.3 | 0 | 74.5 | 8 | 82.1 | pa-228 | 0.0144432 | 0.00611645 | 0.000064 | 0.0000480316 | 0.0000480316
PLATE | PLT20*140 | +2.395 | +2.415 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pc-54 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
PLATE | PLT20*140 | +2.730 | +2.750 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276.2 | pc-54 | 0.0921482 | 0.038668 | 0.0004 | 0.00076086 | 0.00076086
2 x PLATE | PLT10*94.5 | +15.809 | +16.007 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +15.725 | +16.087 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*331.6 | +15.700 | +16.032 | 4 | 99 | 23.1 | 0 | 17.2 | 0.3 | 331.6 | 16 | 711.4 | pb-219 | 0.398702 | 0.235883 | 0.000256 | 0.00294622 | 0.00294622
PLATE | PLT10*94.5 | +17.387 | +17.585 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | PLT10*94.5 | +17.387 | +17.585 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +17.308 | +17.669 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*331.6 | +17.363 | +17.694 | 4 | 99 | 23.3 | 0 | 17.2 | 0.3 | 331.6 | 16 | 715.5 | pb-218 | 0.400955 | 0.237209 | 0.000256 | 0.00296323 | 0.00296323
PLATE | PLT20*140 | +15.345 | +15.365 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
PLATE | PLT16*352.6 | +17.342 | +17.694 | 4 | 99 | 12.6 | 0 | 17.5 | 0.2 | 352.6 | 16 | 380.1 | pb-217 | 0.220856 | 0.134024 | 0.000256 | 0.0016065 | 0.0016065
PLATE | PLT20*140 | +15.680 | +15.700 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
2 x PLATE | PLT10*94.5 | +15.882 | +16.044 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT16*352.6 | +15.700 | +16.053 | 4 | 99 | 12.4 | 0 | 17.5 | 0.2 | 352.6 | 16 | 376.1 | pb-216 | 0.218531 | 0.132614 | 0.000256 | 0.00158881 | 0.00158881
2 x PLATE | PLT10*94.5 | +15.004 | +15.175 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +14.869 | +15.319 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.8 | +14.992 | +15.344 | 4 | 99 | 13.7 | 0 | 17.5 | 0.2 | 352.8 | 16 | 414 | pb-167 | 0.239423 | 0.146056 | 0.000256 | 0.00174693 | 0.00174693
2 x PLATE | PLT10*94.5 | +10.759 | +10.930 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +10.615 | +11.066 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-183 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.8 | +10.590 | +10.943 | 3 | 99 | 13.7 | 0 | 17.5 | 0.2 | 352.8 | 16 | 414 | pa-200 | 0.239423 | 0.146057 | 0.000256 | 0.00174693 | 0.00174693
PLATE | PLT20*140 | +10.235 | +10.255 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
PLATE | PLT20*140 | +10.570 | +10.590 | 5 | 99 | 5.9 | 0 | 15.4 | 0.1 | 140 | 20 | 276 | pc-54 | 0.0920842 | 0.03864 | 0.0004 | 0.0007603 | 0.0007603
PLATE | PLT10*94.5 | +5.848 | +6.031 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | PLT20*147.4 | +5.345 | +5.365 | 3 | 99 | 6.3 | 0 | 15.4 | 0.1 | 147.3 | 20 | 276.2 | pa-43 | 0.0965616 | 0.0407257 | 0.0004 | 0.000802014 | 0.000802014
4 x PLATE | PLT10*94.5 | +5.924 | +6.069 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +5.750 | +6.232 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-211 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*354.9 | +5.700 | +6.073 | 5 | 99 | 12.9 | 0 | 17.5 | 0.2 | 355 | 16 | 373.3 | pc-259 | 0.224745 | 0.132488 | 0.000256 | 0.00163742 | 0.00163742
2 x PLATE | PLT10*94.5 | +2.931 | +3.093 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +2.775 | +3.240 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-211 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.7 | +2.750 | +3.103 | 5 | 99 | 12.6 | 0 | 17.5 | 0.2 | 352.8 | 16 | 379 | pc-260 | 0.220126 | 0.133668 | 0.000256 | 0.0016009 | 0.0016009
PLATE | PLT10*94.5 | +2.932 | +3.093 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | PLT10*94.5 | +2.932 | +3.093 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT16*352.7 | +2.750 | +3.103 | 5 | 99 | 12.4 | 0 | 17.5 | 0.2 | 352.8 | 16 | 378.2 | pc-260 | 0.219771 | 0.133434 | 0.000256 | 0.00159821 | 0.00159821
4 x PLATE | PLT10*94.5 | +2.926 | +3.092 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | FL16*250 | +2.775 | +3.234 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353 | +2.750 | +3.103 | 3 | 99 | 13.1 | 0 | 17.5 | 0.2 | 353 | 16 | 394.6 | pa-198 | 0.228794 | 0.139315 | 0.000256 | 0.00166653 | 0.00166653
PLATE | PLT16*338.4 | +5.700 | +6.187 | 3 | 99 | 17.8 | 0 | 17.3 | 0.3 | 338.4 | 16 | 486.7 | pa-163 | 0.307131 | 0.164681 | 0.000256 | 0.00226695 | 0.00226695
2 x PLATE | PLT10*94.5 | +9.746 | +9.848 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +9.557 | +10.049 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*335.8 | +9.753 | +10.234 | 3 | 99 | 17.5 | 0 | 17.3 | 0.3 | 335.8 | 16 | 481.8 | pa-162 | 0.300017 | 0.161753 | 0.000256 | 0.00221204 | 0.00221204
2 x PLATE | PLT10*94.5 | +10.993 | +11.092 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +10.790 | +11.282 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*334.1 | +10.590 | +11.084 | 3 | 99 | 18 | 0 | 17.3 | 0.3 | 334.1 | 16 | 494 | pa-161 | 0.309283 | 0.165045 | 0.000256 | 0.00228278 | 0.00228278
2 x PLATE | PLT10*94.5 | +14.843 | +14.941 | 4 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pb-164 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +14.653 | +15.144 | 4 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pb-237 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*334.1 | +14.850 | +15.344 | 4 | 99 | 18 | 0 | 17.3 | 0.3 | 334.1 | 16 | 494 | pb-215 | 0.309283 | 0.165045 | 0.000256 | 0.00228278 | 0.00228278
2 x PLATE | PLT10*94.5 | +4.976 | +5.115 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +4.809 | +5.294 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*339.4 | +4.974 | +5.344 | 3 | 99 | 12.4 | 0 | 17.5 | 0.2 | 339.5 | 16 | 370.7 | pa-160 | 0.215206 | 0.125838 | 0.000256 | 0.00156461 | 0.00156461
2 x PLATE | PLT10*94.5 | +2.810 | +2.949 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +2.631 | +3.117 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT10*94.5 | +2.226 | +2.377 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | PLT10*94.5 | +2.226 | +2.377 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +2.068 | +2.546 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.6 | +2.220 | +2.952 | 3 | 99 | 27.7 | 0 | 16.9 | 0.5 | 352.6 | 16 | 731.4 | pa-187 | 0.4736 | 0.257921 | 0.000256 | 0.00353994 | 0.00353994
2 x PLATE | PLT10*94.5 | +5.001 | +5.163 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
2 x PLATE | PLT10*94.5 | +5.001 | +5.163 | 5 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pc-202 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +4.854 | +5.319 | 5 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pc-211 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*352.7 | +4.992 | +5.344 | 5 | 99 | 29.4 | 0 | 16.9 | 0.5 | 352.8 | 16 | 765.3 | pc-212 | 0.500232 | 0.269933 | 0.000256 | 0.00374393 | 0.00374393
3 x PLATE | PLT10*94.5 | +5.002 | +5.169 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT10*94.5 | +5.002 | +5.169 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
2 x PLATE | FL16*250 | +4.861 | +5.319 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-152 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*353 | +4.991 | +5.344 | 3 | 99 | 30.9 | 0 | 16.9 | 0.5 | 353 | 16 | 797.3 | pa-141 | 0.525483 | 0.281454 | 0.000256 | 0.00393729 | 0.00393729
PLATE | PLT16*354.9 | +5.700 | +6.073 | 5 | 99 | 12.9 | 0 | 17.5 | 0.2 | 355 | 16 | 373.3 | pc-259 | 0.224744 | 0.132487 | 0.000256 | 0.00163742 | 0.00163742
PLATE | PLT16*353 | +2.750 | +3.103 | 3 | 99 | 13.1 | 0 | 17.5 | 0.2 | 353 | 16 | 394.6 | pa-198 | 0.228794 | 0.139315 | 0.000256 | 0.00166654 | 0.00166654
2 x PLATE | PLT10*94.5 | +0.396 | +0.547 | 3 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pa-131 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +0.228 | +0.705 | 3 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pa-151 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*350.2 | +0.040 | +0.553 | 3 | 99 | 15.6 | 0 | 17.5 | 0.3 | 350.3 | 16 | 513 | pa-159 | 0.270928 | 0.179661 | 0.000256 | 0.00198096 | 0.00198096

# IfcDiscreteAccessory: PLATFORM ASS. (8)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Phase: 8; Class: 13
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
PLATFORM ASS. | L80*80*8 | +56.610 | +56.690 | 13.3 | 0.1 | 32.3 | 0.3 | 80 | 80 | 1386.4 | mf-162 | 0.431733 | 0.00122675 | 0.00168581 | 0.00170072
2 x PLATFORM ASS. | PC200*75 | +56.600 | +56.800 | 25.5 | 0.1 | 27.8 | 0.6 | 200 | 75 | 1050 | mf-282 | 0.708975 | 0.00309554 | 0.00319095 | 0.00325032
2 x PLATFORM ASS. | L80*80*8 | +56.610 | +56.690 | 13.3 | 0.1 | 32.3 | 0.3 | 80 | 80 | 1387.1 | mf-162 | 0.431958 | 0.00122675 | 0.00168669 | 0.0017016
PLATFORM ASS. | PC200*75 | +56.600 | +56.800 | 29.2 | 0.1 | 27.8 | 0.8 | 200 | 75 | 1200 | mf-281 | 0.810257 | 0.00309554 | 0.0036468 | 0.00371465
PLATFORM ASS. | PC200*75 | +56.600 | +56.800 | 83.4 | 0.3 | 27.8 | 2.5 | 200 | 75 | 3434 | mf-280 | 2.31869 | 0.00309554 | 0.0104359 | 0.0106301
PLATFORM ASS. | PC200*75 | +56.600 | +56.800 | 29.2 | 0.1 | 27.8 | 0.8 | 200 | 75 | 1200 | mf-278 | 0.810257 | 0.00309554 | 0.0036468 | 0.00371465

# IfcDiscreteAccessory: Plate (59)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
Plate | PLT10*147.5 | +55.117 | +55.293 | 8 | 1 | 1.5 | 29.2 | 0 | 147.5 | 10 | 176 | pf-70 | 0.044191 | 0.02596 | 0.0001 | 0.00019255
Plate | FL12*80 | +55.105 | +55.117 | 8 | 1 | 1.3 | 25.9 | 0 | 80 | 12 | 170 | pf-37 | 0.0332 | 0.0136 | 0.000144 | 0.0001632
2 x Plate | FL10*70 | +5.700 | +5.710 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010002 | 0.0142 | 0.0056 | 0.0001 | 0.000056
2 x Plate | FL10*70 | -0.270 | -0.260 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010002 | 0.0142 | 0.0056 | 0.0001 | 0.000056
4 x Plate | FL10*60 | +55.305 | +55.315 | 8 | 8 | 0.4 | 32.9 | 0 | 60 | 10 | 80 | pf-64 | 0.0124 | 0.0048 | 0.0001 | 0.000048
4 x Plate | FL10*60 | +36.270 | +36.280 | 7 | 8 | 0.4 | 32.9 | 0 | 60 | 10 | 80 | pe-68 | 0.0124 | 0.0048 | 0.0001 | 0.000048
2 x Plate | PLT10*82.1 | +35.926 | +36.258 | 6 | 1 | 2.1 | 29.2 | 0.1 | 82.1 | 10 | 332.6 | pd-50 | 0.0622812 | 0.0273065 | 0.0001 | 0.000270815
2 x Plate | FL10*70 | +63.450 | +63.460 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010001 | 0.0142 | 0.0056 | 0.0001 | 0.000056
2 x Plate | FL10*70 | +55.305 | +55.315 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010001 | 0.0142 | 0.0056 | 0.0001 | 0.000056
2 x Plate | FL10*70 | +48.700 | +48.710 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010002 | 0.0142 | 0.0056 | 0.0001 | 0.000056
2 x Plate | FL10*70 | +44.575 | +44.585 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010001 | 0.0142 | 0.0056 | 0.0001 | 0.000056
2 x Plate | FL10*70 | +39.038 | +39.048 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010001 | 0.0142 | 0.0056 | 0.0001 | 0.000056
2 x Plate | FL10*70 | +36.270 | +36.280 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010001 | 0.0142 | 0.0056 | 0.0001 | 0.000056
2 x Plate | FL10*70 | +29.080 | +29.090 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010002 | 0.0142 | 0.0056 | 0.0001 | 0.000056
2 x Plate | PLT16*115 | +17.715 | +17.830 | 4 | 1 | 1.3 | 21.6 | 0 | 115 | 16 | 125 | pb-186 | 0.0255206 | 0.014375 | 0.000256 | 0.0001502
3 x Plate | FL16*100 | +15.244 | +15.344 | 4 | 1 | 1 | 22.5 | 0 | 100 | 16 | 100 | pb-187 | 0.0192502 | 0.01 | 0.000256 | 0.0001088
2 x Plate | FL10*70 | +2.750 | +2.760 | 5 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | pc-124 | 0.0142 | 0.0056 | 0.0001 | 0.000056
4 x Plate | FL10*70 | -0.430 | -0.420 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010002 | 0.0142 | 0.0056 | 0.0001 | 0.000056
2 x Plate | FL10*70 | +21.460 | +21.470 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010002 | 0.0142 | 0.0056 | 0.0001 | 0.000056
2 x Plate | FL10*70 | +15.700 | +15.710 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010002 | 0.0142 | 0.0056 | 0.0001 | 0.000056
Plate | PLT16*126.4 | +5.088 | +5.104 | 3 | 1 | 1.6 | 20.7 | 0 | 126.4 | 16 | 135.3 | pa-139 | 0.0325148 | 0.0171019 | 0.000256 | 0.000200291
Plate | PLT16*126.4 | +4.988 | +5.004 | 3 | 1 | 1.6 | 20.7 | 0 | 126.4 | 16 | 135.3 | pa-139 | 0.0325148 | 0.0171019 | 0.000256 | 0.000200291
Plate | PLT16*126.4 | +7.234 | +7.250 | 3 | 1 | 1.7 | 20.4 | 0 | 126.4 | 16 | 155.3 | pa-138 | 0.0363089 | 0.0196299 | 0.000256 | 0.000226115
Plate | PLT16*126.4 | +6.894 | +6.910 | 3 | 1 | 1.7 | 20.4 | 0 | 126.4 | 16 | 155.3 | pa-138 | 0.0363089 | 0.0196299 | 0.000256 | 0.000226115
Plate | PLT16*126.4 | +9.184 | +9.200 | 3 | 1 | 1.7 | 20.4 | 0 | 126.4 | 16 | 155.3 | pa-138 | 0.0363089 | 0.0196299 | 0.000256 | 0.000226115
Plate | PLT16*126.4 | +8.844 | +8.860 | 3 | 1 | 1.7 | 20.4 | 0 | 126.4 | 16 | 155.3 | pa-138 | 0.0363089 | 0.0196299 | 0.000256 | 0.000226115
Plate | PLT16*126.4 | +11.184 | +11.200 | 3 | 1 | 1.7 | 20.4 | 0 | 126.4 | 16 | 155.3 | pa-138 | 0.0363089 | 0.0196299 | 0.000256 | 0.000226115
2 x Plate | FL10*70 | +5.500 | +5.510 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010000 | 0.0142 | 0.0056 | 0.0001 | 0.000056
2 x Plate | FL10*70 | -0.300 | -0.290 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010002 | 0.0142 | 0.0056 | 0.0001 | 0.000056
2 x Plate | FL10*70 | -0.100 | -0.090 | 1 | 8 | 0.4 | 32.3 | 0 | 70 | 10 | 80 | p010002 | 0.0142 | 0.0056 | 0.0001 | 0.000056
Plate | PLT16*126.4 | +10.844 | +10.860 | 3 | 1 | 1.7 | 20.4 | 0 | 126.4 | 16 | 155.3 | pa-138 | 0.0363089 | 0.0196299 | 0.000256 | 0.000226115

# IfcDiscreteAccessory: RINGS (8)
In: Undefined
Description: ROD25; Material: STEEL/S355JR
Tekla Quantity - Weight: 1.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 21.6 m2; Net surface area: 0 m2; Height: 25 mm; Width: 25 mm; Length: 470 mm
BaseQuantities - NetArea: 0.037431 m2; GrossArea: 0.037431 m2; CrossSectionArea: 0.00046875 m2
Tekla Common - Class: 11
Pset_PlateCommon - LoadBearing: yes
Name | NetVolume (m3) = GrossVolume (m3) | Bottom elevation | Top elevation | Phase | Reference
RINGS | 0.000220313 | +4.565 | +4.590 | 5 | mc-350
RINGS | 0.000220313 | +4.265 | +4.290 | 5 | mc-350
RINGS | 0.000220313 | +3.965 | +3.990 | 5 | mc-350
RINGS | 0.000220313 | +3.665 | +3.690 | 5 | mc-350
RINGS | 0.000220313 | +3.365 | +3.390 | 5 | mc-350
RINGS | 0.000220313 | +3.065 | +3.090 | 5 | mc-350
2 x RINGS | 0.000220312 | -0.135 | -0.110 | 1 | m010018

# IfcDiscreteAccessory: RUNGS (462)
In: Undefined
Description: ROD25; Material: STEEL/S355JR
Tekla Common - Class: 11
Tekla Quantity - Weight: 1.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 21.6 m2; Net surface area: 0 m2; Height: 25 mm; Width: 25 mm; Length: 470 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - NetArea: 0.037431 m2; GrossArea: 0.037431 m2; CrossSectionArea: 0.00046875 m2
Name | Bottom elevation | Top elevation | Phase | Reference | NetVolume (m3) = GrossVolume (m3)
RUNGS | -0.015 | +0.011 | 1 | m010024 | 0.000220312
RUNGS | +0.251 | +0.276 | 1 | m010024 | 0.000220312
RUNGS | +0.515 | +0.540 | 1 | m010024 | 0.000220313
RUNGS | +0.780 | +0.805 | 1 | m010024 | 0.000220313
RUNGS | +1.046 | +1.071 | 1 | m010024 | 0.000220313
RUNGS | +1.311 | +1.335 | 1 | m010024 | 0.000220313
RUNGS | +1.575 | +1.601 | 1 | m010024 | 0.000220313
RUNGS | +1.841 | +1.865 | 1 | m010024 | 0.000220313
RUNGS | +2.106 | +2.131 | 1 | m010024 | 0.000220313
RUNGS | +2.370 | +2.396 | 1 | m010024 | 0.000220313
RUNGS | +2.636 | +2.660 | 1 | m010024 | 0.000220313
RUNGS | +2.901 | +2.926 | 1 | m010024 | 0.000220313
3 x RUNGS | +3.166 | +3.191 | 1 | m010024 | 0.000220313
RUNGS | +3.430 | +3.455 | 1 | m010024 | 0.000220313
RUNGS | +3.696 | +3.720 | 1 | m010024 | 0.000220313
RUNGS | +3.961 | +3.986 | 1 | m010024 | 0.000220313
RUNGS | +4.226 | +4.250 | 1 | m010024 | 0.000220313
RUNGS | +4.490 | +4.516 | 1 | m010024 | 0.000220313
RUNGS | +4.755 | +4.781 | 1 | m010024 | 0.000220313
RUNGS | +5.021 | +5.045 | 1 | m010024 | 0.000220313
RUNGS | +5.285 | +5.311 | 1 | m010024 | 0.000220313
RUNGS | +5.551 | +5.575 | 1 | m010024 | 0.000220313
RUNGS | +7.141 | +7.165 | 1 | m010024 | 0.000220313
RUNGS | +6.875 | +6.901 | 1 | m010024 | 0.000220313
RUNGS | +6.611 | +6.636 | 1 | m010024 | 0.000220313
RUNGS | +6.346 | +6.370 | 1 | m010024 | 0.000220313
RUNGS | +6.080 | +6.106 | 1 | m010024 | 0.000220313
RUNGS | +13.941 | +13.966 | 1 | m010024 | 0.000220313
RUNGS | +13.676 | +13.701 | 1 | m010024 | 0.000220313
RUNGS | +13.411 | +13.435 | 1 | m010024 | 0.000220313
RUNGS | +13.146 | +13.171 | 1 | m010024 | 0.000220313
RUNGS | +12.881 | +12.906 | 1 | m010024 | 0.000220313
RUNGS | +5.990 | +6.016 | 1 | m010024 | 0.000220313
RUNGS | +6.255 | +6.281 | 1 | m010024 | 0.000220313
RUNGS | +6.521 | +6.545 | 1 | m010024 | 0.000220313
RUNGS | +6.785 | +6.811 | 1 | m010024 | 0.000220313
RUNGS | +7.051 | +7.075 | 1 | m010024 | 0.000220313
RUNGS | +7.316 | +7.340 | 1 | m010024 | 0.000220313
RUNGS | +7.580 | +7.606 | 1 | m010024 | 0.000220313
RUNGS | +7.846 | +7.870 | 1 | m010024 | 0.000220313
RUNGS | +8.111 | +8.136 | 1 | m010024 | 0.000220313
RUNGS | +8.376 | +8.400 | 1 | m010024 | 0.000220313
RUNGS | +8.640 | +8.665 | 1 | m010024 | 0.000220313
RUNGS | +8.906 | +8.931 | 1 | m010024 | 0.000220313
RUNGS | +9.171 | +9.195 | 1 | m010024 | 0.000220313
RUNGS | +9.435 | +9.460 | 1 | m010024 | 0.000220313
RUNGS | +9.700 | +9.726 | 1 | m010024 | 0.000220313
RUNGS | +9.966 | +9.991 | 1 | m010024 | 0.000220313
RUNGS | +10.230 | +10.256 | 1 | m010024 | 0.000220313
RUNGS | +10.496 | +10.521 | 1 | m010024 | 0.000220313
RUNGS | +10.761 | +10.786 | 1 | m010024 | 0.000220313
2 x RUNGS | +11.025 | +11.051 | 1 | m010024 | 0.000220313
RUNGS | +11.291 | +11.316 | 1 | m010024 | 0.000220313
RUNGS | +11.556 | +11.581 | 1 | m010024 | 0.000220313
RUNGS | +11.820 | +11.845 | 1 | m010024 | 0.000220313
RUNGS | +12.086 | +12.111 | 1 | m010024 | 0.000220313
RUNGS | +12.351 | +12.376 | 1 | m010024 | 0.000220313
RUNGS | +12.616 | +12.640 | 1 | m010024 | 0.000220313
RUNGS | +5.816 | +5.840 | 1 | m010024 | 0.000220313
2 x RUNGS | +58.240 | +58.266 | 8 | mf-260 | 0.000220313
2 x RUNGS | +57.975 | +58.001 | 8 | mf-260 | 0.000220313
2 x RUNGS | +57.711 | +57.736 | 8 | mf-260 | 0.000220313
2 x RUNGS | +57.446 | +57.471 | 8 | mf-260 | 0.000220313
2 x RUNGS | +57.181 | +57.206 | 8 | mf-260 | 0.000220313
2 x RUNGS | +55.590 | +55.615 | 8 | mf-260 | 0.000220313
2 x RUNGS | +55.855 | +55.880 | 8 | mf-260 | 0.000220313
2 x RUNGS | +56.121 | +56.145 | 8 | mf-260 | 0.000220313
2 x RUNGS | +56.386 | +56.410 | 8 | mf-260 | 0.000220313
2 x RUNGS | +56.651 | +56.676 | 8 | mf-260 | 0.000220313
2 x RUNGS | +56.916 | +56.941 | 8 | mf-260 | 0.000220313
2 x RUNGS | +36.566 | +36.590 | 7 | me-169 | 0.000220313
2 x RUNGS | +36.840 | +36.865 | 7 | me-169 | 0.000220313
2 x RUNGS | +37.115 | +37.141 | 7 | me-169 | 0.000220313
2 x RUNGS | +37.391 | +37.416 | 7 | me-169 | 0.000220313
2 x RUNGS | +37.666 | +37.691 | 7 | me-169 | 0.000220313
2 x RUNGS | +37.941 | +37.965 | 7 | me-169 | 0.000220313
2 x RUNGS | +39.590 | +39.615 | 7 | me-169 | 0.000220313
2 x RUNGS | +39.316 | +39.340 | 7 | me-169 | 0.000220313
2 x RUNGS | +39.041 | +39.066 | 7 | me-169 | 0.000220313
2 x RUNGS | +38.766 | +38.791 | 7 | me-169 | 0.000220313
2 x RUNGS | +38.490 | +38.516 | 7 | me-169 | 0.000220313
2 x RUNGS | +38.215 | +38.240 | 7 | me-169 | 0.000220313
RUNGS | +72.231 | +72.255 | 1 | m010024 | 0.000220313
RUNGS | +71.938 | +71.963 | 1 | m010024 | 0.000220313
RUNGS | +71.644 | +71.669 | 1 | m010024 | 0.000220313
RUNGS | +71.352 | +71.376 | 1 | m010024 | 0.000220313
RUNGS | +71.058 | +71.084 | 1 | m010024 | 0.000220313
RUNGS | +63.733 | +63.758 | 1 | m010024 | 0.000220313
RUNGS | +64.026 | +64.052 | 1 | m010024 | 0.000220313
RUNGS | +64.320 | +64.344 | 1 | m010024 | 0.000220313
RUNGS | +64.612 | +64.638 | 1 | m010024 | 0.000220313
RUNGS | +64.906 | +64.930 | 1 | m010024 | 0.000220313
RUNGS | +65.198 | +65.224 | 1 | m010024 | 0.000220313
RUNGS | +65.492 | +65.516 | 1 | m010024 | 0.000220313
RUNGS | +65.784 | +65.810 | 1 | m010024 | 0.000220313
RUNGS | +66.078 | +66.103 | 1 | m010024 | 0.000220313
RUNGS | +66.371 | +66.395 | 1 | m010024 | 0.000220313
RUNGS | +66.663 | +66.689 | 1 | m010024 | 0.000220313
RUNGS | +66.957 | +66.981 | 1 | m010024 | 0.000220313
RUNGS | +67.249 | +67.275 | 1 | m010024 | 0.000220313
RUNGS | +67.543 | +67.567 | 1 | m010024 | 0.000220313
RUNGS | +67.835 | +67.861 | 1 | m010024 | 0.000220313
RUNGS | +68.129 | +68.153 | 1 | m010024 | 0.000220313
RUNGS | +68.421 | +68.447 | 1 | m010024 | 0.000220313
RUNGS | +68.715 | +68.740 | 1 | m010024 | 0.000220313
RUNGS | +69.007 | +69.032 | 1 | m010024 | 0.000220313
RUNGS | +69.301 | +69.326 | 1 | m010024 | 0.000220313
RUNGS | +69.594 | +69.618 | 1 | m010024 | 0.000220313
RUNGS | +69.886 | +69.912 | 1 | m010024 | 0.000220313
RUNGS | +70.180 | +70.204 | 1 | m010024 | 0.000220313
RUNGS | +70.472 | +70.498 | 1 | m010024 | 0.000220313
RUNGS | +49.004 | +49.029 | 1 | m010024 | 0.000220313
RUNGS | +49.282 | +49.307 | 1 | m010024 | 0.000220313
RUNGS | +49.562 | +49.587 | 1 | m010024 | 0.000220313
RUNGS | +49.840 | +49.865 | 1 | m010024 | 0.000220313
RUNGS | +50.120 | +50.145 | 1 | m010024 | 0.000220313
RUNGS | +50.398 | +50.423 | 1 | m010024 | 0.000220313
RUNGS | +50.678 | +50.703 | 1 | m010024 | 0.000220313
RUNGS | +50.956 | +50.981 | 1 | m010024 | 0.000220313
RUNGS | +51.236 | +51.261 | 1 | m010024 | 0.000220313
RUNGS | +51.514 | +51.539 | 1 | m010024 | 0.000220313
RUNGS | +51.794 | +51.819 | 1 | m010024 | 0.000220313
RUNGS | +52.072 | +52.097 | 1 | m010024 | 0.000220313
RUNGS | +52.352 | +52.377 | 1 | m010024 | 0.000220313
RUNGS | +52.630 | +52.656 | 1 | m010024 | 0.000220313
RUNGS | +52.910 | +52.935 | 1 | m010024 | 0.000220313
RUNGS | +53.188 | +53.214 | 1 | m010024 | 0.000220313
RUNGS | +53.468 | +53.493 | 1 | m010024 | 0.000220313
RUNGS | +53.746 | +53.772 | 1 | m010024 | 0.000220313
RUNGS | +54.026 | +54.051 | 1 | m010024 | 0.000220313
RUNGS | +54.304 | +54.330 | 1 | m010024 | 0.000220313
RUNGS | +54.584 | +54.608 | 1 | m010024 | 0.000220313
RUNGS | +54.862 | +54.888 | 1 | m010024 | 0.000220313
RUNGS | +55.142 | +55.166 | 1 | m010024 | 0.000220313
RUNGS | +56.816 | +56.840 | 1 | m010024 | 0.000220313
RUNGS | +56.536 | +56.562 | 1 | m010024 | 0.000220313
RUNGS | +56.258 | +56.282 | 1 | m010024 | 0.000220313
RUNGS | +55.978 | +56.004 | 1 | m010024 | 0.000220313
RUNGS | +55.700 | +55.724 | 1 | m010024 | 0.000220313
RUNGS | +64.986 | +65.010 | 1 | m010024 | 0.000220313
RUNGS | +64.701 | +64.727 | 1 | m010024 | 0.000220313
RUNGS | +64.418 | +64.442 | 1 | m010024 | 0.000220313
RUNGS | +64.133 | +64.159 | 1 | m010024 | 0.000220313
RUNGS | +63.849 | +63.874 | 1 | m010024 | 0.000220313
RUNGS | +55.614 | +55.639 | 1 | m010024 | 0.000220313
RUNGS | +55.898 | +55.922 | 1 | m010024 | 0.000220313
RUNGS | +56.182 | +56.206 | 1 | m010024 | 0.000220313
RUNGS | +56.465 | +56.490 | 1 | m010024 | 0.000220313
RUNGS | +56.749 | +56.775 | 1 | m010024 | 0.000220313
RUNGS | +57.033 | +57.059 | 1 | m010024 | 0.000220313
RUNGS | +57.318 | +57.343 | 1 | m010024 | 0.000220313
RUNGS | +57.602 | +57.627 | 1 | m010024 | 0.000220313
RUNGS | +57.886 | +57.910 | 1 | m010024 | 0.000220313
RUNGS | +58.169 | +58.194 | 1 | m010024 | 0.000220313
RUNGS | +58.453 | +58.478 | 1 | m010024 | 0.000220313
RUNGS | +58.737 | +58.763 | 1 | m010024 | 0.000220313
RUNGS | +59.022 | +59.047 | 1 | m010024 | 0.000220313
RUNGS | +59.306 | +59.331 | 1 | m010024 | 0.000220313
RUNGS | +59.590 | +59.615 | 1 | m010024 | 0.000220313
RUNGS | +59.874 | +59.898 | 1 | m010024 | 0.000220313
RUNGS | +60.157 | +60.182 | 1 | m010024 | 0.000220313
RUNGS | +60.441 | +60.467 | 1 | m010024 | 0.000220313
RUNGS | +60.725 | +60.751 | 1 | m010024 | 0.000220313
RUNGS | +61.010 | +61.035 | 1 | m010024 | 0.000220313
RUNGS | +61.294 | +61.319 | 1 | m010024 | 0.000220313
RUNGS | +61.578 | +61.602 | 1 | m010024 | 0.000220313
RUNGS | +61.861 | +61.886 | 1 | m010024 | 0.000220313
RUNGS | +62.145 | +62.170 | 1 | m010024 | 0.000220313
RUNGS | +62.429 | +62.455 | 1 | m010024 | 0.000220313
RUNGS | +62.714 | +62.739 | 1 | m010024 | 0.000220313
RUNGS | +62.998 | +63.023 | 1 | m010024 | 0.000220313
RUNGS | +63.282 | +63.307 | 1 | m010024 | 0.000220313
RUNGS | +50.221 | +50.246 | 1 | m010024 | 0.000220313
RUNGS | +49.940 | +49.965 | 1 | m010024 | 0.000220313
RUNGS | +49.658 | +49.684 | 1 | m010024 | 0.000220313
RUNGS | +49.377 | +49.403 | 1 | m010024 | 0.000220313
RUNGS | +49.096 | +49.121 | 1 | m010024 | 0.000220313
RUNGS | +44.882 | +44.907 | 1 | m010024 | 0.000220313
RUNGS | +45.163 | +45.188 | 1 | m010024 | 0.000220313
RUNGS | +45.444 | +45.468 | 1 | m010024 | 0.000220313
RUNGS | +45.724 | +45.749 | 1 | m010024 | 0.000220313
RUNGS | +46.005 | +46.031 | 1 | m010024 | 0.000220313
RUNGS | +46.286 | +46.312 | 1 | m010024 | 0.000220313
RUNGS | +46.568 | +46.593 | 1 | m010024 | 0.000220313
RUNGS | +46.849 | +46.874 | 1 | m010024 | 0.000220313
RUNGS | +47.130 | +47.154 | 1 | m010024 | 0.000220313
RUNGS | +47.410 | +47.435 | 1 | m010024 | 0.000220313
RUNGS | +47.691 | +47.717 | 1 | m010024 | 0.000220313
RUNGS | +47.972 | +47.998 | 1 | m010024 | 0.000220313
RUNGS | +48.254 | +48.279 | 1 | m010024 | 0.000220313
RUNGS | +48.535 | +48.560 | 1 | m010024 | 0.000220313
RUNGS | +15.996 | +16.020 | 1 | m010024 | 0.000220313
RUNGS | +16.275 | +16.299 | 1 | m010024 | 0.000220313
RUNGS | +16.554 | +16.578 | 1 | m010024 | 0.000220312
RUNGS | +16.833 | +16.858 | 1 | m010024 | 0.000220312
RUNGS | +17.111 | +17.137 | 1 | m010024 | 0.000220312
RUNGS | +17.390 | +17.416 | 1 | m010024 | 0.000220312
RUNGS | +17.669 | +17.695 | 1 | m010024 | 0.000220312
RUNGS | +17.948 | +17.974 | 1 | m010024 | 0.000220312
RUNGS | +18.227 | +18.253 | 1 | m010024 | 0.000220312
RUNGS | +18.506 | +18.532 | 1 | m010024 | 0.000220312
RUNGS | +18.785 | +18.811 | 1 | m010024 | 0.000220312
RUNGS | +19.064 | +19.090 | 1 | m010024 | 0.000220312
RUNGS | +19.343 | +19.369 | 1 | m010024 | 0.000220312
RUNGS | +19.622 | +19.648 | 1 | m010024 | 0.000220312
RUNGS | +19.901 | +19.927 | 1 | m010024 | 0.000220312
RUNGS | +20.180 | +20.206 | 1 | m010024 | 0.000220312
RUNGS | +20.459 | +20.485 | 1 | m010024 | 0.000220312
RUNGS | +20.738 | +20.764 | 1 | m010024 | 0.000220312
RUNGS | +21.017 | +21.043 | 1 | m010024 | 0.000220312
RUNGS | +21.297 | +21.322 | 1 | m010024 | 0.000220312
RUNGS | +22.971 | +22.996 | 1 | m010024 | 0.000220312
RUNGS | +22.692 | +22.717 | 1 | m010024 | 0.000220312
RUNGS | +22.413 | +22.438 | 1 | m010024 | 0.000220312
RUNGS | +22.134 | +22.159 | 1 | m010024 | 0.000220312
RUNGS | +21.855 | +21.880 | 1 | m010024 | 0.000220312
RUNGS | +46.100 | +46.126 | 1 | m010024 | 0.000220313
RUNGS | +45.819 | +45.843 | 1 | m010024 | 0.000220313
RUNGS | +45.536 | +45.562 | 1 | m010024 | 0.000220313
RUNGS | +45.255 | +45.279 | 1 | m010024 | 0.000220313
RUNGS | +44.972 | +44.998 | 1 | m010024 | 0.000220313
RUNGS | +39.333 | +39.358 | 1 | m010024 | 0.000220313
RUNGS | +39.615 | +39.639 | 1 | m010024 | 0.000220313
RUNGS | +39.897 | +39.922 | 1 | m010024 | 0.000220313
RUNGS | +40.179 | +40.203 | 1 | m010024 | 0.000220313
RUNGS | +40.461 | +40.486 | 1 | m010024 | 0.000220313
RUNGS | +40.743 | +40.767 | 1 | m010024 | 0.000220313
RUNGS | +41.025 | +41.050 | 1 | m010024 | 0.000220313
RUNGS | +41.307 | +41.331 | 1 | m010024 | 0.000220313
RUNGS | +41.589 | +41.614 | 1 | m010024 | 0.000220313
RUNGS | +41.871 | +41.895 | 1 | m010024 | 0.000220313
RUNGS | +42.153 | +42.178 | 1 | m010024 | 0.000220313
RUNGS | +42.435 | +42.459 | 1 | m010024 | 0.000220313
RUNGS | +42.717 | +42.742 | 1 | m010024 | 0.000220313
RUNGS | +42.999 | +43.023 | 1 | m010024 | 0.000220313
RUNGS | +43.281 | +43.306 | 1 | m010024 | 0.000220313
RUNGS | +43.563 | +43.587 | 1 | m010024 | 0.000220313
RUNGS | +43.844 | +43.870 | 1 | m010024 | 0.000220313
RUNGS | +44.127 | +44.151 | 1 | m010024 | 0.000220313
RUNGS | +44.408 | +44.434 | 1 | m010024 | 0.000220313
RUNGS | +36.571 | +36.596 | 1 | m010024 | 0.000220313
RUNGS | +36.858 | +36.883 | 1 | m010024 | 0.000220313
RUNGS | +37.145 | +37.169 | 1 | m010024 | 0.000220313
RUNGS | +37.432 | +37.456 | 1 | m010024 | 0.000220313
RUNGS | +37.718 | +37.743 | 1 | m010024 | 0.000220313
RUNGS | +38.005 | +38.031 | 1 | m010024 | 0.000220313
RUNGS | +38.292 | +38.318 | 1 | m010024 | 0.000220313
RUNGS | +38.580 | +38.605 | 1 | m010024 | 0.000220313
RUNGS | +38.867 | +38.892 | 1 | m010024 | 0.000220313
RUNGS | +40.589 | +40.614 | 1 | m010024 | 0.000220313
RUNGS | +40.301 | +40.327 | 1 | m010024 | 0.000220313
RUNGS | +40.014 | +40.039 | 1 | m010024 | 0.000220313
RUNGS | +39.727 | +39.752 | 1 | m010024 | 0.000220313
RUNGS | +39.441 | +39.465 | 1 | m010024 | 0.000220313
RUNGS | +37.785 | +37.810 | 1 | m010024 | 0.000220313
RUNGS | +37.505 | +37.531 | 1 | m010024 | 0.000220313
RUNGS | +37.225 | +37.251 | 1 | m010024 | 0.000220313
RUNGS | +36.946 | +36.971 | 1 | m010024 | 0.000220313
RUNGS | +36.666 | +36.691 | 1 | m010024 | 0.000220313
RUNGS | +29.386 | +29.410 | 1 | m010024 | 0.000220312
RUNGS | +29.666 | +29.691 | 1 | m010024 | 0.000220312
RUNGS | +29.945 | +29.971 | 1 | m010024 | 0.000220312
RUNGS | +30.226 | +30.250 | 1 | m010024 | 0.000220312
RUNGS | +30.506 | +30.531 | 1 | m010024 | 0.000220312
RUNGS | +30.785 | +30.811 | 1 | m010024 | 0.000220312
RUNGS | +31.066 | +31.090 | 1 | m010024 | 0.000220312
RUNGS | +31.346 | +31.371 | 1 | m010024 | 0.000220312
RUNGS | +31.625 | +31.651 | 1 | m010024 | 0.000220312
RUNGS | +31.906 | +31.930 | 1 | m010024 | 0.000220312
RUNGS | +32.185 | +32.211 | 1 | m010024 | 0.000220312
RUNGS | +32.465 | +32.490 | 1 | m010024 | 0.000220312
RUNGS | +32.746 | +32.770 | 1 | m010024 | 0.000220313
RUNGS | +33.026 | +33.051 | 1 | m010024 | 0.000220313
RUNGS | +33.306 | +33.331 | 1 | m010024 | 0.000220313
RUNGS | +33.586 | +33.611 | 1 | m010024 | 0.000220313
RUNGS | +33.865 | +33.891 | 1 | m010024 | 0.000220313
RUNGS | +34.145 | +34.170 | 1 | m010024 | 0.000220313
RUNGS | +34.426 | +34.450 | 1 | m010024 | 0.000220313
RUNGS | +34.706 | +34.730 | 1 | m010024 | 0.000220313
RUNGS | +34.986 | +35.011 | 1 | m010024 | 0.000220313
RUNGS | +35.266 | +35.291 | 1 | m010024 | 0.000220313
RUNGS | +35.545 | +35.571 | 1 | m010024 | 0.000220313
RUNGS | +35.825 | +35.850 | 1 | m010024 | 0.000220313
RUNGS | +36.105 | +36.130 | 1 | m010024 | 0.000220313
RUNGS | +70.766 | +70.790 | 1 | m010024 | 0.000220313
RUNGS | +63.566 | +63.590 | 1 | m010024 | 0.000220313
RUNGS | +55.420 | +55.446 | 1 | m010024 | 0.000220313
RUNGS | +48.816 | +48.840 | 1 | m010024 | 0.000220313
RUNGS | +44.691 | +44.715 | 1 | m010024 | 0.000220313
RUNGS | +39.154 | +39.179 | 1 | m010024 | 0.000220313
RUNGS | +36.386 | +36.410 | 1 | m010024 | 0.000220313
2 x RUNGS | +0.166 | +0.191 | 1 | m010024 | 0.000220312
2 x RUNGS | +0.466 | +0.490 | 1 | m010024 | 0.000220312
2 x RUNGS | +0.765 | +0.790 | 1 | m010024 | 0.000220313
2 x RUNGS | +1.065 | +1.091 | 1 | m010024 | 0.000220313
2 x RUNGS | +1.365 | +1.391 | 1 | m010024 | 0.000220313
2 x RUNGS | +1.666 | +1.690 | 1 | m010024 | 0.000220313
2 x RUNGS | +1.966 | +1.990 | 1 | m010024 | 0.000220313
2 x RUNGS | +2.265 | +2.291 | 1 | m010024 | 0.000220313
2 x RUNGS | +2.566 | +2.591 | 1 | m010024 | 0.000220313
2 x RUNGS | +4.365 | +4.391 | 1 | m010024 | 0.000220313
2 x RUNGS | +4.066 | +4.090 | 1 | m010024 | 0.000220313
2 x RUNGS | +3.765 | +3.791 | 1 | m010024 | 0.000220313
2 x RUNGS | +3.466 | +3.490 | 1 | m010024 | 0.000220313
2 x RUNGS | +2.865 | +2.890 | 1 | m010024 | 0.000220313
RUNGS | +12.765 | +12.791 | 1 | m010024 | 0.000220313
RUNGS | +12.476 | +12.501 | 1 | m010024 | 0.000220313
RUNGS | +12.185 | +12.211 | 1 | m010024 | 0.000220313
RUNGS | +11.896 | +11.921 | 1 | m010024 | 0.000220313
RUNGS | +11.605 | +11.631 | 1 | m010024 | 0.000220313
RUNGS | +10.145 | +10.170 | 1 | m010024 | 0.000220313
RUNGS | +9.860 | +9.885 | 1 | m010024 | 0.000220313
RUNGS | +9.575 | +9.600 | 1 | m010024 | 0.000220313
RUNGS | +9.290 | +9.315 | 1 | m010024 | 0.000220313
RUNGS | +9.005 | +9.030 | 1 | m010024 | 0.000220313
RUNGS | +0.170 | +0.195 | 1 | m010024 | 0.000220312
RUNGS | +0.455 | +0.480 | 1 | m010024 | 0.000220312
RUNGS | +0.740 | +0.765 | 1 | m010024 | 0.000220313
RUNGS | +1.025 | +1.050 | 1 | m010024 | 0.000220313
RUNGS | +1.310 | +1.335 | 1 | m010024 | 0.000220313
RUNGS | +1.595 | +1.620 | 1 | m010024 | 0.000220313
RUNGS | +1.880 | +1.905 | 1 | m010024 | 0.000220313
RUNGS | +2.165 | +2.190 | 1 | m010024 | 0.000220313
RUNGS | +2.450 | +2.475 | 1 | m010024 | 0.000220313
RUNGS | +2.735 | +2.760 | 1 | m010024 | 0.000220313
RUNGS | +3.020 | +3.045 | 1 | m010024 | 0.000220313
RUNGS | +3.305 | +3.330 | 1 | m010024 | 0.000220313
RUNGS | +3.590 | +3.615 | 1 | m010024 | 0.000220313
RUNGS | +3.875 | +3.900 | 1 | m010024 | 0.000220313
RUNGS | +4.160 | +4.185 | 1 | m010024 | 0.000220313
RUNGS | +4.445 | +4.470 | 1 | m010024 | 0.000220313
RUNGS | +4.730 | +4.755 | 1 | m010024 | 0.000220313
RUNGS | +5.015 | +5.040 | 1 | m010024 | 0.000220313
RUNGS | +5.300 | +5.325 | 1 | m010024 | 0.000220313
RUNGS | +5.585 | +5.610 | 1 | m010024 | 0.000220313
RUNGS | +5.870 | +5.895 | 1 | m010024 | 0.000220313
RUNGS | +6.155 | +6.180 | 1 | m010024 | 0.000220313
RUNGS | +6.440 | +6.465 | 1 | m010024 | 0.000220313
RUNGS | +6.725 | +6.750 | 1 | m010024 | 0.000220313
RUNGS | +7.010 | +7.035 | 1 | m010024 | 0.000220313
RUNGS | +7.295 | +7.320 | 1 | m010024 | 0.000220313
RUNGS | +7.580 | +7.605 | 1 | m010024 | 0.000220313
RUNGS | +7.865 | +7.890 | 1 | m010024 | 0.000220313
RUNGS | +8.150 | +8.175 | 1 | m010024 | 0.000220313
RUNGS | +8.435 | +8.460 | 1 | m010024 | 0.000220313
RUNGS | +5.806 | +5.830 | 1 | m010024 | 0.000220313
RUNGS | +6.096 | +6.120 | 1 | m010024 | 0.000220313
RUNGS | +6.386 | +6.410 | 1 | m010024 | 0.000220313
RUNGS | +6.676 | +6.700 | 1 | m010024 | 0.000220313
RUNGS | +6.965 | +6.990 | 1 | m010024 | 0.000220313
RUNGS | +7.255 | +7.281 | 1 | m010024 | 0.000220313
RUNGS | +7.545 | +7.571 | 1 | m010024 | 0.000220313
RUNGS | +7.835 | +7.861 | 1 | m010024 | 0.000220313
RUNGS | +8.126 | +8.150 | 1 | m010024 | 0.000220313
RUNGS | +8.415 | +8.441 | 1 | m010024 | 0.000220313
RUNGS | +8.706 | +8.730 | 1 | m010024 | 0.000220313
RUNGS | +8.995 | +9.021 | 1 | m010024 | 0.000220313
RUNGS | +9.286 | +9.310 | 1 | m010024 | 0.000220313
RUNGS | +9.575 | +9.601 | 1 | m010024 | 0.000220313
RUNGS | +9.866 | +9.890 | 1 | m010024 | 0.000220313
RUNGS | +10.156 | +10.181 | 1 | m010024 | 0.000220313
RUNGS | +10.445 | +10.470 | 1 | m010024 | 0.000220313
RUNGS | +10.736 | +10.761 | 1 | m010024 | 0.000220313
RUNGS | +8.720 | +8.745 | 1 | m010024 | 0.000220313
RUNGS | +11.316 | +11.341 | 1 | m010024 | 0.000220313
RUNGS | +7.080 | +7.106 | 1 | m010024 | 0.000220313
RUNGS | +6.787 | +6.813 | 1 | m010024 | 0.000220313
RUNGS | +6.495 | +6.519 | 1 | m010024 | 0.000220313
RUNGS | +6.202 | +6.226 | 1 | m010024 | 0.000220313
RUNGS | +5.909 | +5.934 | 1 | m010024 | 0.000220313
RUNGS | +0.049 | +0.073 | 1 | m010024 | 0.000220312
RUNGS | +0.342 | +0.366 | 1 | m010024 | 0.000220312
RUNGS | +0.634 | +0.659 | 1 | m010024 | 0.000220313
RUNGS | +0.927 | +0.953 | 1 | m010024 | 0.000220313
RUNGS | +1.220 | +1.246 | 1 | m010024 | 0.000220313
RUNGS | +1.514 | +1.539 | 1 | m010024 | 0.000220313
RUNGS | +1.807 | +1.831 | 1 | m010024 | 0.000220313
RUNGS | +2.099 | +2.124 | 1 | m010024 | 0.000220313
RUNGS | +2.393 | +2.418 | 1 | m010024 | 0.000220313
RUNGS | +2.686 | +2.711 | 1 | m010024 | 0.000220313
RUNGS | +2.978 | +3.003 | 1 | m010024 | 0.000220313
RUNGS | +3.272 | +3.297 | 1 | m010024 | 0.000220313
RUNGS | +3.564 | +3.590 | 1 | m010024 | 0.000220313
RUNGS | +3.857 | +3.882 | 1 | m010024 | 0.000220313
RUNGS | +4.151 | +4.176 | 1 | m010024 | 0.000220313
RUNGS | +4.444 | +4.468 | 1 | m010024 | 0.000220313
RUNGS | +4.737 | +4.761 | 1 | m010024 | 0.000220313
RUNGS | +5.029 | +5.055 | 1 | m010024 | 0.000220313
RUNGS | +5.322 | +5.348 | 1 | m010024 | 0.000220313
RUNGS | +5.615 | +5.641 | 1 | m010024 | 0.000220313
RUNGS | +30.680 | +30.706 | 1 | m010024 | 0.000220312
RUNGS | +30.384 | +30.409 | 1 | m010024 | 0.000220312
RUNGS | +30.087 | +30.111 | 1 | m010024 | 0.000220312
RUNGS | +29.790 | +29.814 | 1 | m010024 | 0.000220312
RUNGS | +29.493 | +29.517 | 1 | m010024 | 0.000220312
RUNGS | +21.770 | +21.796 | 1 | m010024 | 0.000220312
RUNGS | +22.067 | +22.093 | 1 | m010024 | 0.000220312
RUNGS | +22.365 | +22.390 | 1 | m010024 | 0.000220312
RUNGS | +22.662 | +22.686 | 1 | m010024 | 0.000220312
RUNGS | +22.959 | +22.983 | 1 | m010024 | 0.000220312
RUNGS | +23.256 | +23.281 | 1 | m010024 | 0.000220312
RUNGS | +23.552 | +23.578 | 1 | m010024 | 0.000220312
RUNGS | +23.849 | +23.875 | 1 | m010024 | 0.000220312
RUNGS | +24.147 | +24.172 | 1 | m010024 | 0.000220312
RUNGS | +24.444 | +24.468 | 1 | m010024 | 0.000220312
RUNGS | +24.741 | +24.765 | 1 | m010024 | 0.000220312
RUNGS | +25.038 | +25.063 | 1 | m010024 | 0.000220312
RUNGS | +25.334 | +25.360 | 1 | m010024 | 0.000220312
RUNGS | +25.631 | +25.657 | 1 | m010024 | 0.000220312
RUNGS | +25.929 | +25.953 | 1 | m010024 | 0.000220312
RUNGS | +26.226 | +26.250 | 1 | m010024 | 0.000220312
