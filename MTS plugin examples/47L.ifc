Properties of the parts of a building model (IFC2X3), part 10 of 22

# IfcDiscreteAccessory: GUSSET PLATE (958)
Name | Description | Bottom elevation | Top elevation | Phase | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x GUSSET PLATE | PLT10*170.6 | +5.593 | +5.603 | 3 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pa-78 | 0.0647785 | 0.0389599 | 0.000289103 | 0.000289103
2 x GUSSET PLATE | PLT10*161.8 | +5.593 | +5.603 | 3 | 2.5 | 0 | 28.5 | 0.1 | 161.7 | 258 | pa-79 | 0.0696158 | 0.0417359 | 0.00031097 | 0.00031097
GUSSET PLATE | PLT10*170.6 | +5.593 | +5.603 | 3 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pa-80 | 0.0658278 | 0.0396316 | 0.000293979 | 0.000293979
2 x GUSSET PLATE | PLT10*170.6 | +5.593 | +5.603 | 3 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pa-80 | 0.0658454 | 0.0396423 | 0.000294059 | 0.000294059
GUSSET PLATE | PLT10*170.6 | +5.593 | +5.603 | 3 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pa-78 | 0.0647608 | 0.038949 | 0.000289022 | 0.000289022
GUSSET PLATE | PLT10*160.5 | +5.593 | +5.603 | 3 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pa-81 | 0.0703425 | 0.0421247 | 0.000314238 | 0.000314238
GUSSET PLATE | PLT10*141.1 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 141.1 | 217.2 | pa-82 | 0.0555457 | 0.0306329 | 0.000245958 | 0.000245958
GUSSET PLATE | PLT10*136.9 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 136.9 | 225.2 | pa-73 | 0.0568742 | 0.0308274 | 0.000252002 | 0.000252002
GUSSET PLATE | PLT10*157.7 | +5.593 | +5.603 | 3 | 2.6 | 0 | 28.5 | 0.1 | 157.7 | 276.6 | pa-83 | 0.0730228 | 0.0436243 | 0.000326405 | 0.000326405
GUSSET PLATE | PLT10*147.9 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 147.8 | 214.9 | pa-84 | 0.056983 | 0.0317733 | 0.00025281 | 0.00025281
GUSSET PLATE | PLT10*141.2 | +5.593 | +5.603 | 3 | 2.2 | 0 | 28.6 | 0.1 | 141.2 | 245.2 | pa-85 | 0.0637481 | 0.0346233 | 0.000284111 | 0.000284111
GUSSET PLATE | PLT10*141.2 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 141.2 | 224.4 | pa-86 | 0.0574568 | 0.0316857 | 0.000254735 | 0.000254735
2 x GUSSET PLATE | PLT10*140.9 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.2 | pa-74 | 0.0576086 | 0.0317279 | 0.000255429 | 0.000255429
2 x GUSSET PLATE | PLT10*140.8 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 140.9 | 225.5 | pa-74 | 0.0576789 | 0.0317475 | 0.00025575 | 0.00025575
GUSSET PLATE | PLT10*144.4 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.4 | pa-87 | 0.0560392 | 0.0312583 | 0.00024827 | 0.00024827
GUSSET PLATE | PLT10*170.6 | +5.593 | +5.603 | 3 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pa-80 | 0.0658269 | 0.0396316 | 0.000293974 | 0.000293974
GUSSET PLATE | PLT10*170.6 | +5.593 | +5.603 | 3 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 232.4 | pa-80 | 0.0658459 | 0.0396423 | 0.000294061 | 0.000294061
GUSSET PLATE | PLT10*144.4 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 144.4 | 216.6 | pa-87 | 0.0560827 | 0.0312867 | 0.000248473 | 0.000248473
GUSSET PLATE | PLT10*163 | +5.593 | +5.603 | 3 | 2.1 | 0 | 28.6 | 0.1 | 163 | 209.2 | pa-88 | 0.0590361 | 0.0341005 | 0.000262746 | 0.000262746
GUSSET PLATE | PLT10*141.1 | +5.593 | +5.603 | 3 | 1.9 | 0 | 28.7 | 0.1 | 141.1 | 217.2 | pa-89 | 0.0555992 | 0.030638 | 0.000246216 | 0.000246216
2 x GUSSET PLATE | PLT10*160.4 | +5.593 | +5.603 | 3 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.9 | pa-81 | 0.0704233 | 0.0421679 | 0.000314601 | 0.000314601
GUSSET PLATE | PLT10*170.6 | +5.593 | +5.603 | 3 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pa-78 | 0.064779 | 0.0389599 | 0.000289105 | 0.000289105
GUSSET PLATE | PLT10*170.6 | +5.593 | +5.603 | 3 | 2.3 | 0 | 28.5 | 0.1 | 170.6 | 228.4 | pa-78 | 0.0647598 | 0.038949 | 0.000289018 | 0.000289018
GUSSET PLATE | PLT10*169.5 | +5.593 | +5.603 | 3 | 2.3 | 0 | 28.5 | 0.1 | 169.5 | 232.1 | pa-90 | 0.0654016 | 0.0393392 | 0.000291932 | 0.000291932
GUSSET PLATE | PLT10*160.5 | +5.593 | +5.603 | 3 | 2.5 | 0 | 28.5 | 0.1 | 160.4 | 262.4 | pa-81 | 0.0703419 | 0.0421247 | 0.000314235 | 0.000314235
2 x GUSSET PLATE | PLT10*163.5 | +5.593 | +5.603 | 3 | 2.2 | 0 | 28.6 | 0.1 | 163.5 | 235.1 | pa-91 | 0.0642629 | 0.0384507 | 0.000286308 | 0.000286308
2 x GUSSET PLATE | PLT10*163.5 | +5.593 | +5.603 | 3 | 2.2 | 0 | 28.6 | 0.1 | 163.5 | 234.3 | pa-91 | 0.064042 | 0.0383117 | 0.000285285 | 0.000285285
GUSSET PLATE | PLT10*163.6 | +5.593 | +5.603 | 3 | 2.2 | 0 | 28.6 | 0.1 | 163.6 | 234.1 | pa-91 | 0.0640212 | 0.0383005 | 0.00028519 | 0.00028519
GUSSET PLATE | PLT10*163.6 | +5.593 | +5.603 | 3 | 2.2 | 0 | 28.6 | 0.1 | 163.6 | 235 | pa-91 | 0.0642421 | 0.0384395 | 0.000286214 | 0.000286214
GUSSET PLATE | PLT10*154.5 | +5.593 | +5.603 | 3 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 267.3 | pa-92 | 0.0696169 | 0.0412969 | 0.000310437 | 0.000310437
GUSSET PLATE | PLT10*153.7 | +5.593 | +5.603 | 3 | 2.5 | 0 | 28.6 | 0.1 | 153.7 | 270.4 | pa-93 | 0.0700471 | 0.0415659 | 0.000312338 | 0.000312338
GUSSET PLATE | PLT10*133.7 | +5.590 | +5.600 | 3 | 1.9 | 0 | 28.7 | 0.1 | 133.8 | 233.5 | pa-94 | 0.0584071 | 0.0312336 | 0.000258971 | 0.000258971
GUSSET PLATE | PLT10*154.5 | +5.593 | +5.603 | 3 | 2.5 | 0 | 28.6 | 0.1 | 154.5 | 268.1 | pa-92 | 0.0698305 | 0.0414282 | 0.000311422 | 0.000311422

# IfcDiscreteAccessory: HAUNCH_PLATE (7)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Phase: 5; Class: 8
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x HAUNCH_PLATE | FL8*65 | +5.712 | +5.812 | 0.4 | 39.9 | 0 | 65 | 8 | 100 | pc-417 | 0.0117743 | 0.0065 | 0.000064 | 0.0000376
3 x HAUNCH_PLATE | PLT12*125.6 | +10.874 | +11.000 | 2.3 | 25.3 | 0.1 | 125.6 | 12 | 300 | pc-66 | 0.0588123 | 0.03768 | 0.000144 | 0.000297288
2 x HAUNCH_PLATE | FL8*150 | +5.174 | +5.300 | 0.7 | 36.6 | 0 | 125.6 | 8 | 125.6 | pc-416 | 0.0301202 | 0.0157754 | 0.000064 | 0.000104832

# IfcDiscreteAccessory: HOOP (157)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x HOOP | FL6*50 | +2.565 | +2.615 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +2.880 | +2.930 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +3.715 | +3.765 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +4.550 | +4.600 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +8.881 | +8.931 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +9.707 | +9.757 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +10.533 | +10.583 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +11.359 | +11.409 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +12.185 | +12.235 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +12.590 | +12.640 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.00044338
HOOP | FL6*50 | +13.145 | +13.195 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.00044338
HOOP | ROD25 | +13.605 | +13.630 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115687 | 0.00046875 | 0.000692749
HOOP | FL6*50 | +5.790 | +5.840 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | FL6*50 | +7.425 | +7.475 | 2.8 | 47.8 | 0.1 | 50 | 6 | 1171.4 | p010024 | 0.132318 | 0.0003 | 0.000352815
HOOP | FL6*50 | +8.055 | +8.105 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +6.345 | +6.395 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | ROD25 | +6.805 | +6.830 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115688 | 0.00046875 | 0.000692752
HOOP | FL6*50 | +5.385 | +5.435 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +5.790 | +5.840 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.00044338
HOOP | FL6*50 | +6.345 | +6.395 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.00044338
HOOP | ROD25 | +6.805 | +6.830 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115687 | 0.00046875 | 0.00069275
HOOP | FL6*50 | +2.055 | +2.105 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +66.340 | +66.390 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1451.1 | p010028 | 0.163889 | 0.0003 | 0.000437382
HOOP | FL6*50 | +67.975 | +68.025 | 2.8 | 47.8 | 0.1 | 50 | 6 | 1171.4 | p010024 | 0.132318 | 0.0003 | 0.000352815
HOOP | FL6*50 | +68.605 | +68.655 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +66.895 | +66.945 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1451.1 | p010028 | 0.163889 | 0.0003 | 0.000437382
HOOP | ROD25 | +67.355 | +67.380 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1457.9 | m010022 | 0.114135 | 0.00046875 | 0.000683377
HOOP | FL6*50 | +69.470 | +69.520 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +70.335 | +70.385 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +70.740 | +70.790 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.00044338
HOOP | FL6*50 | +71.295 | +71.345 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.00044338
HOOP | ROD25 | +71.755 | +71.780 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115687 | 0.00046875 | 0.000692749
HOOP | FL6*50 | +63.540 | +63.590 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | FL6*50 | +65.175 | +65.225 | 2.8 | 47.8 | 0.1 | 50 | 6 | 1171.4 | p010024 | 0.132318 | 0.0003 | 0.000352815
HOOP | FL6*50 | +65.805 | +65.855 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +64.095 | +64.145 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | ROD25 | +64.555 | +64.580 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115688 | 0.00046875 | 0.000692752
HOOP | FL6*50 | +58.560 | +58.610 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +59.475 | +59.525 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +60.390 | +60.440 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +61.305 | +61.355 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +62.220 | +62.270 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +63.135 | +63.185 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +63.540 | +63.590 | 3.7 | 47.7 | 0.2 | 50 | 6 | 1556.1 | p010027 | 0.175649 | 0.0003 | 0.000468882
HOOP | FL6*50 | +64.095 | +64.145 | 3.7 | 47.7 | 0.2 | 50 | 6 | 1556.1 | p010027 | 0.175649 | 0.0003 | 0.000468882
HOOP | ROD25 | +64.555 | +64.580 | 5.9 | 21.3 | 0.1 | 25 | 25 | 1562.9 | m010021 | 0.122288 | 0.00046875 | 0.000732596
HOOP | FL6*50 | +55.395 | +55.445 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | FL6*50 | +57.030 | +57.080 | 2.8 | 47.8 | 0.1 | 50 | 6 | 1171.4 | p010024 | 0.132318 | 0.0003 | 0.000352815
HOOP | FL6*50 | +57.660 | +57.710 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +55.950 | +56.000 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | ROD25 | +56.410 | +56.435 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115688 | 0.00046875 | 0.000692752
HOOP | FL6*50 | +52.035 | +52.085 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +53.020 | +53.070 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +54.005 | +54.055 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +54.990 | +55.040 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +55.395 | +55.445 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.00044338
HOOP | FL6*50 | +55.950 | +56.000 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.00044338
HOOP | ROD25 | +56.410 | +56.435 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115687 | 0.00046875 | 0.00069275
HOOP | FL6*50 | +51.055 | +51.105 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +47.655 | +47.705 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +48.385 | +48.435 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +48.790 | +48.840 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1451.1 | p010028 | 0.16389 | 0.0003 | 0.000437383
HOOP | FL6*50 | +49.345 | +49.395 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1451.1 | p010028 | 0.16389 | 0.0003 | 0.000437383
HOOP | ROD25 | +49.805 | +49.830 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1457.9 | m010022 | 0.114135 | 0.00046875 | 0.000683379
HOOP | FL6*50 | +44.665 | +44.715 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | FL6*50 | +46.300 | +46.350 | 2.8 | 47.8 | 0.1 | 50 | 6 | 1171.4 | p010024 | 0.132318 | 0.0003 | 0.000352815
HOOP | FL6*50 | +46.930 | +46.980 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +45.220 | +45.270 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | ROD25 | +45.680 | +45.705 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115688 | 0.00046875 | 0.000692752
HOOP | FL6*50 | +42.350 | +42.400 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +43.305 | +43.355 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +44.260 | +44.310 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +44.665 | +44.715 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.00044338
HOOP | FL6*50 | +45.220 | +45.270 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.00044338
HOOP | ROD25 | +45.680 | +45.705 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115687 | 0.00046875 | 0.00069275
HOOP | FL6*50 | +39.128 | +39.178 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | FL6*50 | +40.763 | +40.813 | 2.8 | 47.8 | 0.1 | 50 | 6 | 1171.4 | p010024 | 0.132318 | 0.0003 | 0.000352815
HOOP | FL6*50 | +41.393 | +41.443 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +39.683 | +39.733 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | ROD25 | +40.143 | +40.168 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115688 | 0.00046875 | 0.000692752
HOOP | FL6*50 | +38.723 | +38.773 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +39.128 | +39.178 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471 | p010025 | 0.166128 | 0.0003 | 0.000443378
HOOP | FL6*50 | +39.683 | +39.733 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471 | p010025 | 0.166128 | 0.0003 | 0.000443378
HOOP | ROD25 | +40.143 | +40.168 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115684 | 0.00046875 | 0.000692731
HOOP | FL6*50 | +36.360 | +36.410 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | FL6*50 | +38.043 | +38.093 | 2.8 | 47.8 | 0.1 | 50 | 6 | 1171.4 | p010024 | 0.132318 | 0.0003 | 0.000352815
HOOP | FL6*50 | +36.915 | +36.965 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | ROD25 | +37.375 | +37.400 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115688 | 0.00046875 | 0.000692752
HOOP | FL6*50 | +32.339 | +32.389 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +33.243 | +33.293 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +34.147 | +34.197 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +35.051 | +35.101 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +35.955 | +36.005 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +36.360 | +36.410 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166134 | 0.0003 | 0.000443396
HOOP | FL6*50 | +36.915 | +36.965 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166134 | 0.0003 | 0.000443396
HOOP | ROD25 | +37.375 | +37.400 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115691 | 0.00046875 | 0.000692773
HOOP | FL6*50 | +29.170 | +29.220 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | FL6*50 | +30.805 | +30.855 | 2.8 | 47.8 | 0.1 | 50 | 6 | 1171.4 | p010024 | 0.132318 | 0.0003 | 0.000352815
HOOP | FL6*50 | +31.435 | +31.485 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +29.725 | +29.775 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | ROD25 | +30.185 | +30.210 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115688 | 0.00046875 | 0.000692752
2 x HOOP | FL6*50 | +1.895 | +1.945 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
2 x HOOP | FL6*50 | +2.840 | +2.890 | 3.7 | 47.7 | 0.2 | 50 | 6 | 1562.1 | p010026 | 0.176321 | 0.0003 | 0.000470682
2 x HOOP | FL6*50 | +3.395 | +3.445 | 3.7 | 47.7 | 0.2 | 50 | 6 | 1562.1 | p010026 | 0.176321 | 0.0003 | 0.000470682
2 x HOOP | ROD25 | +3.855 | +3.880 | 5.9 | 21.3 | 0.1 | 25 | 25 | 1562.9 | m010021 | 0.122288 | 0.00046875 | 0.000732596
HOOP | FL6*50 | +2.230 | +2.280 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +3.075 | +3.125 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +3.920 | +3.970 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +4.765 | +4.815 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +5.610 | +5.660 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +6.455 | +6.505 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +7.300 | +7.350 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +9.855 | +9.905 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +8.855 | +8.905 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +8.145 | +8.195 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +8.694 | +8.744 | 3.7 | 47.7 | 0.2 | 50 | 6 | 1562.1 | p010026 | 0.176321 | 0.0003 | 0.000470682
HOOP | FL6*50 | +9.249 | +9.299 | 3.7 | 47.7 | 0.2 | 50 | 6 | 1562.1 | p010026 | 0.176321 | 0.0003 | 0.000470682
HOOP | ROD25 | +9.709 | +9.734 | 5.9 | 21.3 | 0.1 | 25 | 25 | 1562.9 | m010021 | 0.122288 | 0.00046875 | 0.000732596
HOOP | FL6*50 | +10.855 | +10.905 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +11.290 | +11.340 | 3.7 | 47.7 | 0.2 | 50 | 6 | 1556.1 | p010027 | 0.175649 | 0.0003 | 0.000468882
HOOP | FL6*50 | +11.845 | +11.895 | 3.7 | 47.7 | 0.2 | 50 | 6 | 1556.1 | p010027 | 0.175649 | 0.0003 | 0.000468882
HOOP | ROD25 | +12.305 | +12.330 | 5.9 | 21.3 | 0.1 | 25 | 25 | 1562.9 | m010021 | 0.122288 | 0.00046875 | 0.000732596
HOOP | FL6*50 | +7.855 | +7.905 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +5.040 | +5.090 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +4.335 | +4.385 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +3.630 | +3.680 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +2.925 | +2.975 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +5.590 | +5.640 | 3.7 | 47.7 | 0.2 | 50 | 6 | 1562.1 | p010026 | 0.176321 | 0.0003 | 0.000470682
HOOP | FL6*50 | +6.145 | +6.195 | 3.7 | 47.7 | 0.2 | 50 | 6 | 1562.1 | p010026 | 0.176321 | 0.0003 | 0.000470682
HOOP | ROD25 | +6.605 | +6.630 | 5.9 | 21.3 | 0.1 | 25 | 25 | 1562.9 | m010021 | 0.122288 | 0.00046875 | 0.000732596
2 x HOOP | FL6*50 | +21.550 | +21.600 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | FL6*50 | +28.765 | +28.815 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +27.775 | +27.825 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +26.785 | +26.835 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +25.795 | +25.845 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +24.805 | +24.855 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +29.170 | +29.220 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.00044338
HOOP | FL6*50 | +29.725 | +29.775 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.00044338
HOOP | ROD25 | +30.185 | +30.210 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115687 | 0.00046875 | 0.000692749
HOOP | FL6*50 | +23.185 | +23.235 | 2.8 | 47.8 | 0.1 | 50 | 6 | 1171.4 | p010024 | 0.132318 | 0.0003 | 0.000352815
HOOP | FL6*50 | +23.815 | +23.865 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
2 x HOOP | FL6*50 | +22.105 | +22.155 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
2 x HOOP | ROD25 | +22.565 | +22.590 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115688 | 0.00046875 | 0.000692752
HOOP | FL6*50 | +18.140 | +18.190 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | FL6*50 | +19.775 | +19.825 | 2.8 | 47.8 | 0.1 | 50 | 6 | 1171.4 | p010024 | 0.132318 | 0.0003 | 0.000352815
HOOP | FL6*50 | +20.405 | +20.455 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | FL6*50 | +18.695 | +18.745 | 3.4 | 47.7 | 0.2 | 50 | 6 | 1471.1 | p010025 | 0.166129 | 0.0003 | 0.000443382
HOOP | FL6*50 | +21.105 | +21.155 | 4.5 | 47.7 | 0.2 | 50 | 6 | 1904 | p010029 | 0.214869 | 0.0003 | 0.000573935
HOOP | ROD25 | +19.155 | +19.180 | 5.4 | 21.3 | 0.1 | 25 | 25 | 1477.9 | m010020 | 0.115688 | 0.00046875 | 0.000692752

# IfcDiscreteAccessory: HOOP TIE (169)
In: Undefined
Description: FL6*30; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 8
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Width: 6 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00018 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
6 x HOOP TIE | +1.905 | +2.605 | 1 | 51.3 | 0.1 | 30 | 700 | p010044 | 0.05076 | 0.05076 | 0.000126 | 0.000126
2 x HOOP TIE | +12.600 | +13.637 | 1.5 | 51.2 | 0.1 | 30 | 1037.5 | p010035 | 0.07506 | 0.07506 | 0.00018675 | 0.00018675
HOOP TIE | +8.080 | +8.086 | 0 |  | 0 | 10.7 | 10.7 | p010030 | 0.000787972 | 0.00115435 | 0.0000010469 | 0.00000198587
HOOP TIE | +8.080 | +8.086 | 0.1 | 55.9 | 0 | 30 | 68.3 | p010031 | 0.00452939 | 0.00659477 | 0.0000103151 | 0.0000155869
2 x HOOP TIE | +5.800 | +8.080 | 3.2 | 51.1 | 0.2 | 30 | 2280 | p010032 | 0.16452 | 0.16452 | 0.0004104 | 0.0004104
3 x HOOP TIE | +8.065 | +12.225 | 5.9 | 51 | 0.3 | 30 | 4160 | p010033 | 0.29988 | 0.29988 | 0.0007488 | 0.0007488
3 x HOOP TIE | +5.800 | +13.637 | 11.1 | 51 | 0.6 | 30 | 7837.5 | p010034 | 0.56466 | 0.56466 | 0.00141075 | 0.00141075
2 x HOOP TIE | +5.800 | +6.837 | 1.5 | 51.2 | 0.1 | 30 | 1037.5 | p010035 | 0.07506 | 0.07506 | 0.00018675 | 0.00018675
3 x HOOP TIE | +2.065 | +5.425 | 4.6 | 51 | 0.2 | 30 | 3360 | p010036 | 0.24228 | 0.24228 | 0.0006048 | 0.0006048
3 x HOOP TIE | +2.065 | +6.837 | 6.6 | 51 | 0.3 | 30 | 4772.5 | p010037 | 0.34398 | 0.34398 | 0.00085905 | 0.00085905
2 x HOOP TIE | +66.350 | +68.630 | 3.2 | 51.1 | 0.2 | 30 | 2280 | p010032 | 0.16452 | 0.16452 | 0.0004104 | 0.0004104
HOOP TIE | +68.630 | +68.636 | 0 |  | 0 | 11.2 | 11.2 | p010030 | 0.000827633 | 0.00119401 | 0.00000114605 | 0.00000208502
HOOP TIE | +68.630 | +68.636 | 0.1 | 55.9 | 0 | 30 | 68.3 | p010031 | 0.00452939 | 0.00659477 | 0.0000103151 | 0.0000155869
2 x HOOP TIE | +70.750 | +71.787 | 1.5 | 51.2 | 0.1 | 30 | 1037.5 | p010035 | 0.07506 | 0.07506 | 0.00018675 | 0.00018675
HOOP TIE | +65.830 | +65.836 | 0 |  | 0 | 10.7 | 10.7 | p010030 | 0.000787972 | 0.00115435 | 0.0000010469 | 0.00000198587
HOOP TIE | +65.830 | +65.836 | 0.1 | 55.9 | 0 | 30 | 68.3 | p010031 | 0.00452939 | 0.00659477 | 0.0000103151 | 0.0000155869
2 x HOOP TIE | +63.550 | +65.830 | 3.2 | 51.1 | 0.2 | 30 | 2280 | p010032 | 0.16452 | 0.16452 | 0.0004104 | 0.0004104
2 x HOOP TIE | +68.615 | +70.375 | 2.5 | 51.1 | 0.1 | 30 | 1760 | p010055 | 0.12708 | 0.12708 | 0.0003168 | 0.0003168
HOOP TIE | +65.815 | +70.375 | 6.3 | 51 | 0.3 | 30 | 4560 | p010056 | 0.32868 | 0.32868 | 0.0008208 | 0.0008208
3 x HOOP TIE | +63.550 | +71.787 | 11.6 | 51 | 0.6 | 30 | 8237.5 | p010057 | 0.59346 | 0.59346 | 0.00148275 | 0.00148275
2 x HOOP TIE | +63.550 | +64.587 | 1.5 | 51.2 | 0.1 | 30 | 1037.5 | p010035 | 0.07506 | 0.07506 | 0.00018675 | 0.00018675
HOOP TIE | +57.685 | +57.691 | 0 |  | 0 | 10.7 | 10.7 | p010030 | 0.000787972 | 0.00115435 | 0.0000010469 | 0.00000198587
HOOP TIE | +57.685 | +57.691 | 0.1 | 55.9 | 0 | 30 | 68.3 | p010031 | 0.00452939 | 0.00659477 | 0.0000103151 | 0.0000155869
2 x HOOP TIE | +55.405 | +57.685 | 3.2 | 51.1 | 0.2 | 30 | 2280 | p010032 | 0.16452 | 0.16452 | 0.0004104 | 0.0004104
3 x HOOP TIE | +57.670 | +63.175 | 7.8 | 51 | 0.3 | 30 | 5505 | p010049 | 0.39672 | 0.39672 | 0.0009909 | 0.0009909
3 x HOOP TIE | +55.405 | +64.587 | 12.9 | 51 | 0.6 | 30 | 9182.5 | p010050 | 0.6615 | 0.6615 | 0.00165285 | 0.00165285
2 x HOOP TIE | +55.405 | +56.442 | 1.5 | 51.2 | 0.1 | 30 | 1037.5 | p010035 | 0.07506 | 0.07506 | 0.00018675 | 0.00018675
3 x HOOP TIE | +51.065 | +55.030 | 5.6 | 51 | 0.3 | 30 | 3965 | p010060 | 0.28584 | 0.28584 | 0.0007137 | 0.0007137
3 x HOOP TIE | +51.065 | +56.442 | 7.7 | 51 | 0.3 | 30 | 5377.5 | p010061 | 0.38754 | 0.38754 | 0.00096795 | 0.00096795
2 x HOOP TIE | +48.800 | +49.837 | 1.5 | 51.2 | 0.1 | 30 | 1037.5 | p010035 | 0.07506 | 0.07506 | 0.00018675 | 0.00018675
HOOP TIE | +46.955 | +46.961 | 0 |  | 0 | 10.7 | 10.7 | p010030 | 0.000787972 | 0.00115435 | 0.0000010469 | 0.00000198587
HOOP TIE | +46.955 | +46.961 | 0.1 | 55.9 | 0 | 30 | 68.3 | p010031 | 0.00452939 | 0.00659477 | 0.0000103151 | 0.0000155869
2 x HOOP TIE | +44.675 | +46.955 | 3.2 | 51.1 | 0.2 | 30 | 2280 | p010032 | 0.16452 | 0.16452 | 0.0004104 | 0.0004104
3 x HOOP TIE | +46.940 | +48.425 | 2.1 | 51.1 | 0.1 | 30 | 1485 | p010053 | 0.10728 | 0.10728 | 0.0002673 | 0.0002673
3 x HOOP TIE | +44.675 | +49.837 | 7.3 | 51 | 0.3 | 30 | 5162.5 | p010054 | 0.37206 | 0.37206 | 0.00092925 | 0.00092925
2 x HOOP TIE | +44.675 | +45.712 | 1.5 | 51.2 | 0.1 | 30 | 1037.5 | p010035 | 0.07506 | 0.07506 | 0.00018675 | 0.00018675
HOOP TIE | +41.418 | +41.424 | 0 |  | 0 | 10.7 | 10.7 | p010030 | 0.000787972 | 0.00115435 | 0.0000010469 | 0.00000198587
HOOP TIE | +41.418 | +41.424 | 0.1 | 55.9 | 0 | 30 | 68.3 | p010031 | 0.00452939 | 0.00659477 | 0.0000103151 | 0.0000155869
2 x HOOP TIE | +39.138 | +41.418 | 3.2 | 51.1 | 0.2 | 30 | 2280 | p010032 | 0.16452 | 0.16452 | 0.0004104 | 0.0004104
3 x HOOP TIE | +41.403 | +44.300 | 4.1 | 51 | 0.2 | 30 | 2897 | p010062 | 0.208944 | 0.208944 | 0.00052146 | 0.00052146
3 x HOOP TIE | +39.138 | +45.712 | 9.3 | 51 | 0.5 | 30 | 6574.5 | p010063 | 0.473724 | 0.473724 | 0.00118341 | 0.00118341
2 x HOOP TIE | +39.138 | +40.175 | 1.5 | 51.2 | 0.1 | 30 | 1037.5 | p010035 | 0.07506 | 0.07506 | 0.00018675 | 0.00018675
HOOP TIE | +38.742 | +38.748 | 0 |  | 0 | 10.7 | 10.7 | p010030 | 0.000787972 | 0.00115435 | 0.0000010469 | 0.00000198587
HOOP TIE | +38.742 | +38.748 | 0.1 | 55.9 | 0 | 30 | 68.3 | p010031 | 0.00452939 | 0.00659477 | 0.0000103151 | 0.0000155869
2 x HOOP TIE | +36.370 | +38.742 | 3.4 | 51.1 | 0.2 | 30 | 2372 | p010051 | 0.171144 | 0.171144 | 0.00042696 | 0.00042696
3 x HOOP TIE | +36.370 | +40.175 | 5.4 | 51 | 0.3 | 30 | 3805.5 | p010052 | 0.274356 | 0.274356 | 0.00068499 | 0.00068499
2 x HOOP TIE | +36.370 | +37.407 | 1.5 | 51.2 | 0.1 | 30 | 1037.5 | p010035 | 0.07506 | 0.07506 | 0.00018675 | 0.00018675
HOOP TIE | +31.460 | +31.466 | 0 |  | 0 | 10.7 | 10.7 | p010030 | 0.000787972 | 0.00115435 | 0.0000010469 | 0.00000198587
HOOP TIE | +31.460 | +31.466 | 0.1 | 55.9 | 0 | 30 | 68.3 | p010031 | 0.00452939 | 0.00659477 | 0.0000103151 | 0.0000155869
2 x HOOP TIE | +29.180 | +31.460 | 3.2 | 51.1 | 0.2 | 30 | 2280 | p010032 | 0.16452 | 0.16452 | 0.0004104 | 0.0004104
3 x HOOP TIE | +31.445 | +35.995 | 6.3 | 51 | 0.3 | 30 | 4550 | p010058 | 0.32796 | 0.32796 | 0.000819 | 0.000819
3 x HOOP TIE | +29.180 | +37.407 | 11.6 | 51 | 0.6 | 30 | 8227.5 | p010059 | 0.59274 | 0.59274 | 0.00148095 | 0.00148095
4 x HOOP TIE | +2.850 | +3.892 | 1.5 | 51.2 | 0.1 | 30 | 1042.5 | p010047 | 0.07542 | 0.07542 | 0.00018765 | 0.00018765
6 x HOOP TIE | +1.905 | +3.892 | 2.8 | 51.1 | 0.1 | 30 | 1987.5 | p010048 | 0.14346 | 0.14346 | 0.00035775 | 0.00035775
3 x HOOP TIE | +2.240 | +8.184 | 8.5 | 51 | 0.3 | 30 | 5944 | p010045 | 0.428328 | 0.428328 | 0.00106992 | 0.00106992
HOOP TIE | +8.164 | +8.170 | 0 |  | 0 | 10.7 | 10.7 | p010030 | 0.000787971 | 0.00115435 | 0.0000010469 | 0.00000198587
HOOP TIE | +8.164 | +8.170 | 0.1 | 55.9 | 0 | 30 | 68.3 | p010031 | 0.00452939 | 0.00659477 | 0.0000103151 | 0.0000155869
2 x HOOP TIE | +8.170 | +9.747 | 2.2 | 51.1 | 0.1 | 30 | 1576.5 | p010041 | 0.113868 | 0.113868 | 0.00028377 | 0.00028377
3 x HOOP TIE | +2.240 | +9.747 | 10.6 | 51 | 0.5 | 30 | 7506.5 | p010046 | 0.540828 | 0.540828 | 0.00135117 | 0.00135117
2 x HOOP TIE | +11.315 | +12.342 | 1.5 | 51.2 | 0.1 | 30 | 1027.5 | p010038 | 0.07434 | 0.07434 | 0.00018495 | 0.00018495
3 x HOOP TIE | +7.865 | +10.895 | 4.3 | 51 | 0.2 | 30 | 3030 | p010039 | 0.21852 | 0.21852 | 0.0005454 | 0.0005454
3 x HOOP TIE | +7.865 | +12.342 | 6.3 | 51 | 0.3 | 30 | 4477.5 | p010040 | 0.32274 | 0.32274 | 0.00080595 | 0.00080595
HOOP TIE | +5.059 | +5.065 | 0 |  | 0 | 10.7 | 10.7 | p010030 | 0.000787971 | 0.00115435 | 0.0000010469 | 0.00000198587
HOOP TIE | +5.059 | +5.065 | 0.1 | 55.9 | 0 | 30 | 68.3 | p010031 | 0.00452939 | 0.00659477 | 0.0000103151 | 0.0000155869
2 x HOOP TIE | +5.065 | +6.642 | 2.2 | 51.1 | 0.1 | 30 | 1577.5 | p010041 | 0.11394 | 0.11394 | 0.00028395 | 0.00028395
3 x HOOP TIE | +2.935 | +5.080 | 2.9 | 51.1 | 0.2 | 30 | 2145 | p010042 | 0.1548 | 0.1548 | 0.0003861 | 0.0003861
3 x HOOP TIE | +2.935 | +6.643 | 5.1 | 51 | 0.3 | 30 | 3707.5 | p010043 | 0.2673 | 0.2673 | 0.00066735 | 0.00066735
2 x HOOP TIE | +21.560 | +22.598 | 1.5 | 51.2 | 0.1 | 30 | 1037.5 | p010035 | 0.07506 | 0.07506 | 0.00018675 | 0.00018675
2 x HOOP TIE | +29.180 | +30.217 | 1.5 | 51.2 | 0.1 | 30 | 1037.5 | p010035 | 0.07506 | 0.07506 | 0.00018675 | 0.00018675
HOOP TIE | +23.840 | +23.846 | 0 |  | 0 | 10.7 | 10.7 | p010030 | 0.000787972 | 0.00115435 | 0.0000010469 | 0.00000198587
HOOP TIE | +23.840 | +23.846 | 0.1 | 55.9 | 0 | 30 | 68.3 | p010031 | 0.00452939 | 0.00659477 | 0.0000103151 | 0.0000155869
2 x HOOP TIE | +21.560 | +23.840 | 3.2 | 51.1 | 0.2 | 30 | 2280 | p010032 | 0.16452 | 0.16452 | 0.0004104 | 0.0004104
3 x HOOP TIE | +23.825 | +28.805 | 7 | 51 | 0.3 | 30 | 4980 | p010066 | 0.35892 | 0.35892 | 0.0008964 | 0.0008964
3 x HOOP TIE | +21.560 | +30.217 | 12.1 | 51 | 0.6 | 30 | 8657.5 | p010067 | 0.6237 | 0.6237 | 0.00155835 | 0.00155835
HOOP TIE | +20.430 | +20.436 | 0 |  | 0 | 11.2 | 11.2 | p010030 | 0.000827633 | 0.00119401 | 0.00000114605 | 0.00000208502
HOOP TIE | +20.430 | +20.436 | 0.1 | 55.9 | 0 | 30 | 68.3 | p010031 | 0.00452939 | 0.00659477 | 0.0000103151 | 0.0000155869
2 x HOOP TIE | +18.150 | +20.430 | 3.2 | 51.1 | 0.2 | 30 | 2280 | p010032 | 0.16452 | 0.16452 | 0.0004104 | 0.0004104
3 x HOOP TIE | +20.415 | +21.145 | 1 | 51.3 | 0.1 | 30 | 730 | p010064 | 0.05292 | 0.05292 | 0.0001314 | 0.0001314
3 x HOOP TIE | +18.150 | +22.598 | 6.3 | 51 | 0.3 | 30 | 4447.5 | p010065 | 0.32058 | 0.32058 | 0.00080055 | 0.00080055

# IfcDiscreteAccessory: KNEERAIL (2)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Width: 6 mm; Length: 897 mm
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
KNEERAIL | FL6*100 | +21.500 | +21.600 | 4.1 | 45.3 | 0.2 | 100 | 471-0-010034 | 0.191364 | 0.0006 | 0.0005382
KNEERAIL | FL6*50 | +22.105 | +22.155 | 2.1 | 47.8 | 0.1 | 50 | 471-0-010033 | 0.101064 | 0.0003 | 0.0002691

# IfcDiscreteAccessory: LADDER ASS. (4)
In: Undefined
Description: FL10*80; Material: STEEL/S355JR
Tekla Common - Class: 8
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 28.7 m2; Height: 80 mm; Width: 10 mm
BaseQuantities - CrossSectionArea: 0.0008 m2
Pset_PlateCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3) | Reference
2 x LADDER ASS. | +55.315 | +58.283 | 8 | 18.6 | 0.5 | 2968 | 0.53476 | 0.53584 | 0.00237031 | 0.0023744 | pf-192
2 x LADDER ASS. | +36.280 | +39.633 | 7 | 21 | 0.6 | 3353 | 0.60406 | 0.60514 | 0.00267831 | 0.0026824 | pe-138

# IfcDiscreteAccessory: PIN (22)
In: Undefined
Description: ROD25; Material: STEEL/S355JR
Tekla Common - Class: 4
Tekla Quantity - Weight: 0.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 22.6 m2; Net surface area: 0 m2; Height: 25 mm; Width: 25 mm; Length: 165 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - NetArea: 0.013749 m2; GrossArea: 0.013749 m2; CrossSectionArea: 0.00046875 m2
Name | Bottom elevation | Top elevation | Phase | Reference | NetVolume (m3) = GrossVolume (m3)
PIN | +13.605 | +13.630 | 1 | m010019 | 0.0000773438
PIN | +6.805 | +6.830 | 1 | m010019 | 0.0000773438
2 x PIN | +57.875 | +57.900 | 8 | mf-259 | 0.0000773438
2 x PIN | +39.175 | +39.200 | 7 | me-168 | 0.0000773438
PIN | +67.355 | +67.380 | 1 | m010019 | 0.0000773438
PIN | +71.755 | +71.780 | 1 | m010019 | 0.0000773438
PIN | +64.555 | +64.580 | 1 | m010019 | 0.0000773438
PIN | +56.410 | +56.435 | 1 | m010019 | 0.0000773438
PIN | +49.805 | +49.830 | 1 | m010019 | 0.0000773438
PIN | +45.680 | +45.705 | 1 | m010019 | 0.0000773438
PIN | +40.143 | +40.168 | 1 | m010019 | 0.0000773438
PIN | +37.375 | +37.400 | 1 | m010019 | 0.0000773438
2 x PIN | +3.855 | +3.880 | 1 | m010019 | 0.0000773438
PIN | +9.709 | +9.734 | 1 | m010019 | 0.0000773438
PIN | +12.305 | +12.330 | 1 | m010019 | 0.0000773438
PIN | +6.605 | +6.630 | 1 | m010019 | 0.0000773438
PIN | +30.185 | +30.210 | 1 | m010019 | 0.0000773437
PIN | +22.565 | +22.590 | 1 | m010019 | 0.0000773437
PIN | +19.155 | +19.180 | 1 | m010019 | 0.0000773437

# IfcDiscreteAccessory: PLATE (5205)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
8 x PLATE | PLT12*91 | +63.167 | +63.433 | 8 | 8 | 2.3 | 0 | 24.9 | 0.1 | 91 | 12 | 266 | pf-39 | 0.056319 | 0.0242059 | 0.000144 | 0.000287771 | 0.000287771
12 x PLATE | FL10*70 | +63.105 | +63.243 | 8 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pf-71 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
16 x PLATE | FL10*70 | +62.949 | +63.087 | 8 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pf-71 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
18 x PLATE | FL10*70 | +70.149 | +70.287 | 8 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pf-71 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
8 x PLATE | FL10*70 | +70.305 | +70.443 | 8 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pf-71 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
30 x PLATE | FL10*70 | +65.749 | +65.887 | 8 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pf-71 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
2 x PLATE | FL10*70 | +68.105 | +68.243 | 8 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pf-71 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
2 x PLATE | FL10*70 | +57.675 | +57.813 | 8 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pf-71 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
4 x PLATE | FL10*70 | +60.338 | +60.476 | 8 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pf-71 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
PLATE | PLT8*85 | +66.075 | +66.238 | 8 | 8 | 1 | 0 | 36.4 | 0 | 85 | 8 | 163 | pf-282 | 0.0316779 | 0.0138549 | 0.000064 | 0.00011084 | 0.00011084
20 x PLATE | PLT8*163 | +66.075 | +66.238 | 8 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pf-276 | 0.0763044 | 0.0352651 | 0.000064 | 0.00028122 | 0.00028122
14 x PLATE | FL10*70 | +54.804 | +54.942 | 8 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pf-71 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
12 x PLATE | FL10*70 | +54.960 | +55.098 | 8 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pf-71 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
7 x PLATE | PLT8*163 | +66.075 | +66.238 | 8 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.4 | pf-277 | 0.0592044 | 0.0271151 | 0.000064 | 0.00021602 | 0.00021602
11 x PLATE | FL12*80 | +70.306 | +70.638 | 8 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pf-38 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
2 x PLATE | PLT12*82.1 | +70.456 | +70.638 | 8 | 8 | 1.5 | 0 | 25.8 | 0 | 82.1 | 12 | 182.5 | pf-36 | 0.0359865 | 0.0149832 | 0.000144 | 0.000178449 | 0.000178449
11 x PLATE | FL12*80 | +63.106 | +63.438 | 8 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pf-38 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
4 x PLATE | PLT12*82.1 | +63.256 | +63.438 | 8 | 8 | 1.5 | 0 | 25.8 | 0 | 82.1 | 12 | 182.5 | pf-36 | 0.0359865 | 0.0149832 | 0.000144 | 0.000178449 | 0.000178449
2 x PLATE | FL10*70 | +52.695 | +52.833 | 8 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pf-71 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
11 x PLATE | FL12*80 | +54.961 | +55.293 | 8 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pf-38 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
4 x PLATE | PLT12*82.1 | +55.111 | +55.293 | 8 | 8 | 1.5 | 0 | 25.8 | 0 | 82.1 | 12 | 182.5 | pf-36 | 0.0359865 | 0.0149832 | 0.000144 | 0.000178449 | 0.000178449
3 x PLATE | PLT8*163 | +48.525 | +48.688 | 7 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.4 | pe-200 | 0.0592009 | 0.0271134 | 0.000064 | 0.000216007 | 0.000216007
4 x PLATE | PLT8*163 | +55.130 | +55.293 | 8 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pf-276 | 0.0763009 | 0.0352634 | 0.000064 | 0.000281207 | 0.000281207
9 x PLATE | PLT8*163 | +55.130 | +55.293 | 8 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pf-276 | 0.0763242 | 0.0352745 | 0.000064 | 0.000281296 | 0.000281296
5 x PLATE | PLT8*163 | +55.130 | +55.293 | 8 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pf-276 | 0.0763044 | 0.0352651 | 0.000064 | 0.00028122 | 0.00028122
4 x PLATE | PLT8*163 | +63.275 | +63.438 | 8 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pf-276 | 0.0763242 | 0.0352745 | 0.000064 | 0.000281296 | 0.000281296
8 x PLATE | PLT8*163 | +63.275 | +63.438 | 8 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pf-276 | 0.0763044 | 0.0352651 | 0.000064 | 0.00028122 | 0.00028122
2 x PLATE | PLT8*163 | +63.275 | +63.438 | 8 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.4 | pf-277 | 0.0592242 | 0.0271245 | 0.000064 | 0.000216096 | 0.000216096
PLATE | PLT8*152.4 | +63.275 | +63.439 | 8 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pf-274 | 0.0546411 | 0.0249398 | 0.000064 | 0.000198619 | 0.000198619
3 x PLATE | PLT8*163 | +63.275 | +63.438 | 8 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pf-276 | 0.0763009 | 0.0352634 | 0.000064 | 0.000281207 | 0.000281207
PLATE | PLT8*163.6 | +63.275 | +63.439 | 8 | 8 | 1.9 | 0 | 34.7 | 0.1 | 163.6 | 8 | 197.5 | pf-280 | 0.0701042 | 0.0323109 | 0.000064 | 0.000257588 | 0.000257588
4 x PLATE | PLT8*163 | +63.275 | +63.438 | 8 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 167.2 | pf-277 | 0.059461 | 0.0272374 | 0.000064 | 0.000216999 | 0.000216999
7 x PLATE | PLT8*163 | +38.863 | +39.026 | 7 | 8 | 1.7 | 0 | 34.9 | 0.1 | 163 | 8 | 166.4 | pe-200 | 0.0592272 | 0.0271259 | 0.000064 | 0.000216107 | 0.000216107
PLATE | PLT8*152.4 | +38.863 | +39.027 | 7 | 8 | 1.6 | 0 | 35 | 0.1 | 152.4 | 8 | 163.6 | pe-197 | 0.054628 | 0.0249336 | 0.000064 | 0.000198569 | 0.000198569
PLATE | PLT8*163.6 | +38.863 | +39.027 | 7 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163.6 | 8 | 217.5 | pe-201 | 0.0769682 | 0.035583 | 0.000064 | 0.000283764 | 0.000283764
16 x PLATE | PLT8*163 | +48.525 | +48.688 | 7 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pe-196 | 0.0763242 | 0.0352745 | 0.000064 | 0.000281296 | 0.000281296
40 x PLATE | FL10*70 | +48.199 | +48.337 | 7 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pe-74 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
2 x PLATE | FL10*70 | +48.355 | +48.493 | 7 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pe-74 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
24 x PLATE | FL10*70 | +44.074 | +44.212 | 7 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pe-74 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
12 x PLATE | FL10*70 | +44.230 | +44.368 | 7 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pe-74 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
4 x PLATE | FL10*70 | +38.537 | +38.675 | 7 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pe-74 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
16 x PLATE | FL10*70 | +35.769 | +35.907 | 6 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pd-115 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
8 x PLATE | FL10*70 | +35.925 | +36.063 | 6 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pd-115 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
PLATE | PLT12*91 | +44.292 | +44.558 | 7 | 99 | 2.3 | 0 | 24.9 | 0.1 | 91 | 12 | 266 | pe-48 | 0.0563191 | 0.024206 | 0.000144 | 0.000287772 | 0.000287772
3 x PLATE | PLT12*82.1 | +44.231 | +44.563 | 7 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pe-47 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
8 x PLATE | PLT8*163 | +44.400 | +44.563 | 7 | 8 | 2.2 | 0 | 34.6 | 0.1 | 163 | 8 | 216.4 | pe-196 | 0.0763044 | 0.0352651 | 0.000064 | 0.00028122 | 0.00028122
10 x PLATE | FL12*80 | +44.231 | +44.563 | 7 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pe-45 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
PLATE | PLT12*113.3 | +44.231 | +44.563 | 7 | 99 | 3.4 | 0 | 24.3 | 0.1 | 113.3 | 12 | 331.6 | pe-41 | 0.0835746 | 0.0375869 | 0.000144 | 0.000440167 | 0.000440167
4 x PLATE | PLT12*113.3 | +44.375 | +44.563 | 7 | 8 | 1.9 | 0 | 24.9 | 0 | 113.3 | 12 | 188.5 | pe-40 | 0.0483049 | 0.0213665 | 0.000144 | 0.000246996 | 0.000255048
PLATE | PLT12*300 | +44.275 | +44.575 | 7 | 8 | 22.2 | 0 | 22.8 | 0.5 | 300 | 12 | 1126 | pe-38 | 0.504824 | 0.3378 | 0.000144 | 0.0028236 | 0.0040536
PLATE | FL10*60 | +44.553 | +44.563 | 7 | 8 | 5.1 | 0.1 | 30 | 0.2 | 60 | 10 | 1114 | pe-72 | 0.15716 | 0.06684 | 0.0001 | 0.0006684 | 0.0006684
PLATE | PLT12*82.1 | +44.381 | +44.563 | 7 | 8 | 1.5 | 0 | 25.8 | 0 | 82.1 | 12 | 182.5 | pe-37 | 0.0359865 | 0.0149832 | 0.000144 | 0.000178449 | 0.000178449
PLATE | PLT12*113.3 | +44.231 | +44.563 | 7 | 99 | 3.3 | 0 | 24.3 | 0.1 | 113.3 | 12 | 331.6 | pe-39 | 0.0803695 | 0.0375869 | 0.000144 | 0.000421417 | 0.000421417
12 x PLATE | FL12*80 | +35.926 | +36.258 | 6 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pd-28 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
2 x PLATE | PLT12*113.3 | +35.926 | +36.258 | 6 | 99 | 3.3 | 0 | 24.3 | 0.1 | 113.3 | 12 | 331.6 | pd-26 | 0.0803695 | 0.0375869 | 0.000144 | 0.000421417 | 0.000421417
4 x PLATE | PLT12*113.3 | +36.070 | +36.258 | 6 | 8 | 1.9 | 0 | 24.9 | 0 | 113.3 | 12 | 188.5 | pd-27 | 0.0483049 | 0.0213665 | 0.000144 | 0.000246996 | 0.000255048
PLATE | FL12*200 | +36.070 | +36.270 | 6 | 8 | 21.2 | 0 | 22.8 | 0.5 | 200 | 12 | 1126 | pd-25 | 0.482224 | 0.2252 | 0.000144 | 0.0027024 | 0.0027024
PLATE | FL10*60 | +36.248 | +36.258 | 6 | 8 | 5.1 | 0.1 | 30 | 0.2 | 60 | 10 | 1114 | pd-55 | 0.15716 | 0.06684 | 0.0001 | 0.0006684 | 0.0006684
2 x PLATE | PLT12*82.1 | +35.926 | +36.258 | 6 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pd-29 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
2 x PLATE | PLT12*82.1 | +36.076 | +36.258 | 6 | 8 | 1.5 | 0 | 25.8 | 0 | 82.1 | 12 | 182.5 | pd-23 | 0.0359865 | 0.0149832 | 0.000144 | 0.000178449 | 0.000178449
12 x PLATE | FL12*80 | +28.736 | +29.068 | 6 | 99 | 2.5 | 0 | 25.1 | 0.1 | 80 | 12 | 331.6 | pd-28 | 0.0622735 | 0.026528 | 0.000144 | 0.000315636 | 0.000315636
2 x PLATE | PLT12*113.3 | +28.736 | +29.068 | 6 | 99 | 3.3 | 0 | 24.3 | 0.1 | 113.3 | 12 | 331.6 | pd-26 | 0.0803695 | 0.0375869 | 0.000144 | 0.000421417 | 0.000421417
4 x PLATE | PLT12*113.3 | +28.880 | +29.068 | 6 | 8 | 1.9 | 0 | 24.9 | 0 | 113.3 | 12 | 188.5 | pd-27 | 0.0483049 | 0.0213665 | 0.000144 | 0.000246996 | 0.000255048
PLATE | FL12*200 | +28.880 | +29.080 | 6 | 8 | 21.2 | 0 | 22.8 | 0.5 | 200 | 12 | 1126 | pd-25 | 0.482224 | 0.2252 | 0.000144 | 0.0027024 | 0.0027024
PLATE | FL10*60 | +29.058 | +29.068 | 6 | 8 | 5.1 | 0.1 | 30 | 0.2 | 60 | 10 | 1114 | pd-55 | 0.15716 | 0.06684 | 0.0001 | 0.0006684 | 0.0006684
2 x PLATE | PLT12*82.1 | +28.736 | +29.068 | 6 | 8 | 2.6 | 0 | 25.1 | 0.1 | 82.1 | 12 | 332.6 | pd-29 | 0.0639048 | 0.0273065 | 0.000144 | 0.000324978 | 0.000324978
2 x PLATE | PLT12*82.1 | +28.886 | +29.068 | 6 | 8 | 1.5 | 0 | 25.8 | 0 | 82.1 | 12 | 182.5 | pd-23 | 0.0359865 | 0.0149832 | 0.000144 | 0.000178449 | 0.000178449
4 x PLATE | PLT10*81.8 | +63.183 | +63.361 | 8 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pf-69 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
2 x PLATE | PLT16*210 | +63.167 | +63.377 | 8 | 99 | 11.3 | 0 | 17.7 | 0.2 | 210 | 16 | 425 | pf-196 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*208.8 | +63.106 | +63.438 | 8 | 99 | 8.2 | 0 | 17.8 | 0.1 | 208.8 | 16 | 332 | pf-218 | 0.147129 | 0.069336 | 0.000256 | 0.00105018 | 0.00105018
PLATE | PLT16*212.5 | +63.106 | +63.438 | 8 | 99 | 8.1 | 0 | 17.9 | 0.1 | 212.5 | 16 | 332 | pf-217 | 0.14507 | 0.0705635 | 0.000256 | 0.00103462 | 0.00103462
4 x PLATE | PLT10*81.8 | +57.753 | +57.931 | 8 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pf-69 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
2 x PLATE | PLT16*210 | +57.737 | +57.947 | 8 | 99 | 11.3 | 0 | 17.7 | 0.2 | 210 | 16 | 425 | pf-196 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*208.8 | +57.676 | +58.008 | 8 | 99 | 8.2 | 0 | 17.8 | 0.1 | 208.8 | 16 | 332 | pf-218 | 0.147129 | 0.069336 | 0.000256 | 0.00105018 | 0.00105018
PLATE | PLT16*212.5 | +57.676 | +58.008 | 8 | 99 | 8.1 | 0 | 17.9 | 0.1 | 212.5 | 16 | 332 | pf-217 | 0.14507 | 0.0705635 | 0.000256 | 0.00103462 | 0.00103462
4 x PLATE | PLT10*81.8 | +55.038 | +55.216 | 8 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pf-69 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
2 x PLATE | PLT16*210 | +55.022 | +55.232 | 8 | 99 | 11.3 | 0 | 17.7 | 0.2 | 210 | 16 | 425 | pf-196 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*208.8 | +54.961 | +55.293 | 8 | 99 | 8.2 | 0 | 17.8 | 0.1 | 208.8 | 16 | 332 | pf-218 | 0.147129 | 0.069336 | 0.000256 | 0.00105018 | 0.00105018
PLATE | PLT16*212.5 | +54.961 | +55.293 | 8 | 99 | 8.1 | 0 | 17.9 | 0.1 | 212.5 | 16 | 332 | pf-217 | 0.14507 | 0.0705635 | 0.000256 | 0.00103462 | 0.00103462
2 x PLATE | FL10*70 | +33.654 | +33.792 | 6 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pd-115 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
4 x PLATE | PLT10*81.8 | +52.773 | +52.951 | 8 | 99 | 1 | 0 | 30.6 | 0 | 81.8 | 10 | 178.1 | pf-69 | 0.0264636 | 0.0145791 | 0.0001 | 0.000110151 | 0.000252685
2 x PLATE | PLT16*210 | +52.757 | +52.967 | 8 | 99 | 11.3 | 0 | 17.7 | 0.2 | 210 | 16 | 425 | pf-196 | 0.19882 | 0.19882 | 0.00336 | 0.001428 | 0.001428
PLATE | PLT16*208.8 | +52.696 | +53.028 | 8 | 99 | 8.2 | 0 | 17.8 | 0.1 | 208.8 | 16 | 332 | pf-218 | 0.147129 | 0.069336 | 0.000256 | 0.00105018 | 0.00105018
PLATE | PLT16*212.5 | +52.696 | +53.028 | 8 | 99 | 8.1 | 0 | 17.9 | 0.1 | 212.5 | 16 | 332 | pf-217 | 0.14507 | 0.0705635 | 0.000256 | 0.00103462 | 0.00103462
2 x PLATE | FL10*70 | +31.383 | +31.521 | 6 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pd-115 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
12 x PLATE | FL10*70 | +28.735 | +28.873 | 6 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pd-115 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
28 x PLATE | FL10*70 | +28.579 | +28.717 | 6 | 99 | 0.7 | 0 | 30.9 | 0 | 70 | 10 | 137.8 | pd-115 | 0.0228223 | 0.009646 | 0.0001 | 0.00009421 | 0.00009421
2 x PLATE | PLT16*142.1 | +48.356 | +48.688 | 7 | 99 | 4.6 | 0 | 18.9 | 0.1 | 142.1 | 16 | 331.6 | pe-163 | 0.0878981 | 0.0471204 | 0.000256 | 0.000591158 | 0.000591158
2 x PLATE | FL12*60 | +48.688 | +48.700 | 7 | 99 | 0.7 | 0 | 27.8 | 0 | 60 | 12 | 150 | pe-46 | 0.0192776 | 0.009 | 0.000144 | 0.0000888 | 0.0000888
2 x PLATE | PLT10*94.5 | +57.645 | +57.655 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT16*165 | +70.624 | +70.640 | 8 | 99 | 4.6 | 0 | 18.6 | 0.1 | 165 | 16 | 279.9 | pf-213 | 0.0869283 | 0.0462 | 0.000256 | 0.0005952 | 0.0005952
2 x PLATE | PLT10*94.5 | +70.069 | +70.157 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +69.875 | +70.364 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-195 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*326.1 | +70.079 | +70.624 | 8 | 99 | 15.8 | 0 | 17.5 | 0.3 | 326.1 | 16 | 545 | pf-211 | 0.275679 | 0.17773 | 0.000256 | 0.0020114 | 0.0020114
2 x PLATE | PLT10*94.5 | +66.482 | +66.570 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +66.275 | +66.764 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-195 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*310 | +66.250 | +66.560 | 8 | 99 | 11.6 | 0 | 17.7 | 0.2 | 310 | 16 | 339.6 | pf-210 | 0.204038 | 0.105296 | 0.000256 | 0.00147667 | 0.00147667
2 x PLATE | PLT10*94.5 | +65.553 | +65.683 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +65.379 | +65.869 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-195 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*340.8 | +65.554 | +65.894 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 340.8 | 16 | 362.2 | pf-209 | 0.23266 | 0.123415 | 0.000256 | 0.00169514 | 0.00169514
PLATE | PLT10*94.5 | +63.661 | +63.791 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | PLT10*94.5 | +63.661 | +63.791 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +63.475 | +63.965 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-195 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*340.8 | +63.450 | +63.791 | 8 | 99 | 11.6 | 0 | 17.7 | 0.2 | 340.8 | 16 | 350.2 | pf-208 | 0.203987 | 0.119325 | 0.000256 | 0.00147911 | 0.00147911
2 x PLATE | PLT10*94.5 | +62.785 | +62.858 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +62.587 | +63.069 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-195 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*296.6 | +62.798 | +63.094 | 8 | 99 | 10.5 | 0 | 17.7 | 0.2 | 296.6 | 16 | 330.4 | pf-207 | 0.1852 | 0.0979885 | 0.000256 | 0.00133648 | 0.00133648
2 x PLATE | PLT10*94.5 | +58.256 | +58.330 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +58.045 | +58.527 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-195 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*296.6 | +58.020 | +58.317 | 8 | 99 | 11.5 | 0 | 17.7 | 0.2 | 296.6 | 16 | 344.4 | pf-206 | 0.201892 | 0.102142 | 0.000256 | 0.00146016 | 0.00146016
2 x PLATE | PLT10*94.5 | +57.322 | +57.456 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +57.151 | +57.639 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-195 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*342.8 | +57.322 | +57.664 | 8 | 99 | 11.5 | 0 | 17.7 | 0.2 | 342.8 | 16 | 347.8 | pf-205 | 0.2028 | 0.119244 | 0.000256 | 0.00146998 | 0.00146998
2 x PLATE | PLT10*94.5 | +55.513 | +55.647 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +55.330 | +55.819 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-195 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*342.8 | +55.305 | +55.648 | 8 | 99 | 12.9 | 0 | 17.5 | 0.2 | 342.8 | 16 | 351.8 | pf-204 | 0.226312 | 0.120616 | 0.000256 | 0.00164663 | 0.00164663
2 x PLATE | PLT10*94.5 | +54.605 | +54.757 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +54.448 | +54.924 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-195 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*350.6 | +54.599 | +54.949 | 8 | 99 | 11.6 | 0 | 17.7 | 0.2 | 350.6 | 16 | 353.1 | pf-203 | 0.205736 | 0.123782 | 0.000256 | 0.00149182 | 0.00149182
2 x PLATE | PLT10*94.5 | +53.232 | +53.384 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +53.065 | +53.541 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-195 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*345.1 | +53.040 | +53.391 | 8 | 99 | 12.9 | 0 | 17.5 | 0.2 | 345.1 | 16 | 350.8 | pf-202 | 0.226019 | 0.121054 | 0.000256 | 0.00164435 | 0.00164435
2 x PLATE | PLT10*94.5 | +48.932 | +49.021 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +48.725 | +49.214 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-195 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*311.7 | +48.700 | +49.012 | 7 | 99 | 11.6 | 0 | 17.7 | 0.2 | 311.7 | 16 | 342.5 | pe-183 | 0.206523 | 0.106744 | 0.000256 | 0.00149559 | 0.00149559
2 x PLATE | PLT10*94.5 | +52.363 | +52.453 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +52.170 | +52.659 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-195 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*311.7 | +52.373 | +52.684 | 8 | 99 | 10.9 | 0 | 17.7 | 0.2 | 311.7 | 16 | 338.5 | pf-201 | 0.192847 | 0.105497 | 0.000256 | 0.00139469 | 0.00139469
PLATE | PLT16*95 | +63.450 | +63.545 | 8 | 99 | 1 | 0 | 22.2 | 0 | 95 | 16 | 95 | pf-219 | 0.0192958 | 0.009025 | 0.000256 | 0.0001106 | 0.0001106
PLATE | PLT16*95 | +62.999 | +63.094 | 8 | 99 | 1 | 0 | 22.2 | 0 | 95 | 16 | 95 | pf-219 | 0.0192958 | 0.009025 | 0.000256 | 0.0001106 | 0.0001106
PLATE | PLT10*94.6 | +65.529 | +65.539 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.6 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT10*94.5 | +65.529 | +65.539 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +65.329 | +65.754 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*270 | +65.554 | +66.560 | 8 | 99 | 28.6 | 0 | 17.3 | 0.5 | 270 | 16 | 1006.4 | pf-221 | 0.493888 | 0.271723 | 0.000256 | 0.00363795 | 0.00434756
2 x PLATE | PLT10*94.5 | +63.560 | +63.570 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +63.345 | +63.770 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
2 x PLATE | PLT10*94.5 | +62.974 | +62.984 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +62.774 | +63.199 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*270 | +62.999 | +63.545 | 8 | 99 | 18.5 | 0 | 17.3 | 0.3 | 270 | 16 | 545.6 | pf-225 | 0.320723 | 0.147312 | 0.000256 | 0.00235699 | 0.00235699
2 x PLATE | PLT10*94.5 | +58.332 | +58.342 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +58.117 | +58.542 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | FL16*250 | +57.445 | +57.870 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT16*270 | +57.670 | +58.317 | 8 | 99 | 21.9 | 0 | 17.3 | 0.3 | 270 | 16 | 646.2 | pf-224 | 0.378278 | 0.174479 | 0.000256 | 0.00279167 | 0.00279167
2 x PLATE | PLT10*94.5 | +55.663 | +55.673 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | FL16*250 | +55.448 | +55.873 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
PLATE | PLT10*94.6 | +54.930 | +54.940 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.6 | 10 | 203.5 | pf-68 | 0.0342153 | 0.0192428 | 0.0001 | 0.000145657 | 0.000328269
PLATE | PLT10*94.5 | +54.930 | +54.940 | 8 | 99 | 1.1 | 0 | 30 | 0 | 94.5 | 10 | 203.5 | pf-68 | 0.0342152 | 0.0192428 | 0.0001 | 0.000145656 | 0.000328269
PLATE | FL16*250 | +54.730 | +55.155 | 8 | 99 | 13.3 | 0 | 17.5 | 0.2 | 250 | 16 | 425 | pf-220 | 0.2341 | 0.2341 | 0.004 | 0.0017 | 0.0017
