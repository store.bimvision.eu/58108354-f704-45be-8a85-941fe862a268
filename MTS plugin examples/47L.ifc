Properties of the parts of a building model (IFC2X3), part 16 of 22

# IfcDiscreteAccessory: RUNGS (462)
Name | Bottom elevation | Top elevation | Phase | Reference | NetVolume (m3) = GrossVolume (m3)
RUNGS | +26.523 | +26.547 | 1 | m010024 | 0.000220312
RUNGS | +26.820 | +26.845 | 1 | m010024 | 0.000220312
RUNGS | +27.116 | +27.142 | 1 | m010024 | 0.000220312
RUNGS | +27.413 | +27.439 | 1 | m010024 | 0.000220312
RUNGS | +27.711 | +27.735 | 1 | m010024 | 0.000220312
RUNGS | +28.008 | +28.032 | 1 | m010024 | 0.000220312
RUNGS | +28.305 | +28.329 | 1 | m010024 | 0.000220312
RUNGS | +28.602 | +28.627 | 1 | m010024 | 0.000220312
RUNGS | +28.898 | +28.924 | 1 | m010024 | 0.000220312
RUNGS | +29.195 | +29.221 | 1 | m010024 | 0.000220312
RUNGS | +21.576 | +21.601 | 1 | m010024 | 0.000220312

# IfcDiscreteAccessory: SAFETY ARM (22)
In: Undefined
Description: ROD25; Material: STEEL/S355JR
Tekla Common - Class: 9
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 21.5 m2; Net surface area: 0.1 m2; Height: 25 mm; Width: 25 mm; Length: 890 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - NetArea: 0.0700422 m2; GrossArea: 0.0700422 m2; CrossSectionArea: 0.00046875 m2; NetVolume: 0.000417188 m3; GrossVolume: 0.000417188 m3
Name | Bottom elevation | Top elevation | Phase | Reference
SAFETY ARM | +13.635 | +13.660 | 1 | m010023
SAFETY ARM | +6.835 | +6.860 | 1 | m010023
2 x SAFETY ARM | +57.905 | +57.930 | 8 | mf-258
2 x SAFETY ARM | +39.205 | +39.230 | 7 | me-167
SAFETY ARM | +67.385 | +67.410 | 1 | m010023
SAFETY ARM | +71.785 | +71.810 | 1 | m010023
SAFETY ARM | +64.585 | +64.610 | 1 | m010023
SAFETY ARM | +56.440 | +56.465 | 1 | m010023
SAFETY ARM | +49.835 | +49.860 | 1 | m010023
SAFETY ARM | +45.710 | +45.735 | 1 | m010023
SAFETY ARM | +40.173 | +40.198 | 1 | m010023
SAFETY ARM | +37.405 | +37.430 | 1 | m010023
2 x SAFETY ARM | +3.885 | +3.910 | 1 | m010023
SAFETY ARM | +9.739 | +9.764 | 1 | m010023
SAFETY ARM | +12.335 | +12.360 | 1 | m010023
SAFETY ARM | +6.635 | +6.660 | 1 | m010023
SAFETY ARM | +30.215 | +30.240 | 1 | m010023
SAFETY ARM | +22.595 | +22.620 | 1 | m010023
SAFETY ARM | +19.185 | +19.210 | 1 | m010023

# IfcDiscreteAccessory: SPILCE PLATE (94)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Class: 8
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 220 mm
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
12 x SPILCE PLATE | PLT12*220 | +6.201 | +7.201 | 5 | 20.8 | 22.6 | 0.5 | 12 | 1000 | pc-67 | 0.46928 | 0.22 | 0.000144 | 0.00264
12 x SPILCE PLATE | PLT12*220 | +49.202 | +50.202 | 7 | 20.8 | 22.6 | 0.5 | 12 | 1000 | pe-33 | 0.46928 | 0.22 | 0.000144 | 0.00264
12 x SPILCE PLATE | PLT12*220 | +58.704 | +59.704 | 8 | 20.8 | 22.6 | 0.5 | 12 | 1000 | pf-28 | 0.46928 | 0.22 | 0.000144 | 0.00264
2 x SPILCE PLATE | PLT12*220 | +13.003 | +14.003 | 5 | 20.8 | 22.6 | 0.5 | 12 | 1000 | pc-67 | 0.46928 | 0.22 | 0.000144 | 0.00264
12 x SPILCE PLATE | PLT3*220 | +37.271 | +37.770 | 6 | 2.6 | 86.6 | 0.2 | 3 | 499 | pd-173 | 0.223874 | 0.10978 | 0.000009 | 0.00032934
12 x SPILCE PLATE | PLT16*220 | +36.770 | +37.770 | 6 | 27.6 | 17.3 | 0.5 | 16 | 1000 | pd-129 | 0.47904 | 0.22 | 0.000256 | 0.00352
12 x SPILCE PLATE | PLT16*220 | +24.803 | +25.803 | 4 | 27.6 | 17.3 | 0.5 | 16 | 1000 | pb-235 | 0.47904 | 0.22 | 0.000256 | 0.00352
20 x SPILCE PLATE | PLT16*220 | +11.501 | +12.501 | 3 | 27.6 | 17.3 | 0.5 | 16 | 1000 | pa-135 | 0.47904 | 0.22 | 0.000256 | 0.00352

# IfcDiscreteAccessory: SPLICE PLATES (258)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Class: 8
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
24 x SPLICE PLATES | PLT16*120 | +6.201 | +7.201 | 5 | 15.1 | 18.3 | 0.3 | 120 | 16 | 1000 | pc-207 | 0.27584 | 0.12 | 0.000256 | 0.00192
12 x SPLICE PLATES | FL16*300 | +6.201 | +7.201 | 5 | 37.7 | 16.9 | 0.6 | 300 | 16 | 1000 | pc-362 | 0.6416 | 0.3 | 0.000256 | 0.0048
24 x SPLICE PLATES | PLT16*120 | +49.202 | +50.202 | 7 | 15.1 | 18.3 | 0.3 | 120 | 16 | 1000 | pe-167 | 0.27584 | 0.12 | 0.000256 | 0.00192
12 x SPLICE PLATES | FL16*300 | +49.202 | +50.202 | 7 | 37.7 | 16.9 | 0.6 | 300 | 16 | 1000 | pe-169 | 0.6416 | 0.3 | 0.000256 | 0.0048
24 x SPLICE PLATES | PLT16*120 | +58.704 | +59.704 | 8 | 15.1 | 18.3 | 0.3 | 120 | 16 | 1000 | pf-215 | 0.27584 | 0.12 | 0.000256 | 0.00192
12 x SPLICE PLATES | FL16*300 | +58.704 | +59.704 | 8 | 37.7 | 16.9 | 0.6 | 300 | 16 | 1000 | pf-266 | 0.6416 | 0.3 | 0.000256 | 0.0048
4 x SPLICE PLATES | PLT16*120 | +13.003 | +14.003 | 5 | 15.1 | 18.3 | 0.3 | 120 | 16 | 1000 | pc-207 | 0.27584 | 0.12 | 0.000256 | 0.00192
2 x SPLICE PLATES | FL16*300 | +13.003 | +14.003 | 5 | 37.7 | 16.9 | 0.6 | 300 | 16 | 1000 | pc-362 | 0.6416 | 0.3 | 0.000256 | 0.0048
12 x SPLICE PLATES | PLT10*300 | +37.271 | +37.770 | 6 | 11.9 | 26.8 | 0.3 | 300 | 10 | 499 | pd-47 | 0.31538 | 0.1497 | 0.0001 | 0.001497
24 x SPLICE PLATES | PLT20*120 | +36.770 | +37.770 | 6 | 18.8 | 15.1 | 0.3 | 120 | 20 | 1000 | pd-2 | 0.2848 | 0.12 | 0.0004 | 0.0024
12 x SPLICE PLATES | FL20*300 | +36.770 | +37.770 | 6 | 47.1 | 13.9 | 0.6 | 300 | 20 | 1000 | pd-1 | 0.652 | 0.3 | 0.0004 | 0.006
24 x SPLICE PLATES | PLT20*120 | +24.803 | +25.803 | 4 | 18.8 | 15.1 | 0.3 | 120 | 20 | 1000 | pb-24 | 0.2848 | 0.12 | 0.0004 | 0.0024
12 x SPLICE PLATES | FL20*300 | +24.803 | +25.803 | 4 | 47.1 | 13.9 | 0.6 | 300 | 20 | 1000 | pb-23 | 0.652 | 0.3 | 0.0004 | 0.006
40 x SPLICE PLATES | PLT20*120 | +11.501 | +12.501 | 3 | 18.8 | 15.1 | 0.3 | 120 | 20 | 1000 | pa-41 | 0.2848 | 0.12 | 0.0004 | 0.0024
20 x SPLICE PLATES | FL20*300 | +11.501 | +12.501 | 3 | 47.1 | 13.9 | 0.6 | 300 | 20 | 1000 | pa-40 | 0.652 | 0.3 | 0.0004 | 0.006

# IfcDiscreteAccessory: STIFFENER (82)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Bottom elevation: +12.156; Top elevation: +12.488; Phase: 5; Class: 8
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Length: 331.6 mm
Pset_PlateCommon - LoadBearing: yes
Name | Description | Weight (kg) | Area per tons (m2) | Height (mm) | Width (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
3 x STIFFENER | PLT12*112.1 | 3.4 | 24.3 | 112.1 | 12 | pc-73 | 0.0843326 | 0.0371724 | 0.000144 | 0.000443368
13 x STIFFENER | PLT12*98.1 | 2.9 | 24.6 | 98.1 | 12 | pc-72 | 0.0747118 | 0.03253 | 0.000144 | 0.00038766
32 x STIFFENER | PLT10*82.1 | 2.1 | 29.2 | 82.1 | 10 | pc-134 | 0.062097 | 0.0272244 | 0.0001 | 0.000269994
7 x STIFFENER | PLT12*161.4 | 4.9 | 23.5 | 161.4 | 12 | pc-70 | 0.118177 | 0.0535037 | 0.000144 | 0.000639344
5 x STIFFENER | PLT12*147.4 | 4.6 | 23.8 | 147.5 | 12 | pc-69 | 0.108556 | 0.0488613 | 0.000144 | 0.000583635
STIFFENER | PLT10*161.3 | 4.1 | 27.8 | 161.4 | 10 | pc-135 | 0.116239 | 0.0535029 | 0.0001 | 0.000532779
5 x STIFFENER | PLT10*161.4 | 4.1 | 27.8 | 161.4 | 10 | pc-135 | 0.116241 | 0.0535037 | 0.0001 | 0.000532787
2 x STIFFENER | PLT10*171.4 | 4.5 | 27.8 | 171.4 | 10 | pc-136 | 0.123073 | 0.0568197 | 0.0001 | 0.000565947
2 x STIFFENER | PLT12*171.4 | 5.4 | 23.5 | 171.4 | 12 | pc-71 | 0.125049 | 0.0568197 | 0.000144 | 0.000679136
10 x STIFFENER | PLT12*157.4 | 4.9 | 23.6 | 157.3 | 12 | pc-68 | 0.115428 | 0.0521773 | 0.000144 | 0.000623427
2 x STIFFENER | PLT10*171.3 | 4.5 | 27.8 | 171.4 | 10 | pc-136 | 0.123071 | 0.0568189 | 0.0001 | 0.000565939

# IfcDiscreteAccessory: STRINGER (104)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x STRINGER | FL10*80 | +5.710 | +13.983 | 1 | 8 | 51.9 | 28.7 | 1.5 | 80 | 10 | 8273 | p010017 | 1.48966 | 1.49074 | 0.0008 | 0.00661431 | 0.0066184
2 x STRINGER | FL10*80 | -0.260 | +7.183 | 1 | 8 | 46.7 | 28.7 | 1.3 | 80 | 10 | 7443 | p010014 | 1.34026 | 1.34134 | 0.0008 | 0.00595031 | 0.0059544
2 x STRINGER | FL10*80 | +55.315 | +58.283 | 8 | 8 | 18.6 | 28.7 | 0.5 | 80 | 10 | 2968 | pf-193 | 0.53476 | 0.53584 | 0.0008 | 0.00237031 | 0.0023744
2 x STRINGER | FL10*80 | +36.280 | +39.633 | 7 | 8 | 21 | 28.7 | 0.6 | 80 | 10 | 3353 | pe-139 | 0.60406 | 0.60514 | 0.0008 | 0.00267831 | 0.0026824
2 x STRINGER | FL10*80 | +63.460 | +72.273 | 1 | 8 | 55.3 | 28.7 | 1.6 | 80 | 10 | 8813 | p010013 | 1.58686 | 1.58794 | 0.0008 | 0.00704631 | 0.0070504
2 x STRINGER | FL10*80 | +55.315 | +65.028 | 1 | 8 | 61 | 28.7 | 1.7 | 80 | 10 | 9713 | p010012 | 1.74886 | 1.74994 | 0.0008 | 0.00776631 | 0.0077704
2 x STRINGER | FL10*80 | +48.710 | +56.858 | 1 | 8 | 51.1 | 28.7 | 1.5 | 80 | 10 | 8148 | p010011 | 1.46716 | 1.46824 | 0.0008 | 0.00651431 | 0.0065184
2 x STRINGER | FL10*80 | +44.585 | +50.263 | 1 | 8 | 35.6 | 28.7 | 1 | 80 | 10 | 5678 | p010010 | 1.02256 | 1.02364 | 0.0008 | 0.00453831 | 0.0045424
2 x STRINGER | FL10*80 | +39.048 | +46.143 | 1 | 8 | 44.5 | 28.7 | 1.3 | 80 | 10 | 7095 | p010009 | 1.27762 | 1.2787 | 0.0008 | 0.00567191 | 0.005676
2 x STRINGER | FL10*80 | +36.280 | +40.631 | 1 | 8 | 27.2 | 28.7 | 0.8 | 80 | 10 | 4351 | p010006 | 0.7837 | 0.78478 | 0.0008 | 0.00347671 | 0.0034808
2 x STRINGER | FL10*80 | +29.090 | +37.828 | 1 | 8 | 54.8 | 28.7 | 1.6 | 80 | 10 | 8738 | p010016 | 1.57336 | 1.57444 | 0.0008 | 0.00698631 | 0.0069904
STRINGER | PFC200*75 | +68.250 | +68.450 | 8 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 94.7 | mf-23 | 0.0639131 | 0.0639131 | 0.00309554 | 0.000181058 | 0.000293012
STRINGER | PFC200*75 | +68.250 | +68.450 | 8 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 94.7 | mf-24 | 0.0639131 | 0.0639131 | 0.00309554 | 0.000181058 | 0.000293012
STRINGER | PFC200*75 | +63.250 | +63.450 | 8 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 94.7 | mf-23 | 0.0639133 | 0.0639133 | 0.00309554 | 0.000181058 | 0.000293013
STRINGER | PFC200*75 | +63.250 | +63.450 | 8 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 94.7 | mf-24 | 0.0639133 | 0.0639133 | 0.00309554 | 0.000181058 | 0.000293013
STRINGER | PFC200*75 | +57.820 | +58.020 | 8 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 91.8 | mf-21 | 0.0619733 | 0.0619733 | 0.00309554 | 0.000174922 | 0.000284119
STRINGER | PFC200*75 | +57.820 | +58.020 | 8 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 91.8 | mf-22 | 0.0619733 | 0.0619733 | 0.00309554 | 0.000174922 | 0.000284119
STRINGER | PFC200*75 | +52.840 | +53.040 | 8 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.3 | mf-19 | 0.0602884 | 0.0602884 | 0.00309554 | 0.000169507 | 0.000276394
STRINGER | PFC200*75 | +52.840 | +53.040 | 8 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.3 | mf-20 | 0.0602884 | 0.0602884 | 0.00309554 | 0.000169507 | 0.000276394
STRINGER | PFC200*75 | +48.500 | +48.700 | 7 | 3 | 2.5 | 27.8 | 0.1 | 200 | 75 | 102 | me-18 | 0.0688798 | 0.0688798 | 0.00309554 | 0.000208738 | 0.000315782
STRINGER | PFC200*75 | +48.500 | +48.700 | 8 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.3 | mf-19 | 0.0602682 | 0.0602682 | 0.00309554 | 0.00016944 | 0.000276301
STRINGER | PFC200*75 | +48.500 | +48.700 | 7 | 3 | 2.5 | 27.8 | 0.1 | 200 | 75 | 102 | me-17 | 0.0688798 | 0.0688798 | 0.00309554 | 0.000208738 | 0.000315782
STRINGER | PFC200*75 | +48.500 | +48.700 | 8 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.3 | mf-20 | 0.0602682 | 0.0602682 | 0.00309554 | 0.00016944 | 0.000276301
STRINGER | PFC200*75 | +44.375 | +44.575 | 7 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 88.7 | me-15 | 0.0598819 | 0.0598819 | 0.00309554 | 0.000168199 | 0.00027453
STRINGER | PFC200*75 | +44.375 | +44.575 | 7 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 88.7 | me-16 | 0.0598819 | 0.0598819 | 0.00309554 | 0.000168199 | 0.00027453
STRINGER | PFC200*75 | +38.838 | +39.038 | 7 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 93.6 | me-13 | 0.0631962 | 0.0631962 | 0.00309554 | 0.000178786 | 0.000289725
STRINGER | PFC200*75 | +38.838 | +39.038 | 7 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 93.6 | me-14 | 0.0631962 | 0.0631962 | 0.00309554 | 0.000178786 | 0.000289725
STRINGER | PFC200*75 | +33.799 | +33.999 | 6 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.5 | md-14 | 0.060456 | 0.060456 | 0.00309554 | 0.000170046 | 0.000277163
STRINGER | PFC200*75 | +33.799 | +33.999 | 6 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.5 | md-15 | 0.060456 | 0.060456 | 0.00309554 | 0.000170046 | 0.000277163
STRINGER | PFC200*75 | +28.880 | +29.080 | 6 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.5 | md-14 | 0.0604194 | 0.0604194 | 0.00309554 | 0.000169927 | 0.000276995
STRINGER | PFC200*75 | +28.880 | +29.080 | 6 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.5 | md-15 | 0.0604194 | 0.0604194 | 0.00309554 | 0.000169927 | 0.000276995
STRINGER | PFC200*75 | +24.118 | +24.318 | 6 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 90.2 | md-14 | 0.0609129 | 0.0609129 | 0.00309554 | 0.000171507 | 0.000279257
STRINGER | PFC200*75 | +24.118 | +24.318 | 6 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 90.2 | md-15 | 0.0609129 | 0.0609129 | 0.00309554 | 0.000171507 | 0.000279257
STRINGER | PFC200*75 | +19.555 | +19.755 | 4 | 3 | 2.5 | 27.8 | 0.1 | 200 | 75 | 101.7 | mb-15 | 0.0685946 | 0.0685946 | 0.00309554 | 0.000206592 | 0.000314474
STRINGER | PFC200*75 | +19.555 | +19.755 | 4 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.6 | mb-12 | 0.0605186 | 0.0605186 | 0.00309554 | 0.000170244 | 0.000277449
STRINGER | PFC200*75 | +19.555 | +19.755 | 4 | 3 | 2.5 | 27.8 | 0.1 | 200 | 75 | 101.7 | mb-14 | 0.0685946 | 0.0685946 | 0.00309554 | 0.000206592 | 0.000314474
STRINGER | PFC200*75 | +19.555 | +19.755 | 4 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.6 | mb-13 | 0.0605186 | 0.0605186 | 0.00309554 | 0.000170244 | 0.000277449
STRINGER | PFC200*75 | +15.500 | +15.700 | 4 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 92.7 | mb-11 | 0.062599 | 0.062599 | 0.00309554 | 0.000176888 | 0.000286987
STRINGER | PFC200*75 | +15.500 | +15.700 | 4 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 92.7 | mb-10 | 0.062599 | 0.062599 | 0.00309554 | 0.000176888 | 0.000286987
STRINGER | PFC200*75 | +70.450 | +70.650 | 8 | 3 | 2.5 | 27.8 | 0.1 | 200 | 75 | 99.5 | mf-26 | 0.067181 | 0.067181 | 0.00309554 | 0.000195766 | 0.000307994
STRINGER | PFC200*75 | +70.450 | +70.650 | 8 | 3 | 2.5 | 27.8 | 0.1 | 200 | 75 | 99.5 | mf-25 | 0.067181 | 0.067181 | 0.00309554 | 0.000195766 | 0.000307994
STRINGER | PFC200*75 | +66.050 | +66.250 | 8 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 94.7 | mf-24 | 0.0639103 | 0.0639103 | 0.00309554 | 0.000181045 | 0.000292999
STRINGER | PFC200*75 | +66.050 | +66.250 | 8 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 94.7 | mf-23 | 0.0639103 | 0.0639103 | 0.00309554 | 0.000181045 | 0.000292999
STRINGER | PFC200*75 | +60.535 | +60.735 | 8 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 91.8 | mf-22 | 0.0619891 | 0.0619891 | 0.00309554 | 0.000174948 | 0.000284191
STRINGER | PFC200*75 | +60.535 | +60.735 | 8 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 91.8 | mf-21 | 0.0619891 | 0.0619891 | 0.00309554 | 0.000174948 | 0.000284191
STRINGER | PFC200*75 | +55.105 | +55.305 | 8 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 91.8 | mf-22 | 0.0619891 | 0.0619891 | 0.00309554 | 0.000174948 | 0.000284191
STRINGER | PFC200*75 | +55.105 | +55.305 | 8 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 91.8 | mf-21 | 0.0619891 | 0.0619891 | 0.00309554 | 0.000174948 | 0.000284191
STRINGER | PFC200*75 | +50.953 | +51.153 | 8 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.3 | mf-20 | 0.0602728 | 0.0602728 | 0.00309554 | 0.000169458 | 0.000276323
STRINGER | PFC200*75 | +50.953 | +51.153 | 8 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.3 | mf-19 | 0.0602728 | 0.0602728 | 0.00309554 | 0.000169458 | 0.000276323
STRINGER | PFC200*75 | +46.813 | +47.013 | 7 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 88.7 | me-16 | 0.0598524 | 0.0598524 | 0.00309554 | 0.000168107 | 0.000274395
STRINGER | PFC200*75 | +46.813 | +47.013 | 7 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 88.7 | me-15 | 0.0598524 | 0.0598524 | 0.00309554 | 0.000168107 | 0.000274395
STRINGER | PFC200*75 | +41.606 | +41.806 | 7 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 93.6 | me-14 | 0.0632208 | 0.0632208 | 0.00309554 | 0.000178866 | 0.000289838
STRINGER | PFC200*75 | +41.606 | +41.806 | 7 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 93.6 | me-13 | 0.0632208 | 0.0632208 | 0.00309554 | 0.000178866 | 0.000289838
STRINGER | PFC200*75 | +36.070 | +36.270 | 7 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 93.6 | me-14 | 0.0631963 | 0.0631963 | 0.00309554 | 0.000178786 | 0.000289725
STRINGER | PFC200*75 | +36.070 | +36.270 | 7 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 93.6 | me-13 | 0.0631963 | 0.0631963 | 0.00309554 | 0.000178786 | 0.000289725
STRINGER | PFC200*75 | +31.528 | +31.728 | 6 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.5 | md-15 | 0.0604539 | 0.0604539 | 0.00309554 | 0.000170036 | 0.000277153
STRINGER | PFC200*75 | +31.528 | +31.728 | 6 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.5 | md-14 | 0.0604539 | 0.0604539 | 0.00309554 | 0.000170036 | 0.000277153
STRINGER | PFC200*75 | +26.215 | +26.415 | 6 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 90.2 | md-15 | 0.0608208 | 0.0608208 | 0.00309554 | 0.000171212 | 0.000278835
STRINGER | PFC200*75 | +26.215 | +26.415 | 6 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 90.2 | md-14 | 0.0608208 | 0.0608208 | 0.00309554 | 0.000171212 | 0.000278835
STRINGER | PFC200*75 | +21.260 | +21.460 | 4 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 90.2 | mb-13 | 0.0608789 | 0.0608789 | 0.00309554 | 0.000171398 | 0.000279101
STRINGER | PFC200*75 | +21.260 | +21.460 | 4 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 90.2 | mb-12 | 0.0608789 | 0.0608789 | 0.00309554 | 0.000171398 | 0.000279101
STRINGER | PFC200*75 | +17.850 | +18.050 | 4 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.6 | mb-13 | 0.0605186 | 0.0605186 | 0.00309554 | 0.000170244 | 0.000277449
STRINGER | PFC200*75 | +17.850 | +18.050 | 4 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89.6 | mb-12 | 0.0605186 | 0.0605186 | 0.00309554 | 0.000170244 | 0.000277449
STRINGER | PFC200*75 | +12.945 | +13.145 | 4 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 93 | mb-10 | 0.0628237 | 0.0628237 | 0.00309554 | 0.000177602 | 0.000288017
STRINGER | PFC200*75 | +12.945 | +13.145 | 4 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 93 | mb-11 | 0.0628237 | 0.0628237 | 0.00309554 | 0.000177602 | 0.000288017
STRINGER | PFC200*75 | +7.945 | +8.145 | 3 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89 | ma-17 | 0.0600608 | 0.0600608 | 0.00309554 | 0.000168778 | 0.000275351
STRINGER | PFC200*75 | +7.945 | +8.145 | 3 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89 | ma-18 | 0.0600608 | 0.0600608 | 0.00309554 | 0.000168778 | 0.000275351
STRINGER | PFC200*75 | +10.390 | +10.590 | 4 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 93 | mb-11 | 0.0628237 | 0.0628237 | 0.00309554 | 0.000177602 | 0.000288017
STRINGER | PFC200*75 | +10.390 | +10.590 | 4 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 93 | mb-10 | 0.0628237 | 0.0628237 | 0.00309554 | 0.000177602 | 0.000288017
STRINGER | PFC200*75 | +5.500 | +5.700 | 3 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89 | ma-18 | 0.0600625 | 0.0600625 | 0.00309554 | 0.00016878 | 0.000275359
STRINGER | PFC200*75 | +5.500 | +5.700 | 3 | 3 | 2.2 | 27.8 | 0 | 200 | 75 | 89 | ma-17 | 0.0600625 | 0.0600625 | 0.00309554 | 0.00016878 | 0.000275359
STRINGER | PFC200*75 | +2.500 | +2.700 | 3 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 94.7 | ma-16 | 0.0639132 | 0.0639132 | 0.00309554 | 0.000181058 | 0.000293012
STRINGER | PFC200*75 | +2.500 | +2.700 | 3 | 3 | 2.5 | 27.8 | 0.1 | 200 | 75 | 99.5 | ma-15 | 0.0671838 | 0.0671838 | 0.00309554 | 0.000195778 | 0.000308006
STRINGER | PFC200*75 | +2.500 | +2.700 | 3 | 3 | 2.3 | 27.8 | 0 | 200 | 75 | 94.7 | ma-14 | 0.0639132 | 0.0639132 | 0.00309554 | 0.000181058 | 0.000293012
STRINGER | PFC200*75 | +2.500 | +2.700 | 3 | 3 | 2.5 | 27.8 | 0.1 | 200 | 75 | 99.5 | ma-13 | 0.0671838 | 0.0671838 | 0.00309554 | 0.000195778 | 0.000308006
2 x STRINGER | FL10*80 | +2.760 | +4.606 | 5 | 8 | 11.6 | 28.7 | 0.3 | 80 | 10 | 1846 | pc-205 | 0.3328 | 0.33388 | 0.0008 | 0.00147271 | 0.0014768
4 x STRINGER | FL10*80 | -0.420 | +4.406 | 1 | 8 | 30.2 | 28.7 | 0.8 | 80 | 10 | 4826 | p010005 | 0.8692 | 0.87028 | 0.0008 | 0.00385671 | 0.0038608
2 x STRINGER | FL10*80 | -0.090 | +10.185 | 1 | 8 | 64.5 | 28.7 | 1.9 | 80 | 10 | 10275.4 | p010004 | 1.85009 | 1.85117 | 0.0008 | 0.00821623 | 0.00822032
2 x STRINGER | FL10*80 | +5.510 | +12.806 | 1 | 8 | 45.8 | 28.7 | 1.3 | 80 | 10 | 7296 | p010008 | 1.3138 | 1.31488 | 0.0008 | 0.00583271 | 0.0058368
2 x STRINGER | FL10*80 | -0.290 | +7.123 | 1 | 8 | 46.5 | 28.7 | 1.3 | 80 | 10 | 7413 | p010007 | 1.33486 | 1.33594 | 0.0008 | 0.00592631 | 0.0059304
2 x STRINGER | FL10*80 | +15.710 | +23.013 | 1 | 8 | 45.8 | 28.7 | 1.3 | 80 | 10 | 7303 | p010003 | 1.31506 | 1.31614 | 0.0008 | 0.00583831 | 0.0058424
2 x STRINGER | FL10*80 | +21.470 | +30.723 | 1 | 8 | 58.1 | 28.7 | 1.7 | 80 | 10 | 9253 | p010015 | 1.66606 | 1.66714 | 0.0008 | 0.00739831 | 0.0074024
STRINGER | PFC200*75 | +26.215 | +26.415 | 6 | 3 | 10.9 | 27.8 | 0.3 | 200 | 75 | 451.3 | md-13 | 0.304752 | 0.304752 | 0.00309554 | 0.00126898 | 0.00139715
STRINGER | PFC200*75 | +26.215 | +26.415 | 6 | 3 | 10.9 | 27.8 | 0.3 | 200 | 75 | 451.3 | md-12 | 0.304752 | 0.304752 | 0.00309554 | 0.00126898 | 0.00139715

# IfcDiscreteAccessory: STUB (57)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Class: 23
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 200 mm
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
STUB | IPE200 | +63.106 | +63.247 | 8 | 3.1 | 34.3 | 0.1 | 100 | 140.4 | mf-150 | 0.107855 | 0.0028535 | 0.000382562 | 0.000400632
STUB | IPE200 | +63.106 | +63.150 | 8 | 1 | 34.3 | 0 | 100 | 43.6 | mf-149 | 0.0334935 | 0.0028535 | 0.000118801 | 0.000124413
2 x STUB | IPE200 | +63.108 | +63.250 | 8 | 3.2 | 34.3 | 0.1 | 100 | 141.6 | mf-146 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
STUB | IPE200 | +70.308 | +70.447 | 8 | 3.1 | 34.3 | 0.1 | 100 | 138.4 | mf-148 | 0.106319 | 0.0028535 | 0.000377112 | 0.000394925
3 x STUB | IPE200 | +70.308 | +70.450 | 8 | 3.2 | 34.3 | 0.1 | 100 | 141.6 | mf-146 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
7 x STUB | IPE200 | +65.908 | +66.050 | 8 | 3.2 | 34.3 | 0.1 | 100 | 141.6 | mf-146 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
STUB | IPE200 | +60.498 | +60.535 | 8 | 0.7 | 34.3 | 0 | 100 | 37.4 | mf-147 | 0.0287289 | 0.0028535 | 0.000101901 | 0.000106715
3 x STUB | IPE200 | +54.963 | +55.105 | 8 | 3.2 | 34.3 | 0.1 | 100 | 141.6 | mf-146 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
10 x STUB | IPE200 | +48.358 | +48.500 | 7 | 3.2 | 34.3 | 0.1 | 100 | 141.6 | me-92 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
STUB | PFC200*75 | +44.233 | +44.375 | 7 | 3.4 | 27.8 | 0.1 | 75 | 141.6 | me-28 | 0.0956103 | 0.00309554 | 0.000430322 | 0.000438329
4 x STUB | IPE200 | +44.233 | +44.375 | 7 | 3.2 | 34.3 | 0.1 | 100 | 141.6 | me-92 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
STUB | IPE200 | +44.233 | +44.372 | 7 | 3.1 | 34.3 | 0.1 | 100 | 138.4 | me-93 | 0.106319 | 0.0028535 | 0.000377112 | 0.000394925
STUB | PFC200*75 | +38.696 | +38.838 | 7 | 3.4 | 27.8 | 0.1 | 75 | 141.6 | me-28 | 0.0956103 | 0.00309554 | 0.000430322 | 0.000438329
3 x STUB | IPE200 | +35.928 | +36.070 | 6 | 3.2 | 34.3 | 0.1 | 100 | 141.6 | md-68 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
STUB | IPE200 | +35.928 | +36.067 | 6 | 3.1 | 34.3 | 0.1 | 100 | 138.4 | md-69 | 0.106319 | 0.0028535 | 0.000377112 | 0.000394925
7 x STUB | IPE200 | +28.738 | +28.880 | 6 | 3.2 | 34.3 | 0.1 | 100 | 141.6 | md-68 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
4 x STUB | IPE200 | +5.358 | +5.500 | 5 | 3.2 | 34.3 | 0.1 | 100 | 141.6 | mc-184 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
4 x STUB | IPE200 | +15.358 | +15.500 | 5 | 3.2 | 34.3 | 0.1 | 100 | 141.6 | mc-184 | 0.108777 | 0.0028535 | 0.000385832 | 0.000404056
STUB | IPE200 | +15.358 | +15.497 | 5 | 3.1 | 34.3 | 0.1 | 100 | 138.4 | mc-185 | 0.106319 | 0.0028535 | 0.000377112 | 0.000394925
STUB | PFC200*75 | +21.118 | +21.260 | 4 | 3.4 | 27.8 | 0.1 | 75 | 141.6 | mb-29 | 0.0956103 | 0.00309554 | 0.000430322 | 0.000438329

# IfcDiscreteAccessory: TOE PLATE (86)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x TOE PLATE | PLT12*94 | +5.506 | +5.694 | 5 | 8 | 1.7 | 25.3 | 0 | 94 | 12 | 188 | pc-105 | 0.042112 | 0.042112 | 0.001128 | 0.000212064
TOE PLATE | PLT16*220 | +21.110 | +21.454 | 4 | 8 | 9.5 | 17.8 | 0.2 | 220 | 16 | 343.6 | pb-184 | 0.169219 | 0.169219 | 0.00352 | 0.00120947
TOE PLATE | PLT16*220 | +21.110 | +21.454 | 5 | 8 | 9.5 | 17.8 | 0.2 | 220 | 16 | 343.6 | pc-408 | 0.169219 | 0.169219 | 0.00352 | 0.00120947
16 x TOE PLATE | FL12*30 | +12.144 | +12.156 | 5 | 1 | 0.7 | 30.8 | 0 | 30 | 12 | 230 | pc-75 | 0.02004 | 0.0069 | 0.000144 | 0.0000828
16 x TOE PLATE | FL12*30 | +12.488 | +12.500 | 5 | 1 | 0.7 | 30.8 | 0 | 30 | 12 | 230 | pc-75 | 0.02004 | 0.0069 | 0.000144 | 0.0000828
12 x TOE PLATE | PLT12*79.3 | +12.144 | +12.156 | 5 | 1 | 2.5 | 25.3 | 0.1 | 79.3 | 12 | 330 | pc-76 | 0.062127 | 0.0261525 | 0.000144 | 0.00031383
12 x TOE PLATE | PLT12*79.3 | +12.488 | +12.500 | 5 | 1 | 2.5 | 25.3 | 0.1 | 79.3 | 12 | 330 | pc-76 | 0.062127 | 0.0261525 | 0.000144 | 0.00031383
12 x TOE PLATE | PLT12*89.3 | +12.144 | +12.156 | 5 | 1 | 2.9 | 24.8 | 0.1 | 89.3 | 12 | 350 | pc-74 | 0.073017 | 0.0312375 | 0.000144 | 0.00037485
12 x TOE PLATE | PLT12*89.3 | +12.488 | +12.500 | 5 | 1 | 2.9 | 24.8 | 0.1 | 89.3 | 12 | 350 | pc-74 | 0.073017 | 0.0312375 | 0.000144 | 0.00037485

# IfcDiscreteAccessory: WASHER PLATE (96)
In: Undefined
Description: FL10*80; Material: STEEL/S355JR
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 31.8 m2; Net surface area: 0 m2; Height: 80 mm; Width: 10 mm; Length: 80 mm
BaseQuantities - NetArea: 0.016 m2; GrossArea: 0.0064 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.000064 m3; GrossVolume: 0.000064 m3
Tekla Common - Class: 1
Pset_PlateCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Reference
48 x WASHER PLATE | +0.025 | +0.035 | 5 | pc-123
48 x WASHER PLATE | +0.040 | +0.050 | 3 | pa-64

# IfcElementAssembly (4115)
In: Undefined
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Steel Assembly | RIGID_FRAME | 221.7 | +60.483 | +60.735 | D/2-3 | 471-G-F320 | 146.1
Steel Assembly | RIGID_FRAME | 221.7 | +60.483 | +60.735 | E/2-3 | 471-G-F315 | 146.1
Steel Assembly | RIGID_FRAME | 221.7 | +68.198 | +68.450 | D/2-3 | 471-G-F318 | 146.1
Steel Assembly | RIGID_FRAME | 221.7 | +68.198 | +68.450 | E/2-3 | 471-G-F319 | 146.1
4 x Steel Assembly | RIGID_FRAME | 47.5 | +66.050 | +66.250 | C-D/2-3 | 471-G-F348 | 135.765
Steel Assembly | RIGID_FRAME | 88.4 | +66.050 | +66.250 | C-D/2-3 | 471-G-F151 | 292.047
Steel Assembly | RIGID_FRAME | 134.1 | +66.050 | +66.250 | C-D/2-3 | 471-G-F139 | 265.894
Steel Assembly | RIGID_FRAME | 131.3 | +66.050 | +66.250 | C-D/2-3 | 471-G-F140 | 253.403
Steel Assembly | RIGID_FRAME | 175.2 | +66.050 | +66.250 | C-D/2-3 | 471-G-F136 | 450.745
4 x Steel Assembly | RIGID_FRAME | 47.5 | +55.105 | +55.305 | C-D/2-3 | 471-G-F348 | 135.765
Steel Assembly | RIGID_FRAME | 88.4 | +55.105 | +55.305 | C-D/2-3 | 471-G-F151 | 292.047
Steel Assembly | RIGID_FRAME | 129.1 | +55.105 | +55.305 | C-D/2-3 | 471-G-F138 | 160
Steel Assembly | RIGID_FRAME | 133.8 | +55.105 | +55.305 | C-D/2-3 | 471-G-F128 | 336.58
Steel Assembly | RIGID_FRAME | 173.2 | +55.105 | +55.305 | C-D/2-3 | 471-G-F135 | 447.925
4 x Steel Assembly | RIGID_FRAME | 47.5 | +70.450 | +70.650 | C-D/2-3 | 471-G-F348 | 135.765
Steel Assembly | RIGID_FRAME | 88.4 | +70.450 | +70.650 | C-D/2-3 | 471-G-F151 | 292.047
Steel Assembly | RIGID_FRAME | 134.1 | +70.450 | +70.650 | C-D/2-3 | 471-G-F139 | 265.894
Steel Assembly | RIGID_FRAME | 131.3 | +70.450 | +70.650 | C-D/2-3 | 471-G-F140 | 253.403
Steel Assembly | RIGID_FRAME | 175.2 | +70.450 | +70.650 | C-D/2-3 | 471-G-F136 | 450.745
4 x Steel Assembly | RIGID_FRAME | 51.2 | +63.250 | +63.450 | C-D/2-3 | 471-G-F39 | 86.696
Steel Assembly | RIGID_FRAME | 13.6 | +63.260 | +63.340 | C-D/2-3 | 471-G-F262 | 80
Steel Assembly | RIGID_FRAME | 50.8 | +63.150 | +63.450 | C-D/2-3 | 471-G-F330 | 448.155
Steel Assembly | RIGID_FRAME | 48.1 | +63.150 | +63.450 | C-D/2-3 | 471-G-F333 | 437.917
Steel Assembly | RIGID_FRAME | 7.8 | +63.260 | +63.340 | C-D/2-3 | 471-G-F284 | 80
Steel Assembly | RIGID_FRAME | 48.2 | +63.150 | +63.450 | C-D/2-3 | 471-G-F334 | 438.168
Steel Assembly | RIGID_FRAME | 13 | +63.260 | +63.340 | C-D/2-3 | 471-G-F263 | 80
Steel Assembly | RIGID_FRAME | 260.2 | +63.150 | +63.450 | C-D/2-3 | 471-G-F326 | 325.227
2 x Steel Assembly | RIGID_FRAME | 13.6 | +63.260 | +63.340 | C-D/2-3 | 471-G-F273 | 80
Steel Assembly | RIGID_FRAME | 86.6 | +63.150 | +63.450 | C-D/2-3 | 471-G-F339 | 254.79
Steel Assembly | RIGID_FRAME | 88.8 | +63.150 | +63.450 | C-D/2-3 | 471-G-F323 | 344.785
2 x Steel Assembly | RIGID_FRAME | 18.9 | +63.260 | +63.340 | C-D/2-3 | 471-G-F261 | 80
Steel Assembly | RIGID_FRAME | 91.8 | +63.150 | +63.450 | C-D/2-3 | 471-G-F337 | 347.794
2 x Steel Assembly | RIGID_FRAME | 13 | +63.260 | +63.340 | C-D/2-3 | 471-G-F260 | 80
Steel Assembly | RIGID_FRAME | 41.9 | +63.250 | +63.450 | C-D/2-3 | 471-G-F211 | 327.541
Steel Assembly | RIGID_FRAME | 7.7 | +63.260 | +63.340 | C-D/2-3 | 471-G-F283 | 80
Steel Assembly | RIGID_FRAME | 24.7 | +63.250 | +63.450 | C-D/2-3 | 471-G-F204 | 384.944
Steel Assembly | RIGID_FRAME | 88.4 | +63.150 | +63.450 | C-D/2-3 | 471-G-F340 | 437.085
Steel Assembly | RIGID_FRAME | 88.2 | +63.150 | +63.450 | C-D/2-3 | 471-G-F341 | 419.125
Steel Assembly | RIGID_FRAME | 41.9 | +63.250 | +63.450 | C-D/2-3 | 471-G-F210 | 328.159
Steel Assembly | RIGID_FRAME | 273.3 | +63.150 | +63.450 | C-D/2-3 | 471-G-F329 | 306.612
Steel Assembly | RIGID_FRAME | 88.8 | +63.150 | +63.450 | C-D/2-3 | 471-G-F325 | 344.402
Steel Assembly | RIGID_FRAME | 88.8 | +63.150 | +63.450 | C-D/2-3 | 471-G-F324 | 342.009
Steel Assembly | RIGID_FRAME | 271.1 | +63.150 | +63.450 | C-D/2-3 | 471-G-F328 | 216
Steel Assembly | RIGID_FRAME | 197.1 | +63.150 | +63.450 | C-D/2-3 | 471-G-F332 | 305.035
Steel Assembly | RIGID_FRAME | 356.2 | +63.150 | +63.450 | C-D/2-3 | 471-G-F327 | 458.851
2 x Steel Assembly | RIGID_FRAME | 14.5 | +63.260 | +63.340 | C-D/2-3 | 471-G-F272 | 80
Steel Assembly | RIGID_FRAME | 54.9 | +63.150 | +63.450 | C-D/2-3 | 471-G-F335 | 458.852
Steel Assembly | RIGID_FRAME | 54.9 | +63.150 | +63.450 | C-D/2-3 | 471-G-F336 | 405.917
Steel Assembly | RIGID_FRAME | 9.1 | +63.260 | +63.340 | C-D/2-3 | 471-G-F285 | 80
Steel Assembly | RIGID_FRAME | 54.9 | +63.150 | +63.450 | C-D/2-3 | 471-G-F338 | 405.917
Steel Assembly | RIGID_FRAME | 14.2 | +63.260 | +63.340 | C-D/2-3 | 471-G-F259 | 80
Steel Assembly | RIGID_FRAME | 9.2 | +63.260 | +63.340 | C-D/2-3 | 471-G-F282 | 80
Steel Assembly | RIGID_FRAME | 14.2 | +63.260 | +63.340 | C-D/2-3 | 471-G-F258 | 80
Steel Assembly | RIGID_FRAME | 97.4 | +63.094 | +63.450 | C-D/2-3 | 471-G-F213 | 448.66
Steel Assembly | RIGID_FRAME | 15.6 | +63.260 | +63.340 | C-D/2-3 | 471-G-F274 | 80
Steel Assembly | RIGID_FRAME | 47.2 | +63.250 | +63.450 | C-D/2-3 | 471-G-F133 | 319.787
3 x Steel Assembly | RIGID_FRAME | 16.2 | +63.260 | +63.340 | C-D/2-3 | 471-G-F264 | 80
Steel Assembly | RIGID_FRAME | 19.5 | +63.260 | +63.340 | C-D/2-3 | 471-G-F257 | 80
Steel Assembly | RIGID_FRAME | 15.8 | +63.260 | +63.340 | C-D/2-3 | 471-G-F265 | 80
Steel Assembly | RIGID_FRAME | 16 | +63.260 | +63.340 | C-D/2-3 | 471-G-F266 | 80
Steel Assembly | RIGID_FRAME | 15.6 | +63.260 | +63.340 | C-D/2-3 | 471-G-F267 | 80
Steel Assembly | RIGID_FRAME | 79.1 | +63.094 | +63.450 | C-D/2-3 | 471-G-F214 | 283.739
Steel Assembly | RIGID_FRAME | 91.6 | +63.150 | +63.450 | C-D/2-3 | 471-G-F331 | 369.267
2 x Steel Assembly | RIGID_FRAME | 15 | +63.260 | +63.340 | C-D/2-3 | 471-G-F271 | 80
Steel Assembly | RIGID_FRAME | 47.1 | +63.250 | +63.450 | C-D/2-3 | 471-G-F132 | 323.238
Steel Assembly | RIGID_FRAME | 54.9 | +63.096 | +63.450 | C-D/2-3 | 471-G-F134 | 323.238
2 x Steel Assembly | RIGID_FRAME | 18.6 | +63.260 | +63.340 | C-D/3-4 | 471-G-F268 | 80
Steel Assembly | RIGID_FRAME | 54.5 | +63.250 | +63.450 | C-D/3-4 | 471-G-F179 | 339.404
Steel Assembly | RIGID_FRAME | 171.9 | +63.250 | +63.450 | C-D/3-4 | 471-G-F185 | 370.41
2 x Steel Assembly | RIGID_FRAME | 16.8 | +63.260 | +63.340 | C-D/3-4 | 471-G-F269 | 80
Steel Assembly | RIGID_FRAME | 56 | +63.250 | +63.450 | C-D/3-4 | 471-G-F145 | 406.813
Steel Assembly | RIGID_FRAME | 56.3 | +63.250 | +63.450 | C-D/3-4 | 471-G-F182 | 339.404
Steel Assembly | RIGID_FRAME | 56.5 | +63.250 | +63.450 | C-D/3-4 | 471-G-F146 | 414.599
4 x Steel Assembly | RIGID_FRAME | 14.5 | +63.260 | +63.340 | C-D/3-4 | 471-G-F270 | 80
2 x Steel Assembly | RIGID_FRAME | 41.7 | +63.250 | +63.450 | C-D/3-4 | 471-G-F203 | 406.966
Steel Assembly | RIGID_FRAME | 56 | +63.250 | +63.450 | C-D/3-4 | 471-G-F148 | 399.128
Steel Assembly | RIGID_FRAME | 16.3 | +63.260 | +63.340 | C-D/3-4 | 471-G-F248 | 80
Steel Assembly | RIGID_FRAME | 56.5 | +63.250 | +63.450 | C-D/3-4 | 471-G-F147 | 406.915
Steel Assembly | RIGID_FRAME | 27.1 | +63.098 | +63.250 | B-C/2-3 | 471-G-F224 | 152.4
Steel Assembly | RIGID_FRAME | 85.1 | +63.250 | +63.450 | B-C/2-3 | 471-G-F23 | 159.994
3 x Steel Assembly | RIGID_FRAME | 27.2 | +62.942 | +63.094 | C-D/2-3 | 471-G-F220 | 152.4
Steel Assembly | RIGID_FRAME | 9.4 | +63.263 | +63.343 | B-C/2-3 | 471-G-F233 | 80
Steel Assembly | RIGID_FRAME | 39.2 | +63.250 | +63.450 | B-C/2-3 | 471-G-F26 | 380.942
Steel Assembly | RIGID_FRAME | 38 | +63.150 | +63.450 | B-C/2-3 | 471-G-F123 | 261.565
2 x Steel Assembly | RIGID_FRAME | 27.1 | +63.098 | +63.250 | C-D/3-4 | 471-G-F219 | 152.4
Steel Assembly | RIGID_FRAME | 63.7 | +70.296 | +70.650 | C-D/2-3 | 471-G-F212 | 281.579
Steel Assembly | RIGID_FRAME | 30.8 | +70.142 | +70.294 | C-D/2-3 | 471-G-F223 | 152.4
Steel Assembly | RIGID_FRAME | 11.4 | +70.468 | +70.620 | B-C/2 | 471-G-F218 | 160
2 x Steel Assembly | RIGID_FRAME | 27.1 | +70.298 | +70.450 | C-D/3-4 | 471-G-F219 | 152.4
Steel Assembly | RIGID_FRAME | 12.4 | +70.463 | +70.543 | C-D/2-3 | 471-G-F280 | 80
Steel Assembly | RIGID_FRAME | 46.4 | +70.450 | +70.650 | C-D/2-3 | 471-G-F150 | 354.324
3 x Steel Assembly | RIGID_FRAME | 27.2 | +70.142 | +70.294 | C-D/2-3 | 471-G-F220 | 152.4
Steel Assembly | RIGID_FRAME | 34.4 | +70.296 | +70.650 | C-D/2-3 | 471-G-F166 | 450.745
Steel Assembly | RIGID_FRAME | 53.3 | +70.296 | +70.650 | C-D/2-3 | 471-G-F154 | 327.809
Steel Assembly | RIGID_FRAME | 34.5 | +70.296 | +70.650 | C-D/2-3 | 471-G-F168 | 450.448
Steel Assembly | RIGID_FRAME | 36.2 | +70.142 | +70.294 | D-E/2-3 | 471-G-F216 | 152.4
Steel Assembly | RIGID_FRAME | 81.6 | +70.296 | +70.650 | D-E/2-3 | 471-G-F3 | 266.806
2 x Steel Assembly | RIGID_FRAME | 27.2 | +65.742 | +65.894 | B-C/2-3 | 471-G-F220 | 152.4
5 x Steel Assembly | RIGID_FRAME | 27.2 | +65.742 | +65.894 | C-D/2-3 | 471-G-F220 | 152.4
Steel Assembly | RIGID_FRAME | 34.4 | +65.896 | +66.250 | C-D/2-3 | 471-G-F165 | 455.304
Steel Assembly | RIGID_FRAME | 53.2 | +65.896 | +66.250 | B-C/2-3 | 471-G-F156 | 334.804
Steel Assembly | RIGID_FRAME | 53 | +65.896 | +66.250 | C-D/2-3 | 471-G-F152 | 346.838
Steel Assembly | RIGID_FRAME | 136 | +65.896 | +66.250 | C-D/2-3 | 471-G-F137 | 349.211
Steel Assembly | RIGID_FRAME | 59.3 | +65.896 | +66.250 | B-C/2-3 | 471-G-F121 | 445.594
Steel Assembly | RIGID_FRAME | 53.3 | +65.896 | +66.250 | C-D/2-3 | 471-G-F155 | 327.809
Steel Assembly | RIGID_FRAME | 53.3 | +65.896 | +66.250 | C-D/2-3 | 471-G-F154 | 327.809
Steel Assembly | RIGID_FRAME | 36.2 | +65.742 | +65.894 | D-E/2-3 | 471-G-F216 | 152.4
Steel Assembly | RIGID_FRAME | 75.9 | +65.896 | +66.250 | D-E/2-3 | 471-G-F30 | 170
Steel Assembly | RIGID_FRAME | 38.1 | +62.942 | +63.094 | D-E/2-3 | 471-G-F222 | 152.4
Steel Assembly | RIGID_FRAME | 75.9 | +63.096 | +63.450 | D-E/2-3 | 471-G-F131 | 291.919
Steel Assembly | RIGID_FRAME | 58.8 | +68.250 | +68.450 | D-E/2-3 | 471-G-F29 | 230.66
Steel Assembly | RIGID_FRAME | 57.5 | +68.250 | +68.450 | D-E/2-3 | 471-G-F186 | 280.962
Steel Assembly | RIGID_FRAME | 30.2 | +68.098 | +68.250 | D-E/2-3 | 471-G-F215 | 152.4
Steel Assembly | RIGID_FRAME | 69.7 | +57.820 | +58.020 | D-E/2-3 | 471-G-F36 | 160
Steel Assembly | RIGID_FRAME | 67.4 | +57.820 | +58.020 | D-E/2-3 | 471-G-F189 | 215.002
Steel Assembly | RIGID_FRAME | 30.2 | +57.668 | +57.820 | D-E/2-3 | 471-G-F215 | 152.4
Steel Assembly | RIGID_FRAME | 18.6 | +60.331 | +60.484 | D-E/3 | 471-G-F221 | 152.4
Steel Assembly | RIGID_FRAME | 61.6 | +60.486 | +60.735 | D-E/3 | 471-G-F130 | 280.927
Steel Assembly | RIGID_FRAME | 37.7 | +55.105 | +55.305 | B-C/2-3 | 471-G-F25 | 256.549
Steel Assembly | RIGID_FRAME | 26 | +54.953 | +55.105 | B-C/2-3 | 471-G-F217 | 152.4
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | D/2-3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 407.4 | +65.894 | +66.600 | D/2-3 | 471-G-F49 | 315
4 x Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | D/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | D/2 | 471-G-F310 | 70
3 x Steel Assembly | RIGID_FRAME | 27.2 | +54.797 | +54.949 | C-D/2-3 | 471-G-F220 | 152.4
Steel Assembly | RIGID_FRAME | 32.5 | +54.951 | +55.305 | C-D/2-3 | 471-G-F167 | 302.796
Steel Assembly | RIGID_FRAME | 375.2 | +65.894 | +66.250 | B-C/2-3 | 471-G-F41 | 255.75
4 x Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | B-C/2-3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 113.3 | +65.894 | +66.250 | B-C/2 | 471-G-F44 | 413.655
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | B-C/2 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | C/2 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | B-C/2 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | B-C/3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 166.6 | +65.554 | +66.560 | B-C/3 | 471-G-F43 | 355.008
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | B-C/3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | C/3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 183.5 | +65.545 | +66.603 | D-E/3 | 471-G-F75 | 376.835
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | D-E/3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | D/3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 131.7 | +65.894 | +66.594 | C-D/3 | 471-G-F69 | 315.008
Steel Assembly | RIGID_FRAME | 177.6 | +65.894 | +66.250 | C-D/3 | 471-G-F68 | 310.008
Steel Assembly | RIGID_FRAME | 131.7 | +65.894 | +66.594 | C-D/3 | 471-G-F66 | 315.008
3 x Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | C-D/3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | C/3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | D/3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 446 | +65.541 | +66.594 | C-D/2 | 471-G-F42 | 315.008
3 x Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | C-D/2 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 53 | +54.951 | +55.305 | C-D/2-3 | 471-G-F153 | 346.75
Steel Assembly | RIGID_FRAME | 53.3 | +54.951 | +55.305 | C-D/2-3 | 471-G-F154 | 327.809
2 x Steel Assembly | RIGID_FRAME | 27.1 | +54.953 | +55.105 | C-D/3-4 | 471-G-F219 | 152.4
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | C/2 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +66.075 | +67.355 | D/2 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 36.2 | +54.797 | +54.949 | D-E/2-3 | 471-G-F216 | 152.4
Steel Assembly | RIGID_FRAME | 45.7 | +69.151 | +70.294 | D/1-2 | 471-G-F193 | 180
Steel Assembly | RIGID_FRAME | 227.3 | +70.294 | +70.650 | C-D/2 | 471-G-F106 | 183.5
Steel Assembly | RIGID_FRAME | 20.1 | +70.450 | +70.650 | C-D/1-2 | 471-G-F349 | 75
Steel Assembly | RIGID_FRAME | 75 | +70.294 | +70.650 | C-D/1-2 | 471-G-F104 | 171.5
Steel Assembly | RIGID_FRAME | 45.7 | +69.151 | +70.294 | C/1-2 | 471-G-F193 | 180
Steel Assembly | RIGID_FRAME | 405.8 | +70.294 | +70.650 | C-D/1-2 | 471-G-F103 | 183.5
Steel Assembly | RIGID_FRAME | 83.3 | +70.294 | +70.650 | D/1-2 | 471-G-F102 | 190
Steel Assembly | RIGID_FRAME | 83.3 | +70.294 | +70.650 | C/1-2 | 471-G-F100 | 190
Steel Assembly | RIGID_FRAME | 437.9 | +62.741 | +63.796 | C/2-3 | 471-G-F48 | 314.99
Steel Assembly | RIGID_FRAME | 427.9 | +62.741 | +63.791 | D/2-3 | 471-G-F47 | 315.058
Steel Assembly | RIGID_FRAME | 45.7 | +61.951 | +63.094 | D/1-2 | 471-G-F193 | 180
Steel Assembly | RIGID_FRAME | 22.6 | +63.250 | +63.450 | C-D/1-2 | 471-G-F350 | 87
2 x Steel Assembly | RIGID_FRAME | 23.7 | +63.250 | +63.450 | C-D/1-2 | 471-G-F351 | 75
Steel Assembly | RIGID_FRAME | 227.3 | +63.094 | +63.450 | C-D/2 | 471-G-F106 | 183.5
Steel Assembly | RIGID_FRAME | 80.2 | +63.094 | +63.450 | C-D/1-2 | 471-G-F105 | 183.5
Steel Assembly | RIGID_FRAME | 45.7 | +61.951 | +63.094 | C/1-2 | 471-G-F193 | 180
Steel Assembly | RIGID_FRAME | 405.8 | +63.094 | +63.450 | C-D/1-2 | 471-G-F103 | 183.5
Steel Assembly | RIGID_FRAME | 83.3 | +63.094 | +63.450 | D/1-2 | 471-G-F102 | 190
Steel Assembly | RIGID_FRAME | 83.3 | +63.094 | +63.450 | C/1-2 | 471-G-F100 | 190
Steel Assembly | RIGID_FRAME | 79.1 | +54.951 | +55.305 | D-E/2-3 | 471-G-F12 | 238.778
Steel Assembly | RIGID_FRAME | 17.5 | +55.118 | +55.198 | C-D/3-4 | 471-G-F252 | 80
Steel Assembly | RIGID_FRAME | 65.7 | +54.949 | +55.305 | C-D/3 | 471-G-F61 | 356.99
Steel Assembly | RIGID_FRAME | 53.9 | +55.105 | +55.305 | C-D/3-4 | 471-G-F181 | 306.702
Steel Assembly | RIGID_FRAME | 69.7 | +52.840 | +53.040 | D-E/2-3 | 471-G-F36 | 160
Steel Assembly | RIGID_FRAME | 67.4 | +52.840 | +53.040 | D-E/2-3 | 471-G-F188 | 216.041
Steel Assembly | RIGID_FRAME | 30.2 | +52.688 | +52.840 | D-E/2-3 | 471-G-F215 | 152.4
Steel Assembly | RIGID_FRAME | 439.7 | +54.621 | +55.645 | D/2-3 | 471-G-F55 | 315.058
Steel Assembly | RIGID_FRAME | 45.7 | +53.806 | +54.949 | D/1-2 | 471-G-F193 | 180
Steel Assembly | RIGID_FRAME | 83.3 | +54.949 | +55.305 | D/1-2 | 471-G-F101 | 190
Steel Assembly | RIGID_FRAME | 405.8 | +54.949 | +55.305 | C-D/1-2 | 471-G-F103 | 183.5
Steel Assembly | RIGID_FRAME | 227.3 | +54.949 | +55.305 | C-D/2 | 471-G-F106 | 183.5
Steel Assembly | RIGID_FRAME | 22.6 | +55.105 | +55.305 | C-D/1-2 | 471-G-F350 | 87
2 x Steel Assembly | RIGID_FRAME | 23.7 | +55.105 | +55.305 | C-D/1-2 | 471-G-F351 | 75
Steel Assembly | RIGID_FRAME | 80.2 | +54.949 | +55.305 | C-D/1-2 | 471-G-F105 | 183.5
Steel Assembly | RIGID_FRAME | 45.7 | +53.806 | +54.949 | C/1-2 | 471-G-F193 | 180
Steel Assembly | RIGID_FRAME | 83.3 | +54.949 | +55.305 | C/1-2 | 471-G-F99 | 190
Steel Assembly | RIGID_FRAME | 1160.6 | +59.205 | +70.650 | C/3 | 471-G-F109 | 304.8
Steel Assembly | RIGID_FRAME | 429.3 | +47.995 | +49.050 | D/2-3 | 471-F-E36 | 315.058
Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | D/2 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 40.4 | +35.762 | +35.914 | D-E/2-3 | 471-E-D106 | 152.4
Steel Assembly | RIGID_FRAME | 430.1 | +35.563 | +36.611 | D/2-3 | 471-E-D16 | 315.058
Steel Assembly | RIGID_FRAME | 451.8 | +54.621 | +55.649 | C/2-3 | 471-G-F51 | 315.386
2 x Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | C/2-3 | 471-G-F310 | 70
4 x Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | D/2-3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 449.5 | +54.599 | +55.658 | C-D/2 | 471-G-F52 | 315.008
3 x Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | C-D/2 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | C/2 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | D/2 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | D/2 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +55.130 | +56.410 | C/2-3 | 471-G-F308 | 70
3 x Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | D/2-3 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 184.7 | +62.744 | +63.799 | D-E/2 | 471-G-F62 | 368.037
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | D-E/2 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | D/2 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | E/2 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 425 | +62.741 | +63.787 | E/2-3 | 471-G-F71 | 265.058
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | E/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | E/2 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 429.7 | +62.762 | +63.803 | C-D/2 | 471-G-F46 | 315.008
3 x Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | C-D/2 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | C/2 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | D/2 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | B-C/2-3 | 471-G-F309 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | C/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 9.2 | +63.263 | +63.343 | B-C/2-3 | 471-G-F281 | 80
Steel Assembly | RIGID_FRAME | 35.1 | +63.250 | +63.450 | B-C/2-3 | 471-G-F38 | 236.09
Steel Assembly | RIGID_FRAME | 35.8 | +63.250 | +63.450 | B-C/2-3 | 471-G-F205 | 337.632
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | B-C/2-3 | 471-G-F310 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | C/2-3 | 471-G-F307 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +63.275 | +64.555 | C/2 | 471-G-F309 | 70
Steel Assembly | RIGID_FRAME | 9.2 | +38.851 | +38.931 | B-C/2-3 | 471-F-E172 | 80
Steel Assembly | RIGID_FRAME | 35.1 | +38.838 | +39.038 | B-C/2-3 | 471-F-E80 | 337.632
Steel Assembly | RIGID_FRAME | 35.1 | +38.838 | +39.038 | B-C/2-3 | 471-F-E11 | 236.09
Steel Assembly | RIGID_FRAME | 409.1 | +38.682 | +39.391 | C/2-3 | 471-F-E23 | 340.133
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.143 | C/2-3 | 471-F-E202 | 70
Steel Assembly | RIGID_FRAME | 93.6 | +38.838 | +39.038 | B-C/2-3 | 471-F-E9 | 159.994
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.143 | B-C/2-3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 39.1 | +38.838 | +39.038 | B-C/2-3 | 471-F-E13 | 400.943
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.143 | B-C/2-3 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.143 | C/2-3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +38.863 | +40.143 | C/2-3 | 471-F-E204 | 70
2 x Steel Assembly | RIGID_FRAME | 27.7 | +48.513 | +48.593 | C-D/1-2 | 471-F-E168 | 80
Steel Assembly | RIGID_FRAME | 370.8 | +48.344 | +48.700 | C-D/1-2 | 471-F-E34 | 297.904
2 x Steel Assembly | RIGID_FRAME | 26.9 | +48.513 | +48.593 | C-D/1-2 | 471-F-E169 | 80
Steel Assembly | RIGID_FRAME | 64.7 | +48.500 | +48.700 | C-D/1-2 | 471-F-E77 | 347.618
Steel Assembly | RIGID_FRAME | 64.7 | +48.500 | +48.700 | C-D/1-2 | 471-F-E75 | 349.079
Steel Assembly | RIGID_FRAME | 64.7 | +48.500 | +48.700 | C-D/1-2 | 471-F-E76 | 349.079
Steel Assembly | RIGID_FRAME | 276 | +48.344 | +48.700 | C-D/3 | 471-F-E37 | 310.058
4 x Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | C-D/3 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 108.8 | +48.017 | +49.044 | C-D/3 | 471-F-E39 | 315.058
Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | D/3 | 471-F-E204 | 70
Steel Assembly | RIGID_FRAME | 110.8 | +48.017 | +49.044 | C-D/3 | 471-F-E40 | 462.93
Steel Assembly | RIGID_FRAME | 8.2 | +48.525 | +49.805 | C/3 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 176.7 | +48.346 | +48.700 | B-C/2-3 | 471-F-E65 | 362.428
4 x Steel Assembly | RIGID_FRAME | 27.2 | +48.192 | +48.344 | B-C/2-3 | 471-F-E144 | 152.4
Steel Assembly | RIGID_FRAME | 31.3 | +48.346 | +48.700 | B-C/2-3 | 471-F-E135 | 410.342
Steel Assembly | RIGID_FRAME | 31.5 | +48.346 | +48.700 | B-C/2-3 | 471-F-E134 | 464.976
6 x Steel Assembly | RIGID_FRAME | 27.2 | +48.192 | +48.344 | C-D/2-3 | 471-F-E144 | 152.4
Steel Assembly | RIGID_FRAME | 34.4 | +48.346 | +48.700 | C-D/2-3 | 471-F-E111 | 455.304
Steel Assembly | RIGID_FRAME | 9.4 | +48.513 | +48.593 | B-C/2-3 | 471-F-E177 | 80
Steel Assembly | RIGID_FRAME | 28.3 | +48.500 | +48.700 | B-C/2-3 | 471-F-E120 | 393.011
Steel Assembly | RIGID_FRAME | 9.7 | +48.513 | +48.593 | B-C/2-3 | 471-F-E178 | 80
Steel Assembly | RIGID_FRAME | 24.7 | +48.500 | +48.700 | B-C/2-3 | 471-F-E138 | 376.789
Steel Assembly | RIGID_FRAME | 9.1 | +48.513 | +48.593 | B-C/2-3 | 471-F-E179 | 80
Steel Assembly | RIGID_FRAME | 11.9 | +48.513 | +48.593 | B-C/2-3 | 471-F-E180 | 80
2 x Steel Assembly | RIGID_FRAME | 23.7 | +48.500 | +48.700 | B-C/2-3 | 471-F-E106 | 302.204
Steel Assembly | RIGID_FRAME | 15 | +48.513 | +48.593 | B-C/2-3 | 471-F-E181 | 80
Steel Assembly | RIGID_FRAME | 33.4 | +48.500 | +48.700 | B-C/2-3 | 471-F-E108 | 265.112
Steel Assembly | RIGID_FRAME | 35.8 | +48.500 | +48.700 | B-C/2-3 | 471-F-E107 | 354.327
Steel Assembly | RIGID_FRAME | 14.8 | +48.513 | +48.593 | B-C/2-3 | 471-F-E185 | 80
Steel Assembly | RIGID_FRAME | 35.8 | +48.500 | +48.700 | B-C/2-3 | 471-F-E100 | 265.175
Steel Assembly | RIGID_FRAME | 33.4 | +48.500 | +48.700 | B-C/2-3 | 471-F-E99 | 265.175
Steel Assembly | RIGID_FRAME | 14.2 | +48.513 | +48.593 | B-C/2-3 | 471-F-E183 | 80
2 x Steel Assembly | RIGID_FRAME | 31.1 | +48.500 | +48.700 | B-C/2-3 | 471-F-E109 | 267.192
Steel Assembly | RIGID_FRAME | 11.9 | +48.513 | +48.593 | B-C/2-3 | 471-F-E182 | 80
Steel Assembly | RIGID_FRAME | 63.3 | +48.500 | +48.700 | B-C/2-3 | 471-F-E91 | 302.516
Steel Assembly | RIGID_FRAME | 12.2 | +48.513 | +48.593 | B-C/2-3 | 471-F-E170 | 80
Steel Assembly | RIGID_FRAME | 25.2 | +48.500 | +48.700 | B-C/2-3 | 471-F-E136 | 444.93
Steel Assembly | RIGID_FRAME | 11.4 | +48.513 | +48.593 | B-C/2-3 | 471-F-E184 | 80
Steel Assembly | RIGID_FRAME | 25.2 | +48.500 | +48.700 | B-C/2-3 | 471-F-E137 | 444.922
Steel Assembly | RIGID_FRAME | 12.2 | +48.513 | +48.593 | B-C/2-3 | 471-F-E186 | 80
3 x Steel Assembly | RIGID_FRAME | 61.2 | +48.500 | +48.700 | B-C/2-3 | 471-F-E90 | 160
Steel Assembly | RIGID_FRAME | 15.3 | +48.513 | +48.593 | B-C/2-3 | 471-F-E187 | 80
Steel Assembly | RIGID_FRAME | 14.8 | +48.513 | +48.593 | B-C/2-3 | 471-F-E188 | 80
Steel Assembly | RIGID_FRAME | 44.6 | +48.500 | +48.700 | B-C/2-3 | 471-F-E129 | 237.85
Steel Assembly | RIGID_FRAME | 61.2 | +48.500 | +48.700 | B-C/2-3 | 471-F-E66 | 160
Steel Assembly | RIGID_FRAME | 12.6 | +48.513 | +48.593 | B-C/2-3 | 471-F-E176 | 80
Steel Assembly | RIGID_FRAME | 26.2 | +48.500 | +48.700 | B-C/2-3 | 471-F-E119 | 291.125
Steel Assembly | RIGID_FRAME | 16.2 | +48.513 | +48.593 | C-D/2-3 | 471-F-E167 | 80
Steel Assembly | RIGID_FRAME | 28.1 | +48.500 | +48.700 | C-D/2-3 | 471-F-E105 | 461.115
Steel Assembly | RIGID_FRAME | 127.7 | +48.500 | +48.700 | C-D/2-3 | 471-F-E98 | 243.355
Steel Assembly | RIGID_FRAME | 137.7 | +48.346 | +48.700 | C-D/2-3 | 471-F-E93 | 253.403
Steel Assembly | RIGID_FRAME | 135.4 | +48.346 | +48.700 | C-D/2-3 | 471-F-E92 | 160
Steel Assembly | RIGID_FRAME | 51.2 | +48.346 | +48.700 | B-C/2-3 | 471-F-E67 | 214.993
Steel Assembly | RIGID_FRAME | 53.3 | +48.346 | +48.700 | C-D/2-3 | 471-F-E122 | 327.809
Steel Assembly | RIGID_FRAME | 53 | +48.346 | +48.700 | C-D/2-3 | 471-F-E123 | 346.75
Steel Assembly | RIGID_FRAME | 53.3 | +48.346 | +48.700 | C-D/2-3 | 471-F-E121 | 327.809
Steel Assembly | RIGID_FRAME | 70.6 | +48.500 | +48.700 | D-E/2-3 | 471-F-E19 | 164.595
Steel Assembly | RIGID_FRAME | 69.7 | +48.500 | +48.700 | D-E/2-3 | 471-F-E85 | 281.303
Steel Assembly | RIGID_FRAME | 32.1 | +48.348 | +48.500 | D-E/2-3 | 471-F-E143 | 152.4
Steel Assembly | RIGID_FRAME | 221.7 | +50.901 | +51.153 | D/2-3 | 471-G-F316 | 146.1
Steel Assembly | RIGID_FRAME | 221.7 | +50.901 | +51.153 | E/2-3 | 471-G-F317 | 146.1
Steel Assembly | RIGID_FRAME | 221.7 | +46.761 | +47.013 | D/2-3 | 471-F-E210 | 146.1
Steel Assembly | RIGID_FRAME | 221.7 | +46.761 | +47.013 | E/2-3 | 471-F-E209 | 146.1
Steel Assembly | RIGID_FRAME | 79.5 | +44.221 | +44.575 | D-E/2-3 | 471-F-E16 | 230.618
Steel Assembly | RIGID_FRAME | 33.1 | +44.067 | +44.219 | D-E/2-3 | 471-F-E141 | 152.4
4 x Steel Assembly | RIGID_FRAME | 27.2 | +44.067 | +44.219 | C-D/2-3 | 471-F-E144 | 152.4
Steel Assembly | RIGID_FRAME | 34.5 | +44.221 | +44.575 | C-D/2-3 | 471-F-E112 | 450.448
Steel Assembly | RIGID_FRAME | 27.1 | +44.223 | +44.375 | B-C/2-3 | 471-F-E140 | 152.4
Steel Assembly | RIGID_FRAME | 93.6 | +44.375 | +44.575 | B-C/2-3 | 471-F-E10 | 159.994
Steel Assembly | RIGID_FRAME | 34.4 | +44.221 | +44.575 | C-D/2-3 | 471-F-E113 | 450.745
Steel Assembly | RIGID_FRAME | 12.4 | +44.388 | +44.468 | C-D/2-3 | 471-F-E159 | 80
Steel Assembly | RIGID_FRAME | 63.6 | +44.221 | +44.575 | C-D/2-3 | 471-F-E211 | 282.009
Steel Assembly | RIGID_FRAME | 46.4 | +44.375 | +44.575 | C-D/2-3 | 471-F-E69 | 354.115
Steel Assembly | RIGID_FRAME | 30.6 | +44.067 | +44.219 | C-D/2-3 | 471-F-E145 | 152.4
2 x Steel Assembly | RIGID_FRAME | 27.1 | +44.223 | +44.375 | C-D/3-4 | 471-F-E139 | 152.4
Steel Assembly | RIGID_FRAME | 53.3 | +44.221 | +44.575 | C-D/2-3 | 471-F-E122 | 327.809
Steel Assembly | RIGID_FRAME | 53.3 | +44.221 | +44.575 | C-D/2-3 | 471-F-E121 | 327.809
Steel Assembly | RIGID_FRAME | 221.7 | +41.554 | +41.806 | E/2-3 | 471-F-E207 | 146.1
Steel Assembly | RIGID_FRAME | 221.7 | +41.554 | +41.806 | D/2-3 | 471-F-E208 | 146.1
Steel Assembly | RIGID_FRAME | 221.7 | +33.747 | +33.999 | E/2-3 | 471-E-D156 | 146.1
Steel Assembly | RIGID_FRAME | 221.7 | +33.747 | +33.999 | D/2-3 | 471-E-D157 | 146.1
Steel Assembly | RIGID_FRAME | 221.7 | +26.164 | +26.415 | D/2-3 | 471-E-D155 | 146.1
Steel Assembly | RIGID_FRAME | 221.7 | +26.164 | +26.415 | E/2-3 | 471-E-D154 | 146.1
Steel Assembly | RIGID_FRAME | 79.5 | +38.684 | +39.038 | D-E/2-3 | 471-F-E15 | 231.268
Steel Assembly | RIGID_FRAME | 33.1 | +38.530 | +38.682 | D-E/2-3 | 471-F-E141 | 152.4
Steel Assembly | RIGID_FRAME | 75.4 | +35.916 | +36.270 | D-E/2-3 | 471-E-D48 | 298.407
Steel Assembly | RIGID_FRAME | 63.7 | +35.916 | +36.270 | C-D/2-3 | 471-E-D163 | 281.469
Steel Assembly | RIGID_FRAME | 30.9 | +35.762 | +35.914 | C-D/2-3 | 471-E-D105 | 152.4
Steel Assembly | RIGID_FRAME | 12.2 | +36.083 | +36.163 | C-D/2-3 | 471-E-D129 | 80
Steel Assembly | RIGID_FRAME | 46.4 | +36.070 | +36.270 | C-D/2-3 | 471-E-D59 | 354.376
Steel Assembly | RIGID_FRAME | 11.4 | +36.088 | +36.240 | B-C/2 | 471-E-D102 | 160
2 x Steel Assembly | RIGID_FRAME | 27.1 | +35.918 | +36.070 | C-D/3-4 | 471-E-D100 | 152.4
Steel Assembly | RIGID_FRAME | 53.3 | +35.916 | +36.270 | C-D/2-3 | 471-E-D67 | 327.809
2 x Steel Assembly | RIGID_FRAME | 27.2 | +35.762 | +35.914 | C-D/2-3 | 471-E-D103 | 152.4
Steel Assembly | RIGID_FRAME | 53.3 | +35.916 | +36.270 | C-D/2-3 | 471-E-D68 | 327.809
Steel Assembly | RIGID_FRAME | 41.9 | +44.275 | +44.575 | C-D/1-2 | 471-F-E216 | 112
Steel Assembly | RIGID_FRAME | 380.5 | +44.219 | +44.575 | C-D/1-2 | 471-F-E54 | 183.5
Steel Assembly | RIGID_FRAME | 473.7 | +43.887 | +44.937 | C-D/2 | 471-F-E28 | 315.008
3 x Steel Assembly | RIGID_FRAME | 8.2 | +44.400 | +45.680 | C-D/2 | 471-F-E203 | 70
Steel Assembly | RIGID_FRAME | 33.4 | +44.275 | +44.575 | C-D/1-2 | 471-F-E214 | 100
Steel Assembly | RIGID_FRAME | 20 | +44.375 | +44.575 | C-D/1-2 | 471-F-E221 | 75
Steel Assembly | RIGID_FRAME | 24.6 | +44.375 | +44.575 | C-D/1-2 | 471-F-E223 | 75
Steel Assembly | RIGID_FRAME | 39.1 | +44.275 | +44.575 | C-D/1-2 | 471-F-E215 | 100
Steel Assembly | RIGID_FRAME | 44.7 | +43.108 | +44.217 | C/1-2 | 471-F-E89 | 180
Steel Assembly | RIGID_FRAME | 44.7 | +43.108 | +44.217 | D/1-2 | 471-F-E89 | 180
Steel Assembly | RIGID_FRAME | 435.1 | +43.866 | +44.924 | C/2-3 | 471-F-E29 | 316.239
Steel Assembly | RIGID_FRAME | 427.8 | +43.866 | +44.924 | D/2-3 | 471-F-E30 | 315.058
Steel Assembly | RIGID_FRAME | 68.3 | +44.219 | +44.575 | C/1-2 | 471-F-E57 | 190
Steel Assembly | RIGID_FRAME | 68.3 | +44.219 | +44.575 | D/1-2 | 471-F-E58 | 190
Steel Assembly | RIGID_FRAME | 77 | +35.970 | +36.270 | C-D/1-2 | 471-E-D165 | 100
Steel Assembly | RIGID_FRAME | 27.9 | +36.070 | +36.270 | C-D/1-2 | 471-E-D168 | 87
Steel Assembly | RIGID_FRAME | 26.7 | +36.070 | +36.270 | C-D/1-2 | 471-E-D166 | 75
Steel Assembly | RIGID_FRAME | 25.2 | +36.070 | +36.270 | C-D/1-2 | 471-E-D169 | 75
Steel Assembly | RIGID_FRAME | 51.6 | +35.970 | +36.270 | C-D/1-2 | 471-E-D164 | 100
Steel Assembly | RIGID_FRAME | 44.6 | +34.806 | +35.912 | C/1-2 | 471-E-D97 | 180
Steel Assembly | RIGID_FRAME | 44.6 | +34.806 | +35.912 | D/1-2 | 471-E-D97 | 180
Steel Assembly | RIGID_FRAME | 377.5 | +35.914 | +36.270 | C-D/1-2 | 471-E-D42 | 183.5
Steel Assembly | RIGID_FRAME | 447.4 | +35.563 | +36.615 | C/2-3 | 471-E-D17 | 318.136
Steel Assembly | RIGID_FRAME | 84.7 | +35.914 | +36.270 | C/1-2 | 471-E-D43 | 190.75
Steel Assembly | RIGID_FRAME | 479 | +35.572 | +36.623 | C-D/2 | 471-E-D15 | 315.058
Steel Assembly | RIGID_FRAME | 81.8 | +35.914 | +36.270 | D/1-2 | 471-E-D44 | 190
Steel Assembly | RIGID_FRAME | 77 | +28.780 | +29.080 | C-D/1-2 | 471-E-D165 | 100
Steel Assembly | RIGID_FRAME | 27.9 | +28.880 | +29.080 | C-D/1-2 | 471-E-D168 | 87
Steel Assembly | RIGID_FRAME | 26.7 | +28.880 | +29.080 | C-D/1-2 | 471-E-D166 | 75
Steel Assembly | RIGID_FRAME | 25.2 | +28.880 | +29.080 | C-D/1-2 | 471-E-D169 | 75
Steel Assembly | RIGID_FRAME | 51.6 | +28.780 | +29.080 | C-D/1-2 | 471-E-D164 | 100
Steel Assembly | RIGID_FRAME | 44.6 | +27.616 | +28.722 | C/1-2 | 471-E-D97 | 180
Steel Assembly | RIGID_FRAME | 44.6 | +27.616 | +28.722 | D/1-2 | 471-E-D97 | 180
Steel Assembly | RIGID_FRAME | 377.5 | +28.724 | +29.080 | C-D/1-2 | 471-E-D42 | 183.5
Steel Assembly | RIGID_FRAME | 441.6 | +28.373 | +29.424 | C/2-3 | 471-E-D18 | 314.99
Steel Assembly | RIGID_FRAME | 430.3 | +28.373 | +29.419 | D/2-3 | 471-E-D19 | 315.065
Steel Assembly | RIGID_FRAME | 84.7 | +28.724 | +29.080 | C/1-2 | 471-E-D43 | 190.75
Steel Assembly | RIGID_FRAME | 479.4 | +28.382 | +29.433 | C-D/2 | 471-E-D20 | 315.008
Steel Assembly | RIGID_FRAME | 81.8 | +28.724 | +29.080 | D/1-2 | 471-E-D44 | 190
Steel Assembly | RIGID_FRAME | 99.4 | +63.167 | +63.377 | B-C/2-3 | 471-G-F352 | 193.7
Steel Assembly | RIGID_FRAME | 171.6 | +62.798 | +63.791 | B-C/3 | 471-G-F96 | 276.191
Steel Assembly | RIGID_FRAME | 99.4 | +57.737 | +57.947 | B-C/2-3 | 471-G-F352 | 193.7
Steel Assembly | RIGID_FRAME | 168 | +57.322 | +58.317 | B-C/3 | 471-G-F95 | 276.191
Steel Assembly | RIGID_FRAME | 402.7 | +57.664 | +58.373 | C/2-3 | 471-G-F67 | 278.694
Steel Assembly | RIGID_FRAME | 99.4 | +55.022 | +55.232 | B-C/2-3 | 471-G-F352 | 193.7
Steel Assembly | RIGID_FRAME | 171.2 | +54.599 | +55.648 | B-C/3 | 471-G-F94 | 276.191
Steel Assembly | RIGID_FRAME | 58.9 | +33.799 | +33.999 | D-E/2-3 | 471-E-D2 | 228.139
Steel Assembly | RIGID_FRAME | 57.6 | +33.799 | +33.999 | D-E/2-3 | 471-E-D45 | 278.439
Steel Assembly | RIGID_FRAME | 29 | +33.647 | +33.799 | D-E/2-3 | 471-E-D99 | 152.4
Steel Assembly | RIGID_FRAME | 74.1 | +31.528 | +31.728 | D-E/2-3 | 471-E-D3 | 226.818
Steel Assembly | RIGID_FRAME | 99.4 | +52.757 | +52.967 | B-C/2-3 | 471-G-F352 | 193.7
Steel Assembly | RIGID_FRAME | 170.7 | +52.373 | +53.391 | B-C/3 | 471-G-F93 | 276.191
Steel Assembly | RIGID_FRAME | 435.3 | +52.334 | +53.369 | C/2-3 | 471-G-F56 | 278.694
