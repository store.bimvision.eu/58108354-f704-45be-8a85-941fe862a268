Properties of the parts of a building model (IFC2X3), part 1 of 22

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], ExchangeRequirement[Structural, SurfaceGeometry]
File name: 47L.ifc
Time: 2017-01-18T18:11:25
Author: GEN-PC\GEN
Organization: Structural Designer
Written by: IFC Database Version:Work
Made in: Tekla Structures 21.1, IFC Export Version: 4.0.0.0 Sep 11 2015

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: 350*350 (3)
In: Undefined
Description: 350*350; Material: STEEL/S355JR
Tekla Common - Bottom elevation: -1.030; Top elevation: -0.030; Phase: 152; Class: 2
Tekla Quantity - Weight: 961.6 kg; Volume: 0.1 m3; Gross footprint area: 0.1 m2; Area per tons: 1.7 m2; Net surface area: 1.6 m2; Height: 349.9 mm; Width: 350 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 471-0-010013
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 1.645 m2; NetVolume: 0.1225 m3; NetWeight: 961.625 kg

# IfcBeam: 400*1000 (25)
In: Undefined
Description: 400*1000; Material: STEEL/S355JR
Tekla Common - Bottom elevation: -1.830; Top elevation: -0.830; Phase: 152; Class: 2
Tekla Quantity - Area per tons: 0.9 m2; Height: 1000 mm; Width: 400 mm
Pset_BeamCommon - LoadBearing: yes
Name | Weight (kg) = NetWeight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3)
BEAM | 7850 | 1 | 0.9 | 7.8 | 2500 | 10012 | 7.8 | 1
4 x BEAM | 18840 | 2.4 | 2.4 | 17.6 | 6000 | 10011 | 17.6 | 2.4
4 x BEAM | 27318 | 3.5 | 3.5 | 25.2 | 8700 | 10007 | 25.16 | 3.48
2 x BEAM | 12560 | 1.6 | 1.6 | 12 | 4000 | 10010 | 12 | 1.6
2 x BEAM | 21980 | 2.8 | 2.8 | 20.4 | 7000 | 10009 | 20.4 | 2.8
3 x BEAM | 13816 | 1.8 | 1.8 | 13.1 | 4400 | 10000 | 13.12 | 1.76
BEAM | 9106 | 1.2 | 1.2 | 9 | 2900 | 10008 | 8.92 | 1.16
2 x BEAM | 11775 | 1.5 | 1.5 | 11.3 | 3750 | 10006 | 11.3 | 1.5
2 x BEAM | 17238.6 | 2.2 | 2.2 | 16.2 | 5490 | 10005 | 16.172 | 2.196
2 x BEAM | 18039.3 | 2.3 | 2.3 | 16.9 | 5745 | 10004 | 16.886 | 2.298
BEAM | 16014 | 2 | 2 | 15.1 | 5100 | 10003 | 15.08 | 2.04
BEAM | 19468 | 2.4 | 2.4 | 18.2 | 6200 | 10002 | 18.16 | 2.48

# IfcBeam: 400*700, BEAM
In: Undefined
Description: 400*700; Material: STEEL/S355JR
Tekla Common - Bottom elevation: -1.830; Top elevation: -0.830; Phase: 152; Class: 2
Tekla Quantity - Weight: 2198 kg; Volume: 0.3 m3; Gross footprint area: 0.3 m2; Area per tons: 1.3 m2; Net surface area: 2.8 m2; Height: 700 mm; Width: 400 mm; Length: 1000 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 10001
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 2.76 m2; NetVolume: 0.28 m3; NetWeight: 2198 kg

# IfcBeam: 750*750 (32)
In: Undefined
Description: 750*750; Material: STEEL/S355JR
Tekla Common - Bottom elevation: -1.330; Phase: 152; Class: 2
Tekla Quantity - Volume: 0.7 m3; Gross footprint area: 0.6 m2; Area per tons: 0.9 m2; Height: 750 mm; Width: 750 mm
Pset_BeamCommon - LoadBearing: yes
Name | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
24 x BEAM | -0.030 | 5740.3 | 5 | 1300 | 471-0-010032 | 5.025 | 0.73125 | 5740.31
8 x BEAM | -0.330 | 4415.6 | 4.1 | 1000 | 471-0-010031 | 4.125 | 0.5625 | 4415.62

# IfcBeam: CHS193.7*8.0 (68)
In: Undefined
Description: CHS193.7*8.0; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 16.7 m2; Height: 193.7 mm; Width: 193.7 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
HOR. BRACE | +63.175 | +63.369 | 8 | 6 | 73.5 | 1.3 | 2013.3 | mf-288 | 2013.27 | 1.22513 | 0.0091729 | 72.0072
HOR. BRACE | +57.745 | +57.939 | 8 | 6 | 73.5 | 1.3 | 2013.3 | mf-288 | 2013.27 | 1.22513 | 0.0091729 | 72.0072
HOR. BRACE | +55.030 | +55.224 | 8 | 6 | 73.5 | 1.3 | 2013.3 | mf-288 | 2013.27 | 1.22513 | 0.0091729 | 72.0072
HOR. BRACE | +52.765 | +52.959 | 8 | 6 | 73.5 | 1.3 | 2013.3 | mf-288 | 2013.27 | 1.22513 | 0.0091729 | 72.0072
HOR. BRACE | +44.300 | +44.494 | 7 | 6 | 154.3 | 2.6 | 4227.1 | me-182 | 4227.12 | 2.57231 | 0.0193877 | 152.193
HOR. BRACE | +38.763 | +38.957 | 7 | 6 | 154.3 | 2.6 | 4227.1 | me-182 | 4227.12 | 2.57231 | 0.0193877 | 152.193
HOR. BRACE | +35.995 | +36.189 | 6 | 6 | 154.3 | 2.6 | 4227.1 | md-140 | 4227.12 | 2.57231 | 0.0193877 | 152.193
HOR. BRACE | +31.453 | +31.647 | 6 | 6 | 154.3 | 2.6 | 4227.1 | md-140 | 4227.12 | 2.57231 | 0.0193877 | 152.193
HOR. BRACE | +28.805 | +28.999 | 6 | 6 | 154.3 | 2.6 | 4227.1 | md-140 | 4227.12 | 2.57231 | 0.0193877 | 152.193
HOR. BRACE | +24.043 | +24.237 | 5 | 6 | 154.3 | 2.6 | 4227.1 | mc-396 | 4227.12 | 2.57231 | 0.0193877 | 152.193
FLOOR BRACE | +17.606 | +17.799 | 4 | 6 | 149.7 | 2.5 | 4101.4 | mb-190 | 4101.37 | 2.49579 | 0.0188074 | 147.638
FLOOR BRACE | +10.146 | +10.339 | 3 | 6 | 150.1 | 2.5 | 4112.4 | ma-174 | 4112.44 | 2.50253 | 0.0188585 | 148.04
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 135.6 | 2.3 | 3714.7 | mc-395 | 3714.67 | 2.26047 | 0.0170232 | 133.632
FLOOR BRACE | +5.441 | +5.635 | 3 | 6 | 143.5 | 2.5 | 3932.5 | ma-177 | 3932.46 | 2.39301 | 0.0180281 | 141.521
FLOOR BRACE | +15.256 | +15.449 | 5 | 4 | 138.4 | 2.3 | 3790.5 | mc-394 | 3790.49 | 2.30661 | 0.017373 | 136.378
FLOOR BRACE | +15.256 | +15.449 | 5 | 6 | 221.1 | 3.7 | 6056.3 | mc-393 | 6056.27 | 3.6854 | 0.0278274 | 218.445
FLOOR BRACE | +10.146 | +10.339 | 3 | 6 | 136.6 | 2.3 | 3741.7 | ma-176 | 3741.7 | 2.27692 | 0.0171479 | 134.611
FLOOR BRACE | +10.146 | +10.339 | 3 | 6 | 248.5 | 4.1 | 6807.4 | ma-175 | 6807.38 | 4.14247 | 0.031293 | 245.65
FLOOR BRACE | +5.256 | +5.449 | 3 | 6 | 248.5 | 4.1 | 6807.4 | ma-175 | 6807.38 | 4.14247 | 0.031293 | 245.65
FLOOR BRACE | +5.256 | +5.449 | 3 | 6 | 150.1 | 2.5 | 4112.4 | ma-174 | 4112.44 | 2.50253 | 0.0188585 | 148.04
2 x FLOOR BRACE | +5.256 | +5.449 | 3 | 6 | 131.6 | 2.2 | 3604.5 | ma-173 | 3604.54 | 2.19346 | 0.0165151 | 129.643
2 x FLOOR BRACE | +10.146 | +10.339 | 3 | 6 | 141.6 | 2.5 | 3879.3 | ma-172 | 3879.34 | 2.36068 | 0.017783 | 139.596
FLOOR BRACE | +15.256 | +15.449 | 5 | 4 | 165.6 | 2.7 | 4538 | mc-392 | 4538.03 | 2.76151 | 0.0208222 | 163.454
2 x FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 185.5 | 3.1 | 5081.8 | mc-390 | 5081.84 | 3.09244 | 0.0233314 | 183.151
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 38.3 | 0.6 | 1048.3 | mc-391 | 1048.26 | 0.637896 | 0.00472035 | 37.0548
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 69.4 | 1.3 | 1901.9 | mc-389 | 1901.89 | 1.15735 | 0.00865902 | 67.9733
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 107.1 | 1.7 | 2935 | mc-388 | 2935.04 | 1.78605 | 0.013426 | 105.394
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 96.2 | 1.6 | 2636.7 | mc-387 | 2636.66 | 1.60448 | 0.0120493 | 94.5867
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 109.3 | 1.7 | 2997.9 | mc-386 | 2997.94 | 1.82432 | 0.0137162 | 107.672
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 133.9 | 2.2 | 3669.1 | mc-385 | 3669.13 | 2.23277 | 0.0168131 | 131.983
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 132.8 | 2.2 | 3635.6 | mc-384 | 3635.65 | 2.21239 | 0.0166586 | 130.77
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 129.1 | 2.1 | 3537.8 | mc-383 | 3537.81 | 2.15285 | 0.0162072 | 127.226
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 148.6 | 2.5 | 4071.6 | mc-382 | 4071.65 | 2.47771 | 0.0186703 | 146.562
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 152.6 | 2.5 | 4180 | mc-381 | 4179.95 | 2.54361 | 0.01917 | 150.485
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 116.2 | 1.9 | 3180.8 | mc-380 | 3180.78 | 1.93559 | 0.0145598 | 114.294
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 139.2 | 2.3 | 3817.1 | mc-379 | 3817.1 | 2.32281 | 0.0174958 | 137.342
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 141.1 | 2.3 | 3866.3 | mc-378 | 3866.34 | 2.35277 | 0.017723 | 139.126
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 79 | 1.3 | 2164.9 | mc-377 | 2164.89 | 1.31739 | 0.00987251 | 77.4992
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 113.7 | 1.9 | 3115.7 | mc-376 | 3115.67 | 1.89597 | 0.0142594 | 111.936
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 107.7 | 1.7 | 2950.4 | mc-375 | 2950.44 | 1.79542 | 0.013497 | 105.952
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 67.5 | 1.1 | 1849.3 | mc-374 | 1849.34 | 1.12537 | 0.00841653 | 66.0698
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 136.3 | 2.3 | 3734.4 | mc-373 | 3734.45 | 2.27251 | 0.0171145 | 134.348
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 76 | 1.3 | 2080.3 | mc-372 | 2080.3 | 1.26592 | 0.00948219 | 74.4352
2 x FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 50.8 | 0.8 | 1392.6 | mc-371 | 1392.56 | 0.847411 | 0.00630895 | 49.5253
FLOOR BRACE | +12.056 | +12.249 | 5 | 6 | 45.8 | 0.8 | 1255.8 | mc-370 | 1255.85 | 0.764218 | 0.00567816 | 44.5736
FLOOR BRACE | +10.281 | +10.475 | 5 | 6 | 95.6 | 1.6 | 2618.3 | mc-369 | 2618.35 | 1.59333 | 0.0119647 | 93.9233
FLOOR BRACE | +10.281 | +10.475 | 5 | 6 | 95.8 | 1.6 | 2625.8 | mc-368 | 2625.76 | 1.59784 | 0.011999 | 94.1918
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 109.7 | 1.7 | 3005.1 | mc-367 | 3005.05 | 1.82865 | 0.013749 | 107.93
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 162.5 | 2.7 | 4451.7 | mc-366 | 4451.67 | 2.70896 | 0.0204237 | 160.326
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 153.9 | 2.6 | 4217.1 | mc-365 | 4217.08 | 2.56621 | 0.0193413 | 151.83
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 115 | 1.9 | 3149.7 | mc-364 | 3149.72 | 1.91669 | 0.0144165 | 113.17
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 113.3 | 1.9 | 3103.6 | mc-363 | 3103.6 | 1.88862 | 0.0142037 | 111.499
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 123.7 | 2.1 | 3388.3 | mc-362 | 3388.3 | 2.06187 | 0.0155173 | 121.811
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 124 | 2.1 | 3397.5 | mc-361 | 3397.45 | 2.06744 | 0.0155596 | 122.143
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 123.3 | 1.9 | 3377.7 | mc-360 | 3377.69 | 2.05542 | 0.0154684 | 121.427
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 50.2 | 0.8 | 1376.1 | mc-359 | 1376.1 | 0.837396 | 0.00623302 | 48.9292
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 55.6 | 0.8 | 1522.1 | mc-358 | 1522.13 | 0.926253 | 0.00690676 | 54.2181
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 41.9 | 0.6 | 1147.2 | mc-357 | 1147.17 | 0.698084 | 0.00517671 | 40.6372
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 112.6 | 1.9 | 3084.4 | mc-356 | 3084.43 | 1.87696 | 0.0141153 | 110.805
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 120 | 1.9 | 3288.4 | mc-355 | 3288.44 | 2.0011 | 0.0150566 | 118.194
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 104.2 | 1.7 | 2853 | mc-354 | 2853.04 | 1.73615 | 0.0130476 | 102.424
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 61.2 | 1 | 1676.2 | mc-353 | 1676.17 | 1.01999 | 0.00761752 | 59.7975
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 66.4 | 1.1 | 1822.1 | mc-352 | 1822.08 | 1.10879 | 0.00829078 | 65.0826
FLOOR BRACE | +5.256 | +5.449 | 5 | 6 | 70 | 1.3 | 1914.5 | mc-351 | 1914.55 | 1.16505 | 0.0087174 | 68.4316

# IfcBeam: CHS219.1*8.0 (40)
In: Undefined
Description: CHS219.1*8.0; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 16.5 m2; Height: 219.1 mm; Width: 219.1 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
HOR. BRACE | +21.172 | +21.392 | 5 | 6 | 270.3 | 4.5 | 6497.1 | mc-444 | 6497.06 | 4.47207 | 0.0340654 | 267.413
BRACE | +63.570 | +65.529 | 8 | 1 | 81.5 | 1.3 | 1958.6 | mf-325 | 1958.64 | 1.34817 | 0.0101882 | 79.9777
BRACE | +58.342 | +62.974 | 8 | 1 | 192.7 | 3.2 | 4632.8 | mf-323 | 4632.78 | 3.18885 | 0.0242572 | 190.419
BRACE | +55.673 | +57.645 | 8 | 1 | 82.1 | 1.5 | 1972.6 | mf-321 | 1972.56 | 1.35776 | 0.0102615 | 80.5528
BRACE | +53.416 | +54.930 | 8 | 1 | 63 | 1 | 1514.6 | mf-319 | 1514.59 | 1.04253 | 0.00785207 | 61.6387
BRACE | +49.037 | +52.665 | 8 | 1 | 151 | 2.5 | 3628.7 | mf-317 | 3628.7 | 2.49772 | 0.0189746 | 148.951
BRACE | +39.393 | +44.200 | 7 | 1 | 200 | 3.3 | 4807.8 | me-201 | 4807.75 | 3.30928 | 0.0251489 | 197.419
BRACE | +36.648 | +38.663 | 7 | 1 | 83.8 | 1.5 | 2015.4 | me-199 | 2015.43 | 1.38727 | 0.0104582 | 82.0972
BRACE | +32.090 | +35.895 | 6 | 1 | 158.3 | 2.6 | 3805.7 | md-167 | 3805.67 | 2.61953 | 0.0198769 | 156.033
BRACE | +29.455 | +31.353 | 6 | 1 | 79 | 1.3 | 1898.6 | md-165 | 1898.65 | 1.30688 | 0.00984384 | 77.2742
BRACE | +5.725 | +11.851 | 5 | 1 | 254.8 | 4.3 | 6125.9 | mc-436 | 6125.93 | 4.21662 | 0.032156 | 252.425
BRACE | +18.403 | +19.055 | 5 | 6 | 137 | 2.3 | 3293.5 | mc-433 | 3293.52 | 2.26701 | 0.0172112 | 135.108
2 x BRACE | +15.296 | +16.999 | 5 | 6 | 215.4 | 3.6 | 5178.2 | mc-432 | 5178.24 | 3.5643 | 0.0271269 | 212.947
2 x BRACE | +47.459 | +48.246 | 7 | 1 | 93.3 | 1.5 | 2243.9 | me-197 | 2243.89 | 1.54452 | 0.011689 | 91.7586
2 x VERT BRACE | +15.811 | +17.576 | 4 | 5 | 207.2 | 3.5 | 4980.7 | mb-207 | 4980.68 | 3.42832 | 0.0260875 | 204.787
FLOOR BRACE | +17.593 | +17.812 | 4 | 6 | 274.5 | 4.5 | 6597.4 | mb-204 | 6597.44 | 4.54117 | 0.0345935 | 271.559
BRACE | +10.702 | +12.032 | 5 | 5 | 147.4 | 2.5 | 3543.5 | mc-425 | 3543.49 | 2.43907 | 0.0185263 | 145.432
4 x FLOOR BRACE | +5.428 | +5.648 | 5 | 6 | 270.5 | 4.5 | 6501.4 | mc-401 | 6501.38 | 4.47505 | 0.0340881 | 267.592
VERT BRACE | +15.806 | +17.589 | 4 | 1 | 227.5 | 3.8 | 5467.9 | mb-229 | 5467.86 | 3.76365 | 0.0286506 | 224.907
FLOOR BRACE | +5.243 | +5.462 | 5 | 6 | 284.4 | 4.7 | 6835.7 | mc-402 | 6835.65 | 4.70514 | 0.0358468 | 281.397
BRACE | +63.565 | +65.779 | 8 | 5 | 251.8 | 4.1 | 6052.6 | mf-304 | 6052.62 | 4.16615 | 0.0317271 | 249.058
FLOOR BRACE | +5.428 | +5.648 | 5 | 6 | 171.4 | 2.8 | 4119.9 | mc-400 | 4119.91 | 2.83583 | 0.0215589 | 169.238
FLOOR BRACE | +5.428 | +5.648 | 5 | 6 | 243.5 | 4 | 5853.9 | mc-399 | 5853.95 | 4.02941 | 0.0306819 | 240.853
2 x BRACE | +53.141 | +54.849 | 8 | 5 | 234.7 | 4 | 5641 | mf-293 | 5641 | 3.88283 | 0.0295615 | 232.058
BRACE | +55.418 | +57.551 | 8 | 5 | 249.3 | 4.1 | 5993.2 | mf-295 | 5993.21 | 4.12526 | 0.0314145 | 246.604
BRACE | +53.141 | +54.849 | 8 | 5 | 235.3 | 4 | 5655.7 | mf-294 | 5655.66 | 3.89292 | 0.0296387 | 232.664
BRACE | +36.384 | +38.568 | 7 | 5 | 250.8 | 4.1 | 6028.5 | me-186 | 6028.48 | 4.14954 | 0.0316001 | 248.061
BRACE | +29.191 | +31.261 | 6 | 5 | 247.2 | 4.1 | 5942.8 | md-153 | 5942.79 | 4.09056 | 0.0311493 | 244.522
2 x VERT BRACE | +21.577 | +23.846 | 4 | 5 | 253.2 | 4.1 | 6086.9 | mb-216 | 6086.88 | 4.18974 | 0.0319074 | 250.473
VERT BRACE | +15.803 | +17.591 | 4 | 5 | 238 | 4 | 5720.2 | mb-213 | 5720.17 | 3.93732 | 0.0299781 | 235.328
FLOOR BRACE | +15.413 | +15.632 | 4 | 6 | 177 | 3 | 4253.3 | mb-203 | 4253.31 | 2.92765 | 0.0222608 | 174.747
FLOOR BRACE | +15.413 | +15.632 | 4 | 6 | 286.6 | 4.7 | 6888.8 | mb-202 | 6888.78 | 4.74171 | 0.0361263 | 283.591

# IfcBeam: CHS273.1*10.0 (2)
In: Undefined
Description: CHS273.1*10.0; Material: STEEL/S355JR
Tekla Common - Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 13.3 m2; Height: 273.1 mm; Width: 273.1 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BRACE | +24.768 | +28.604 | 6 | 249 | 3.3 | 3836.4 | md-175 | 3.29151 | 0.031227 | 245.132
BRACE | +21.910 | +23.512 | 5 | 104 | 1.5 | 1602.4 | mc-455 | 1.37481 | 0.0129164 | 101.393

# IfcBeam: IPE200 (626)
In: Undefined
Description: IPE200; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 34.3 m2; Height: 200 mm; Width: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BEAM | +63.250 | +63.450 | 8 | 14 | 31.7 | 0.1 | 1.1 | 1413 | mf-145 | 1413 | 1.08546 | 0.00376296 | 29.5393
BEAM | +63.250 | +63.450 | 8 | 14 | 15.1 | 0.1 | 0.5 | 672 | mf-141 | 672 | 0.516229 | 0.00183107 | 14.3739
BEAM | +63.250 | +63.450 | 8 | 14 | 31.7 | 0.1 | 1.1 | 1413 | mf-145 | 1413 | 1.08546 | 0.00376297 | 29.5393
2 x BEAM | +63.250 | +63.450 | 8 | 14 | 31.7 | 0.1 | 1.1 | 1416.4 | mf-140 | 1416.4 | 1.08808 | 0.00369041 | 28.9697
6 x BEAM | +48.500 | +48.700 | 7 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | me-89 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
5 x BEAM | +48.500 | +48.700 | 7 | 14 | 16.2 | 0.1 | 0.5 | 724.6 | me-91 | 724.55 | 0.556598 | 0.00181228 | 14.2264
2 x BEAM | +48.500 | +48.700 | 7 | 14 | 26.8 | 0.1 | 0.8 | 1198.4 | me-82 | 1198.4 | 0.920609 | 0.0030964 | 24.3068
2 x BEAM | +48.500 | +48.700 | 7 | 14 | 24.6 | 0.1 | 0.8 | 1099.4 | me-86 | 1099.4 | 0.844557 | 0.00282665 | 22.1892
2 x BEAM | +48.500 | +48.700 | 7 | 14 | 26.9 | 0.1 | 0.8 | 1201.4 | me-85 | 1201.4 | 0.922913 | 0.00310458 | 24.3709
4 x BEAM | +48.500 | +48.700 | 7 | 14 | 56.5 | 0.2 | 1.9 | 2521.6 | me-80 | 2521.55 | 1.93705 | 0.00670875 | 52.6637
2 x BEAM | +48.500 | +48.700 | 7 | 14 | 17.2 | 0.1 | 0.6 | 766.4 | me-84 | 766.4 | 0.588747 | 0.00191929 | 15.0664
2 x BEAM | +48.500 | +48.700 | 7 | 14 | 19.4 | 0.1 | 0.6 | 865.6 | me-88 | 865.55 | 0.664914 | 0.00219648 | 17.2424
2 x BEAM | +5.500 | +5.700 | 5 | 23 | 47.1 | 0.2 | 1.6 | 2102.6 | mc-258 | 2102.55 | 1.61518 | 0.00556706 | 43.7014
BEAM | +5.500 | +5.700 | 5 | 23 | 23.9 | 0.1 | 0.8 | 1067.4 | mc-246 | 1067.4 | 0.819975 | 0.00273946 | 21.5047
BEAM | +5.500 | +5.700 | 5 | 23 | 17.8 | 0.1 | 0.6 | 795.4 | mc-245 | 795.4 | 0.611025 | 0.00199831 | 15.6867
3 x BEAM | +5.500 | +5.700 | 5 | 23 | 66.4 | 0.3 | 2.3 | 2964.7 | mc-236 | 2964.7 | 2.27748 | 0.00792327 | 62.1977
2 x BEAM | +5.500 | +5.700 | 5 | 23 | 21.6 | 0.1 | 0.6 | 965.6 | mc-257 | 965.55 | 0.741734 | 0.00246896 | 19.3813
BEAM | +5.500 | +5.700 | 5 | 23 | 129.7 | 0.6 | 4.5 | 5789.1 | mc-230 | 5789.1 | 4.44718 | 0.0156095 | 122.534
BEAM | +15.500 | +15.700 | 5 | 23 | 32.6 | 0.1 | 1.1 | 1456.4 | mc-225 | 1456.4 | 1.1188 | 0.0037994 | 29.8253
2 x BEAM | +15.500 | +15.700 | 5 | 23 | 19.4 | 0.1 | 0.6 | 869.4 | mc-244 | 869.4 | 0.667872 | 0.00219995 | 17.2696
2 x BEAM | +15.500 | +15.700 | 5 | 23 | 89.6 | 0.3 | 3.1 | 3999.7 | mc-238 | 3999.7 | 3.07256 | 0.0107434 | 84.336
3 x BEAM | +15.500 | +15.700 | 5 | 23 | 89.6 | 0.3 | 3.1 | 3999.7 | mc-209 | 3999.7 | 3.07256 | 0.0107434 | 84.336
7 x BEAM | +15.500 | +15.700 | 5 | 23 | 65.6 | 0.3 | 2.3 | 2929.7 | mc-207 | 2929.7 | 2.25059 | 0.0078279 | 61.449
3 x BEAM | +15.500 | +15.700 | 5 | 23 | 88.8 | 0.3 | 3.1 | 3964.7 | mc-208 | 3964.7 | 3.04568 | 0.0106481 | 83.5873
2 x BEAM | +15.500 | +15.700 | 5 | 23 | 17 | 0.1 | 0.6 | 756.4 | mc-224 | 756.4 | 0.581065 | 0.00189204 | 14.8525
2 x BEAM | +15.500 | +15.700 | 5 | 23 | 14.9 | 0.1 | 0.5 | 666.4 | mc-223 | 666.4 | 0.511927 | 0.00164681 | 12.9275
2 x BEAM | +15.500 | +15.700 | 5 | 23 | 28.2 | 0.1 | 1 | 1265.6 | mc-199 | 1265.55 | 0.972193 | 0.0032864 | 25.7982
2 x BEAM | +15.500 | +15.700 | 5 | 23 | 28.4 | 0.1 | 1 | 1266.4 | mc-243 | 1266.4 | 0.972846 | 0.00328169 | 25.7613
BEAM | +5.500 | +5.700 | 5 | 23 | 17.2 | 0.1 | 0.6 | 766.4 | mc-222 | 766.4 | 0.588747 | 0.00191929 | 15.0664
BEAM | +5.500 | +5.700 | 5 | 23 | 17.2 | 0.1 | 0.6 | 765.6 | mc-256 | 765.55 | 0.588094 | 0.001924 | 15.1034
BEAM | +5.500 | +5.700 | 5 | 23 | 20.5 | 0.1 | 0.6 | 915.6 | mc-254 | 915.55 | 0.703324 | 0.00233272 | 18.3118
BEAM | +5.500 | +5.700 | 5 | 23 | 27.2 | 0.1 | 0.8 | 1215.6 | mc-255 | 1215.55 | 0.933783 | 0.00315016 | 24.7288
BEAM | +5.500 | +5.700 | 5 | 23 | 20.5 | 0.1 | 0.6 | 915.5 | mc-254 | 915.55 | 0.703324 | 0.00233272 | 18.3118
BEAM | +5.500 | +5.700 | 5 | 7 | 27.9 | 0.1 | 1 | 1250.5 | mc-195 | 1250.45 | 0.960593 | 0.00333554 | 26.184
BEAM | +5.500 | +5.700 | 5 | 7 | 52.1 | 0.2 | 1.7 | 2327.4 | mc-193 | 2327.35 | 1.78787 | 0.00626409 | 49.1731
BEAM | +5.500 | +5.700 | 5 | 7 | 27.9 | 0.1 | 1 | 1250.5 | mc-195 | 1250.45 | 0.960594 | 0.00333555 | 26.1841
BEAM | +12.300 | +12.500 | 5 | 7 | 26.3 | 0.1 | 0.8 | 1171.2 | mc-194 | 1171.2 | 0.899713 | 0.0031196 | 24.4889
2 x BEAM | +5.500 | +5.700 | 5 | 23 | 17.2 | 0.1 | 0.6 | 764.7 | mc-220 | 764.7 | 0.587441 | 0.00192871 | 15.1404
BEAM | +5.700 | +5.900 | 5 | 13 | 130.3 | 0.6 | 4.7 | 5818.2 | mc-189 | 5818.2 | 4.46953 | 0.0157689 | 123.786
BEAM | +5.700 | +5.900 | 5 | 13 | 130.3 | 0.6 | 4.7 | 5818.2 | mc-188 | 5818.2 | 4.46953 | 0.0157689 | 123.786
BEAM | +5.700 | +5.900 | 5 | 13 | 129.2 | 0.6 | 4.5 | 5768.2 | mc-187 | 5768.2 | 4.43112 | 0.0156327 | 122.717
BEAM | +5.700 | +5.900 | 5 | 13 | 198.7 | 0.9 | 7 | 8870 | mc-186 | 8870 | 6.81392 | 0.024169 | 189.726
BEAM | +48.500 | +48.700 | 7 | 3 | 59.7 | 0.3 | 2.1 | 2664.7 | me-75 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +57.820 | +58.020 | 8 | 3 | 59.7 | 0.3 | 2.1 | 2664.7 | mf-131 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +50.953 | +51.153 | 8 | 3 | 47.4 | 0.2 | 1.6 | 2115.9 | mf-130 | 2115.9 | 1.62543 | 0.00562987 | 44.1945
BEAM | +46.813 | +47.013 | 7 | 3 | 47.4 | 0.2 | 1.6 | 2115.9 | me-74 | 2115.9 | 1.62543 | 0.00562987 | 44.1945
BEAM | +41.606 | +41.806 | 7 | 3 | 47.4 | 0.2 | 1.6 | 2115.9 | me-74 | 2115.9 | 1.62543 | 0.00562987 | 44.1945
BEAM | +70.450 | +70.650 | 8 | 7 | 156 | 0.6 | 5.5 | 6964.7 | mf-127 | 6964.7 | 5.35027 | 0.0188225 | 147.756
2 x BEAM | +70.450 | +70.650 | 8 | 7 | 44 | 0.2 | 1.5 | 1965.6 | mf-125 | 1965.55 | 1.50993 | 0.0051925 | 40.7611
4 x BEAM | +70.450 | +70.650 | 8 | 7 | 44 | 0.2 | 1.5 | 1965.6 | mf-124 | 1965.55 | 1.50993 | 0.00519376 | 40.771
2 x BEAM | +70.450 | +70.650 | 8 | 7 | 19.4 | 0.1 | 0.6 | 865.5 | mf-123 | 865.55 | 0.664914 | 0.00219648 | 17.2424
4 x BEAM | +70.450 | +70.650 | 8 | 7 | 19.4 | 0.1 | 0.6 | 866.4 | mf-139 | 866.4 | 0.665567 | 0.00219177 | 17.2054
BEAM | +70.450 | +70.650 | 8 | 7 | 75.4 | 0.3 | 2.6 | 3366.4 | mf-121 | 3366.4 | 2.58606 | 0.00900377 | 70.6796
2 x BEAM | +70.450 | +70.650 | 8 | 7 | 19.4 | 0.1 | 0.6 | 865.5 | mf-123 | 865.549 | 0.664913 | 0.00219648 | 17.2423
BEAM | +70.450 | +70.650 | 8 | 7 | 37.3 | 0.2 | 1.3 | 1665.6 | mf-122 | 1665.55 | 1.27947 | 0.00437821 | 34.3689
2 x BEAM | +70.450 | +70.650 | 8 | 7 | 37.3 | 0.2 | 1.3 | 1665.6 | mf-120 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
3 x BEAM | +70.450 | +70.650 | 8 | 7 | 37.3 | 0.2 | 1.3 | 1665.6 | mf-122 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +70.450 | +70.650 | 8 | 7 | 117.9 | 0.5 | 4.1 | 5265.5 | mf-117 | 5265.55 | 4.04499 | 0.0141875 | 111.372
3 x BEAM | +70.450 | +70.650 | 8 | 7 | 117.9 | 0.5 | 4.1 | 5265.5 | mf-117 | 5265.55 | 4.04499 | 0.0141856 | 111.357
BEAM | +70.450 | +70.650 | 8 | 7 | 156 | 0.6 | 5.5 | 6964.7 | mf-116 | 6964.7 | 5.35027 | 0.0188225 | 147.756
2 x BEAM | +70.450 | +70.650 | 8 | 7 | 37.3 | 0.2 | 1.3 | 1665.5 | mf-122 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
2 x BEAM | +66.050 | +66.250 | 8 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | mf-123 | 865.55 | 0.664914 | 0.00219648 | 17.2424
4 x BEAM | +66.050 | +66.250 | 8 | 14 | 19.4 | 0.1 | 0.6 | 866.4 | mf-139 | 866.4 | 0.665567 | 0.00219177 | 17.2054
BEAM | +66.050 | +66.250 | 8 | 14 | 75.4 | 0.3 | 2.6 | 3366.4 | mf-121 | 3366.4 | 2.58606 | 0.00900377 | 70.6796
2 x BEAM | +66.050 | +66.250 | 8 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | mf-123 | 865.549 | 0.664913 | 0.00219648 | 17.2423
BEAM | +66.050 | +66.250 | 8 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | mf-122 | 1665.55 | 1.27947 | 0.00437821 | 34.3689
6 x BEAM | +66.050 | +66.250 | 8 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | mf-122 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +66.050 | +66.250 | 8 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | mf-117 | 5265.55 | 4.04499 | 0.0141875 | 111.372
3 x BEAM | +66.050 | +66.250 | 8 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | mf-117 | 5265.55 | 4.04499 | 0.0141856 | 111.357
BEAM | +66.050 | +66.250 | 8 | 14 | 156 | 0.6 | 5.5 | 6964.7 | mf-116 | 6964.7 | 5.35027 | 0.0188225 | 147.756
3 x BEAM | +66.050 | +66.250 | 8 | 14 | 37.3 | 0.2 | 1.3 | 1665.5 | mf-122 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +63.250 | +63.450 | 8 | 14 | 156 | 0.6 | 5.5 | 6964.7 | mf-128 | 6964.7 | 5.35027 | 0.0188225 | 147.756
BEAM | +63.250 | +63.450 | 8 | 14 | 44 | 0.2 | 1.5 | 1961.6 | mf-126 | 1961.55 | 1.50686 | 0.00518645 | 40.7137
4 x BEAM | +63.250 | +63.450 | 8 | 14 | 44 | 0.2 | 1.5 | 1961.6 | mf-119 | 1961.55 | 1.50686 | 0.00518771 | 40.7235
BEAM | +63.250 | +63.450 | 8 | 14 | 44 | 0.2 | 1.5 | 1965.6 | mf-125 | 1965.55 | 1.50993 | 0.0051925 | 40.7611
2 x BEAM | +63.250 | +63.450 | 8 | 14 | 37.2 | 0.1 | 1.3 | 1659.4 | mf-114 | 1659.35 | 1.27471 | 0.00435675 | 34.2005
BEAM | +63.250 | +63.450 | 8 | 14 | 37.1 | 0.1 | 1.3 | 1655.4 | mf-115 | 1655.35 | 1.27164 | 0.0043507 | 34.153
BEAM | +55.105 | +55.305 | 8 | 14 | 156 | 0.6 | 5.5 | 6964.7 | mf-127 | 6964.7 | 5.35027 | 0.0188225 | 147.756
2 x BEAM | +55.105 | +55.305 | 8 | 14 | 44 | 0.2 | 1.5 | 1965.6 | mf-125 | 1965.55 | 1.50993 | 0.0051925 | 40.7611
4 x BEAM | +55.105 | +55.305 | 8 | 14 | 44 | 0.2 | 1.5 | 1965.6 | mf-124 | 1965.55 | 1.50993 | 0.00519376 | 40.771
2 x BEAM | +55.105 | +55.305 | 8 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | mf-123 | 865.55 | 0.664914 | 0.00219648 | 17.2424
3 x BEAM | +55.105 | +55.305 | 8 | 14 | 19.4 | 0.1 | 0.6 | 866.4 | mf-139 | 866.4 | 0.665567 | 0.00219177 | 17.2054
BEAM | +55.105 | +55.305 | 8 | 14 | 75.4 | 0.3 | 2.6 | 3366.4 | mf-121 | 3366.4 | 2.58606 | 0.00900377 | 70.6796
BEAM | +55.105 | +55.305 | 8 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | mf-111 | 1665.55 | 1.27947 | 0.00437821 | 34.3689
4 x BEAM | +55.105 | +55.305 | 8 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | mf-122 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +55.105 | +55.305 | 8 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | mf-123 | 865.549 | 0.664913 | 0.00219648 | 17.2423
BEAM | +55.105 | +55.305 | 8 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | mf-118 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +55.105 | +55.305 | 8 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | mf-110 | 5265.55 | 4.04499 | 0.0141875 | 111.372
2 x BEAM | +55.105 | +55.305 | 8 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | mf-117 | 5265.55 | 4.04499 | 0.0141856 | 111.357
BEAM | +55.105 | +55.305 | 8 | 14 | 156 | 0.6 | 5.5 | 6964.7 | mf-116 | 6964.7 | 5.35027 | 0.0188225 | 147.756
BEAM | +55.105 | +55.305 | 8 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | mf-109 | 5265.55 | 4.04499 | 0.0141856 | 111.357
2 x BEAM | +55.105 | +55.305 | 8 | 14 | 37.3 | 0.2 | 1.3 | 1665.5 | mf-122 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +44.375 | +44.575 | 7 | 14 | 21.8 | 0.1 | 0.8 | 968.1 | me-73 | 968.1 | 0.743693 | 0.00263788 | 20.7073
BEAM | +44.375 | +44.575 | 7 | 14 | 25.1 | 0.1 | 0.8 | 1120.4 | me-72 | 1120.35 | 0.860651 | 0.00297526 | 23.3558
BEAM | +44.375 | +44.575 | 7 | 14 | 25 | 0.1 | 0.8 | 1116.5 | me-70 | 1116.35 | 0.857578 | 0.00296921 | 23.3083
2 x BEAM | +70.450 | +70.650 | 8 | 7 | 25.1 | 0.1 | 0.8 | 1120.4 | mf-144 | 1120.35 | 0.860651 | 0.00297526 | 23.3558
BEAM | +70.450 | +70.650 | 8 | 7 | 21.8 | 0.1 | 0.8 | 968.1 | mf-108 | 968.1 | 0.743693 | 0.00263788 | 20.7073
BEAM | +70.450 | +70.650 | 8 | 7 | 25 | 0.1 | 0.8 | 1116.5 | mf-143 | 1116.35 | 0.857578 | 0.00296921 | 23.3083
BEAM | +55.105 | +55.305 | 8 | 14 | 21.8 | 0.1 | 0.8 | 968.1 | mf-108 | 968.1 | 0.743693 | 0.00263788 | 20.7073
BEAM | +55.105 | +55.305 | 8 | 14 | 25.1 | 0.1 | 0.8 | 1120.4 | mf-144 | 1120.35 | 0.860651 | 0.00297526 | 23.3558
BEAM | +55.105 | +55.305 | 8 | 14 | 25 | 0.1 | 0.8 | 1116.5 | mf-143 | 1116.35 | 0.857578 | 0.00296921 | 23.3083
BEAM | +63.250 | +63.450 | 8 | 14 | 21.8 | 0.1 | 0.8 | 968.1 | mf-108 | 968.1 | 0.743693 | 0.00263788 | 20.7073
BEAM | +63.250 | +63.450 | 8 | 14 | 25.1 | 0.1 | 0.8 | 1120.4 | mf-142 | 1120.35 | 0.860651 | 0.0029775 | 23.3733
BEAM | +63.250 | +63.450 | 8 | 14 | 25 | 0.1 | 0.8 | 1116.5 | mf-107 | 1116.35 | 0.857578 | 0.00297131 | 23.3248
BEAM | +38.838 | +39.038 | 7 | 14 | 21.8 | 0.1 | 0.8 | 968.1 | me-73 | 968.1 | 0.743693 | 0.00263788 | 20.7073
BEAM | +38.838 | +39.038 | 7 | 14 | 25.1 | 0.1 | 0.8 | 1120.4 | me-72 | 1120.35 | 0.860651 | 0.00297526 | 23.3558
BEAM | +38.838 | +39.038 | 7 | 14 | 25 | 0.1 | 0.8 | 1116.5 | me-71 | 1116.35 | 0.857578 | 0.00296921 | 23.3083
3 x BEAM | +48.500 | +48.700 | 7 | 14 | 55.2 | 0.2 | 1.9 | 2464.7 | me-69 | 2464.7 | 1.89338 | 0.00656087 | 51.5028
2 x BEAM | +48.500 | +48.700 | 7 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | me-88 | 865.55 | 0.664914 | 0.00219648 | 17.2424
4 x BEAM | +48.500 | +48.700 | 7 | 14 | 19.4 | 0.1 | 0.6 | 866.4 | me-83 | 866.4 | 0.665567 | 0.00219177 | 17.2054
BEAM | +48.500 | +48.700 | 7 | 14 | 75.4 | 0.3 | 2.6 | 3366.4 | me-68 | 3366.4 | 2.58606 | 0.00900377 | 70.6796
2 x BEAM | +48.500 | +48.700 | 7 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | me-88 | 865.549 | 0.664913 | 0.00219648 | 17.2423
BEAM | +48.500 | +48.700 | 7 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | me-89 | 1665.55 | 1.27947 | 0.00437821 | 34.3689
BEAM | +48.500 | +48.700 | 7 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | me-81 | 5265.55 | 4.04499 | 0.0141875 | 111.372
3 x BEAM | +48.500 | +48.700 | 7 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | me-81 | 5265.55 | 4.04499 | 0.0141856 | 111.357
BEAM | +48.500 | +48.700 | 7 | 14 | 156 | 0.6 | 5.5 | 6964.7 | me-67 | 6964.7 | 5.35027 | 0.0188225 | 147.756
2 x BEAM | +48.500 | +48.700 | 7 | 14 | 37.3 | 0.2 | 1.3 | 1665.5 | me-89 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +66.050 | +66.250 | 8 | 14 | 13.7 | 0.1 | 0.3 | 616.4 | mf-138 | 616.4 | 0.473517 | 0.00151057 | 11.858
2 x BEAM | +66.050 | +66.250 | 8 | 14 | 44 | 0.2 | 1.5 | 1964.7 | mf-106 | 1964.7 | 1.50928 | 0.00519847 | 40.808
BEAM | +44.375 | +44.575 | 7 | 14 | 156 | 0.6 | 5.5 | 6964.7 | me-66 | 6964.7 | 5.35027 | 0.0188225 | 147.756
2 x BEAM | +44.375 | +44.575 | 7 | 14 | 44 | 0.2 | 1.5 | 1965.6 | me-65 | 1965.55 | 1.50993 | 0.0051925 | 40.7611
4 x BEAM | +44.375 | +44.575 | 7 | 14 | 44 | 0.2 | 1.5 | 1965.6 | me-90 | 1965.55 | 1.50993 | 0.00519376 | 40.771
2 x BEAM | +44.375 | +44.575 | 7 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | me-88 | 865.55 | 0.664914 | 0.00219648 | 17.2424
4 x BEAM | +44.375 | +44.575 | 7 | 14 | 19.4 | 0.1 | 0.6 | 866.4 | me-83 | 866.4 | 0.665567 | 0.00219177 | 17.2054
BEAM | +44.375 | +44.575 | 7 | 14 | 75.4 | 0.3 | 2.6 | 3366.4 | me-68 | 3366.4 | 2.58606 | 0.00900377 | 70.6796
2 x BEAM | +44.375 | +44.575 | 7 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | me-88 | 865.549 | 0.664913 | 0.00219648 | 17.2423
BEAM | +44.375 | +44.575 | 7 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | me-89 | 1665.55 | 1.27947 | 0.00437821 | 34.3689
2 x BEAM | +44.375 | +44.575 | 7 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | me-64 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
3 x BEAM | +44.375 | +44.575 | 7 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | me-89 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +44.375 | +44.575 | 7 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | me-81 | 5265.55 | 4.04499 | 0.0141875 | 111.372
3 x BEAM | +44.375 | +44.575 | 7 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | me-81 | 5265.55 | 4.04499 | 0.0141856 | 111.357
BEAM | +44.375 | +44.575 | 7 | 14 | 156 | 0.6 | 5.5 | 6964.7 | me-67 | 6964.7 | 5.35027 | 0.0188225 | 147.756
2 x BEAM | +44.375 | +44.575 | 7 | 14 | 37.3 | 0.2 | 1.3 | 1665.5 | me-89 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +36.070 | +36.270 | 6 | 14 | 21.4 | 0.1 | 0.8 | 956.4 | md-64 | 956.4 | 0.734705 | 0.002606 | 20.4571
BEAM | +36.070 | +36.270 | 6 | 14 | 25.1 | 0.1 | 0.8 | 1120.4 | md-63 | 1120.35 | 0.860651 | 0.00297526 | 23.3558
BEAM | +36.070 | +36.270 | 6 | 14 | 25 | 0.1 | 0.8 | 1116.5 | md-62 | 1116.35 | 0.857578 | 0.00296921 | 23.3083
BEAM | +36.070 | +36.270 | 6 | 14 | 156 | 0.6 | 5.5 | 6964.7 | md-61 | 6964.7 | 5.35027 | 0.0188225 | 147.756
2 x BEAM | +36.070 | +36.270 | 6 | 14 | 44 | 0.2 | 1.5 | 1965.6 | md-60 | 1965.55 | 1.50993 | 0.0051925 | 40.7611
4 x BEAM | +36.070 | +36.270 | 6 | 14 | 44 | 0.2 | 1.5 | 1965.6 | md-59 | 1965.55 | 1.50993 | 0.00519376 | 40.771
2 x BEAM | +36.070 | +36.270 | 6 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | md-58 | 865.55 | 0.664914 | 0.00219648 | 17.2424
4 x BEAM | +36.070 | +36.270 | 6 | 14 | 19.4 | 0.1 | 0.6 | 866.4 | md-56 | 866.4 | 0.665567 | 0.00219177 | 17.2054
BEAM | +36.070 | +36.270 | 6 | 14 | 75.4 | 0.3 | 2.6 | 3366.4 | md-55 | 3366.4 | 2.58606 | 0.00900377 | 70.6796
2 x BEAM | +36.070 | +36.270 | 6 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | md-58 | 865.549 | 0.664913 | 0.00219648 | 17.2423
BEAM | +36.070 | +36.270 | 6 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | md-57 | 1665.55 | 1.27947 | 0.00437821 | 34.3689
2 x BEAM | +36.070 | +36.270 | 6 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | md-54 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
3 x BEAM | +36.070 | +36.270 | 6 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | md-57 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +36.070 | +36.270 | 6 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | md-52 | 5265.55 | 4.04499 | 0.0141875 | 111.372
2 x BEAM | +36.070 | +36.270 | 6 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | md-51 | 5265.55 | 4.04499 | 0.0141856 | 111.357
BEAM | +36.070 | +36.270 | 6 | 14 | 156 | 0.6 | 5.5 | 6964.7 | md-50 | 6964.7 | 5.35027 | 0.0187936 | 147.53
BEAM | +36.070 | +36.270 | 6 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | md-49 | 5265.55 | 4.04499 | 0.0141856 | 111.357
2 x BEAM | +36.070 | +36.270 | 6 | 14 | 37.3 | 0.2 | 1.3 | 1665.5 | md-57 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +28.880 | +29.080 | 6 | 14 | 156 | 0.6 | 5.5 | 6964.7 | md-61 | 6964.7 | 5.35027 | 0.0188225 | 147.756
2 x BEAM | +28.880 | +29.080 | 6 | 14 | 44 | 0.2 | 1.5 | 1965.6 | md-60 | 1965.55 | 1.50993 | 0.0051925 | 40.7611
4 x BEAM | +28.880 | +29.080 | 6 | 14 | 44 | 0.2 | 1.5 | 1965.6 | md-59 | 1965.55 | 1.50993 | 0.00519376 | 40.771
2 x BEAM | +28.880 | +29.080 | 6 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | md-58 | 865.55 | 0.664914 | 0.00219648 | 17.2424
4 x BEAM | +28.880 | +29.080 | 6 | 14 | 19.4 | 0.1 | 0.6 | 866.4 | md-56 | 866.4 | 0.665567 | 0.00219177 | 17.2054
BEAM | +28.880 | +29.080 | 6 | 14 | 75.4 | 0.3 | 2.6 | 3366.4 | md-55 | 3366.4 | 2.58606 | 0.00900377 | 70.6796
2 x BEAM | +28.880 | +29.080 | 6 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | md-58 | 865.549 | 0.664913 | 0.00219648 | 17.2423
BEAM | +28.880 | +29.080 | 6 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | md-57 | 1665.55 | 1.27947 | 0.00437821 | 34.3689
4 x BEAM | +28.880 | +29.080 | 6 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | md-57 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +28.880 | +29.080 | 6 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | md-53 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +28.880 | +29.080 | 6 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | md-51 | 5265.55 | 4.04499 | 0.0141875 | 111.372
2 x BEAM | +28.880 | +29.080 | 6 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | md-51 | 5265.55 | 4.04499 | 0.0141856 | 111.357
BEAM | +28.880 | +29.080 | 6 | 14 | 156 | 0.6 | 5.5 | 6964.7 | md-48 | 6964.7 | 5.35027 | 0.0188225 | 147.756
BEAM | +28.880 | +29.080 | 6 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | md-47 | 5265.55 | 4.04499 | 0.0141856 | 111.357
2 x BEAM | +28.880 | +29.080 | 6 | 14 | 37.3 | 0.2 | 1.3 | 1665.5 | md-57 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +28.880 | +29.080 | 6 | 14 | 21.4 | 0.1 | 0.8 | 956.4 | md-64 | 956.4 | 0.734705 | 0.002606 | 20.4571
BEAM | +28.880 | +29.080 | 6 | 14 | 25.1 | 0.1 | 0.8 | 1120.4 | md-46 | 1120.35 | 0.860651 | 0.00297526 | 23.3558
BEAM | +28.880 | +29.080 | 6 | 14 | 25 | 0.1 | 0.8 | 1116.5 | md-62 | 1116.35 | 0.857578 | 0.00296921 | 23.3083
3 x BEAM | +11.000 | +11.200 | 5 | 5 | 26 | 0.1 | 0.8 | 1161.6 | mc-252 | 1161.55 | 0.892301 | 0.00300875 | 23.6187
3 x BEAM | +10.390 | +10.590 | 5 | 14 | 21.6 | 0.1 | 0.6 | 964.7 | mc-214 | 964.7 | 0.741081 | 0.00247367 | 19.4183
2 x BEAM | +17.850 | +18.050 | 4 | 14 | 97.8 | 0.3 | 3.5 | 4364.7 | mb-88 | 4364.7 | 3.35295 | 0.011738 | 92.1432
BEAM | +17.850 | +18.050 | 4 | 14 | 25.1 | 0.1 | 0.8 | 1120.4 | mb-87 | 1120.35 | 0.860651 | 0.00290226 | 22.7828
BEAM | +21.260 | +21.460 | 4 | 14 | 21.4 | 0.1 | 0.8 | 956.4 | mb-83 | 956.4 | 0.734705 | 0.002606 | 20.4571
BEAM | +21.260 | +21.460 | 4 | 3 | 59.7 | 0.3 | 2.1 | 2664.7 | mb-82 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +15.500 | +15.700 | 4 | 23 | 59.7 | 0.3 | 2.1 | 2664.7 | mb-85 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +21.260 | +21.460 | 4 | 14 | 25.1 | 0.1 | 0.8 | 1120.4 | mb-79 | 1120.35 | 0.860651 | 0.00297526 | 23.3558
BEAM | +21.260 | +21.460 | 4 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | mb-77 | 865.549 | 0.664913 | 0.00219648 | 17.2423
BEAM | +21.260 | +21.460 | 4 | 14 | 25 | 0.1 | 0.8 | 1116.5 | mb-75 | 1116.35 | 0.857578 | 0.00296921 | 23.3083
BEAM | +5.500 | +5.700 | 5 | 23 | 97.8 | 0.3 | 3.5 | 4364 | mc-229 | 4363.95 | 3.35238 | 0.0117311 | 92.0891
3 x BEAM | +5.500 | +5.700 | 5 | 23 | 88.8 | 0.3 | 3.1 | 3964.1 | mc-231 | 3964.1 | 3.04521 | 0.0106367 | 83.4983
4 x BEAM | +2.550 | +2.750 | 5 | 7 | 88.8 | 0.3 | 3.1 | 3964.7 | mc-228 | 3964.7 | 3.04568 | 0.0106481 | 83.5873
BEAM | +2.550 | +2.750 | 5 | 7 | 88.8 | 0.3 | 3.1 | 3964.7 | mc-208 | 3964.7 | 3.04568 | 0.0106481 | 83.5873
2 x BEAM | +15.500 | +15.700 | 5 | 23 | 41.7 | 0.2 | 1.5 | 1863.6 | mc-253 | 1863.55 | 1.43158 | 0.00491583 | 38.5893
7 x BEAM | +8.404 | +8.604 | 5 | 3 | 36.2 | 0.1 | 1.3 | 1615.9 | mc-212 | 1615.9 | 1.24133 | 0.00426747 | 33.4996
BEAM | +5.300 | +5.500 | 5 | 5 | 22.7 | 0.1 | 0.8 | 1012.3 | mc-183 | 1012.25 | 0.777609 | 0.00275818 | 21.6517
BEAM | +21.260 | +21.460 | 4 | 7 | 37.3 | 0.2 | 1.3 | 1665.6 | mb-74 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
2 x BEAM | +21.260 | +21.460 | 4 | 7 | 19.4 | 0.1 | 0.6 | 865.5 | mb-77 | 865.55 | 0.664914 | 0.00219648 | 17.2424
4 x BEAM | +21.260 | +21.460 | 4 | 7 | 19.4 | 0.1 | 0.6 | 866.4 | mb-68 | 866.4 | 0.665567 | 0.00219177 | 17.2054
BEAM | +21.260 | +21.460 | 4 | 7 | 75.4 | 0.3 | 2.6 | 3366.4 | mb-67 | 3366.4 | 2.58606 | 0.00900377 | 70.6796
BEAM | +21.260 | +21.460 | 4 | 7 | 37.3 | 0.2 | 1.3 | 1665.6 | mb-66 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
3 x BEAM | +21.260 | +21.460 | 4 | 7 | 37.3 | 0.2 | 1.3 | 1665.6 | mb-78 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +21.260 | +21.460 | 4 | 7 | 19.4 | 0.1 | 0.6 | 865.5 | mb-73 | 865.549 | 0.664913 | 0.00219648 | 17.2423
BEAM | +21.260 | +21.460 | 4 | 7 | 117.9 | 0.5 | 4.1 | 5265.5 | mb-65 | 5265.55 | 4.04499 | 0.0141856 | 111.357
2 x BEAM | +21.260 | +21.460 | 4 | 7 | 117.9 | 0.5 | 4.1 | 5265.5 | mb-64 | 5265.55 | 4.04499 | 0.0141856 | 111.357
BEAM | +21.260 | +21.460 | 4 | 7 | 156 | 0.6 | 5.5 | 6964.7 | mb-62 | 6964.7 | 5.35027 | 0.0188225 | 147.756
BEAM | +21.260 | +21.460 | 4 | 7 | 117.9 | 0.5 | 4.1 | 5265.5 | mb-61 | 5265.55 | 4.04499 | 0.0141856 | 111.357
2 x BEAM | +21.260 | +21.460 | 4 | 7 | 37.3 | 0.2 | 1.3 | 1665.5 | mb-78 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +21.260 | +21.460 | 4 | 7 | 37.3 | 0.2 | 1.3 | 1665.6 | mb-72 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
2 x BEAM | +17.850 | +18.050 | 4 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | mb-69 | 865.55 | 0.664914 | 0.00219648 | 17.2424
4 x BEAM | +17.850 | +18.050 | 4 | 14 | 19.4 | 0.1 | 0.6 | 866.4 | mb-68 | 866.4 | 0.665567 | 0.00219177 | 17.2054
BEAM | +17.850 | +18.050 | 4 | 14 | 75.4 | 0.3 | 2.6 | 3366.4 | mb-67 | 3366.4 | 2.58606 | 0.00900377 | 70.6796
2 x BEAM | +17.850 | +18.050 | 4 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | mb-77 | 865.549 | 0.664913 | 0.00219648 | 17.2423
BEAM | +17.850 | +18.050 | 4 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | mb-71 | 1665.55 | 1.27947 | 0.00437821 | 34.3689
2 x BEAM | +17.850 | +18.050 | 4 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | mb-70 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +17.850 | +18.050 | 4 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | mb-71 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +17.850 | +18.050 | 4 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | mb-65 | 5265.55 | 4.04499 | 0.0141875 | 111.372
2 x BEAM | +17.850 | +18.050 | 4 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | mb-65 | 5265.55 | 4.04499 | 0.0141856 | 111.357
BEAM | +17.850 | +18.050 | 4 | 14 | 156 | 0.6 | 5.5 | 6964.7 | mb-60 | 6964.7 | 5.35027 | 0.0188225 | 147.756
BEAM | +17.850 | +18.050 | 4 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | mb-63 | 5265.55 | 4.04499 | 0.0141856 | 111.357
2 x BEAM | +17.850 | +18.050 | 4 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | mb-78 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
2 x BEAM | +17.850 | +18.050 | 4 | 14 | 37.3 | 0.2 | 1.3 | 1665.5 | mb-78 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +11.000 | +11.200 | 5 | 5 | 77.5 | 0.3 | 2.7 | 3460 | mc-181 | 3460 | 2.65797 | 0.00942781 | 74.0083
BEAM | +5.300 | +5.500 | 5 | 5 | 22.7 | 0.1 | 0.8 | 1011.6 | mc-251 | 1011.55 | 0.777071 | 0.00260858 | 20.4773
BEAM | +5.300 | +5.500 | 5 | 5 | 24.6 | 0.1 | 0.8 | 1098.4 | mc-180 | 1098.35 | 0.84375 | 0.00292016 | 22.9233
BEAM | +5.300 | +5.500 | 5 | 5 | 39.2 | 0.2 | 1.3 | 1751.4 | mc-242 | 1751.4 | 1.34542 | 0.00461264 | 36.2092
BEAM | +5.300 | +5.500 | 5 | 5 | 33.9 | 0.1 | 1.3 | 1514.6 | mc-219 | 1514.7 | 1.16359 | 0.00397231 | 31.1826
BEAM | +15.500 | +15.700 | 5 | 23 | 52.5 | 0.2 | 1.7 | 2339.6 | mc-179 | 2339.55 | 1.79724 | 0.00621283 | 48.7708
BEAM | +15.500 | +15.700 | 5 | 23 | 52.5 | 0.2 | 1.7 | 2339.6 | mc-250 | 2339.55 | 1.79724 | 0.00621283 | 48.7708
BEAM | +15.500 | +15.700 | 5 | 23 | 52.5 | 0.2 | 1.7 | 2339.6 | mc-198 | 2339.55 | 1.79724 | 0.00621283 | 48.7708
BEAM | +15.500 | +15.700 | 5 | 23 | 52.5 | 0.2 | 1.7 | 2339.6 | mc-178 | 2339.55 | 1.79724 | 0.00621283 | 48.7708
BEAM | +15.500 | +15.700 | 5 | 23 | 144.8 | 0.6 | 5.2 | 6464.7 | mc-176 | 6464.7 | 4.96617 | 0.0174601 | 137.062
2 x BEAM | +11.000 | +11.200 | 5 | 5 | 58.1 | 0.2 | 1.9 | 2594.7 | mc-218 | 2594.7 | 1.99324 | 0.00691509 | 54.2835
7 x BEAM | +12.300 | +12.500 | 5 | 7 | 97.8 | 0.3 | 3.5 | 4364.7 | mc-203 | 4364.7 | 3.35295 | 0.011738 | 92.1432
BEAM | +12.300 | +12.500 | 5 | 7 | 97.8 | 0.3 | 3.5 | 4364.7 | mc-175 | 4364.7 | 3.35295 | 0.011738 | 92.1432
2 x BEAM | +10.390 | +10.590 | 3 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | ma-96 | 865.55 | 0.664914 | 0.00219648 | 17.2424
BEAM | +10.390 | +10.590 | 3 | 23 | 19.4 | 0.1 | 0.6 | 866.4 | ma-92 | 866.4 | 0.665567 | 0.00219177 | 17.2054
3 x BEAM | +10.390 | +10.590 | 3 | 14 | 19.4 | 0.1 | 0.6 | 866.4 | ma-92 | 866.4 | 0.665567 | 0.00219177 | 17.2054
BEAM | +10.390 | +10.590 | 3 | 14 | 75.4 | 0.3 | 2.6 | 3366.4 | ma-90 | 3366.4 | 2.58606 | 0.00900377 | 70.6796
2 x BEAM | +10.390 | +10.590 | 3 | 14 | 19.4 | 0.1 | 0.6 | 865.5 | ma-96 | 865.549 | 0.664913 | 0.00219648 | 17.2423
BEAM | +10.390 | +10.590 | 3 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | ma-95 | 1665.55 | 1.27947 | 0.00437821 | 34.3689
5 x BEAM | +10.390 | +10.590 | 3 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | ma-95 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +10.390 | +10.590 | 3 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | ma-89 | 5265.55 | 4.04499 | 0.0141875 | 111.372
BEAM | +10.390 | +10.590 | 3 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | ma-89 | 5265.55 | 4.04499 | 0.0141856 | 111.357
BEAM | +10.390 | +10.590 | 3 | 14 | 156 | 0.6 | 5.5 | 6964.7 | ma-87 | 6964.7 | 5.35027 | 0.0188225 | 147.756
BEAM | +10.390 | +10.590 | 3 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | ma-86 | 5265.55 | 4.04499 | 0.0141856 | 111.357
BEAM | +10.390 | +10.590 | 3 | 14 | 117.9 | 0.5 | 4.1 | 5265.5 | ma-85 | 5265.55 | 4.04499 | 0.0141856 | 111.357
2 x BEAM | +10.390 | +10.590 | 3 | 14 | 37.3 | 0.2 | 1.3 | 1665.5 | ma-95 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +10.390 | +10.590 | 3 | 14 | 59.7 | 0.3 | 2.1 | 2664.7 | ma-84 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
2 x BEAM | +10.390 | +10.590 | 3 | 14 | 59.7 | 0.3 | 2.1 | 2664.7 | ma-75 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +10.390 | +10.590 | 3 | 14 | 59.7 | 0.3 | 2.1 | 2664.7 | ma-83 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
4 x POST | +5.712 | +8.150 | 5 | 3 | 54.6 | 0 | 1.9 | 2438 | mc-174 | 2438 | 1.87287 | 0.00664306 | 52.148
4 x BEAM | +5.500 | +5.700 | 3 | 23 | 19.4 | 0.1 | 0.6 | 866.4 | ma-92 | 866.4 | 0.665567 | 0.00219177 | 17.2054
BEAM | +5.500 | +5.700 | 3 | 23 | 75.4 | 0.3 | 2.6 | 3366.4 | ma-90 | 3366.4 | 2.58606 | 0.00900377 | 70.6796
BEAM | +66.050 | +66.250 | 8 | 14 | 39.6 | 0.2 | 1.5 | 1766.4 | mf-137 | 1766.4 | 1.35695 | 0.00464409 | 36.4561
2 x BEAM | +66.050 | +66.250 | 8 | 14 | 44 | 0.2 | 1.5 | 1964.7 | mf-105 | 1964.7 | 1.50928 | 0.00519847 | 40.808
BEAM | +48.500 | +48.700 | 7 | 14 | 37.3 | 0.2 | 1.3 | 1665.6 | me-63 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +17.850 | +18.050 | 4 | 14 | 25 | 0.1 | 0.8 | 1116.5 | mb-80 | 1116.35 | 0.857578 | 0.00296921 | 23.3083
3 x BEAM | +17.850 | +18.050 | 4 | 14 | 19.4 | 0.1 | 0.6 | 865.6 | mb-77 | 865.55 | 0.664914 | 0.00219648 | 17.2424
BEAM | +17.850 | +18.050 | 4 | 14 | 97.8 | 0.3 | 3.5 | 4364.7 | mb-59 | 4364.7 | 3.35295 | 0.011738 | 92.1432
3 x BEAM | +15.500 | +15.700 | 5 | 23 | 44.6 | 0.2 | 1.5 | 1991.6 | mc-197 | 1991.55 | 1.52991 | 0.0052646 | 41.3271
BEAM | +12.300 | +12.500 | 5 | 7 | 91.7 | 0.3 | 3.2 | 4094.7 | mc-217 | 4094.7 | 3.14554 | 0.0110023 | 86.368
9 x BEAM | +12.300 | +12.500 | 5 | 7 | 72.7 | 0.3 | 2.5 | 3244.7 | mc-205 | 3244.7 | 2.49257 | 0.00868621 | 68.1868
BEAM | +5.500 | +5.700 | 3 | 23 | 44 | 0.2 | 1.5 | 1965.6 | ma-72 | 1965.55 | 1.50993 | 0.00519376 | 40.771
3 x BEAM | +5.500 | +5.700 | 3 | 23 | 44 | 0.2 | 1.5 | 1965.6 | ma-94 | 1965.55 | 1.50993 | 0.00519376 | 40.771
2 x BEAM | +5.500 | +5.700 | 3 | 23 | 19.4 | 0.1 | 0.6 | 865.5 | ma-96 | 865.549 | 0.664913 | 0.00219648 | 17.2423
2 x BEAM | +5.500 | +5.700 | 3 | 23 | 19.4 | 0.1 | 0.6 | 865.5 | ma-96 | 865.55 | 0.664914 | 0.00219648 | 17.2424
6 x BEAM | +5.500 | +5.700 | 3 | 23 | 37.3 | 0.2 | 1.3 | 1665.6 | ma-95 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +5.500 | +5.700 | 5 | 23 | 45.1 | 0.2 | 1.6 | 2011.7 | mc-241 | 2011.7 | 1.54538 | 0.00532653 | 41.8133
2 x BEAM | +5.500 | +5.700 | 5 | 23 | 45.1 | 0.2 | 1.6 | 2011.7 | mc-216 | 2011.7 | 1.54538 | 0.00532653 | 41.8133
BEAM | +5.500 | +5.700 | 5 | 23 | 97.8 | 0.3 | 3.5 | 4364 | mc-215 | 4363.95 | 3.35238 | 0.0117311 | 92.0891
2 x BEAM | +5.500 | +5.700 | 5 | 23 | 31.7 | 0.1 | 1.1 | 1417.7 | mc-200 | 1417.7 | 1.08908 | 0.003708 | 29.1078
BEAM | +5.500 | +5.700 | 5 | 23 | 97.8 | 0.3 | 3.5 | 4364.7 | mc-240 | 4364.7 | 3.35295 | 0.011738 | 92.1432
2 x BEAM | +5.500 | +5.700 | 5 | 23 | 97.8 | 0.3 | 3.5 | 4364.7 | mc-203 | 4364.7 | 3.35295 | 0.011738 | 92.1432
2 x BEAM | +5.500 | +5.700 | 5 | 23 | 97.8 | 0.3 | 3.5 | 4364.7 | mc-239 | 4364.7 | 3.35295 | 0.011738 | 92.1432
BEAM | +2.550 | +2.750 | 5 | 7 | 63.9 | 0.3 | 2.2 | 2856.7 | mc-173 | 2856.7 | 2.19451 | 0.00771132 | 60.5338
BEAM | +10.390 | +10.590 | 3 | 14 | 97.8 | 0.3 | 3.5 | 4364.7 | ma-88 | 4364.7 | 3.35295 | 0.011738 | 92.1432
BEAM | +10.390 | +10.590 | 3 | 14 | 97.8 | 0.3 | 3.5 | 4364.7 | ma-77 | 4364.7 | 3.35295 | 0.011738 | 92.1432
BEAM | +10.390 | +10.590 | 3 | 14 | 97.8 | 0.3 | 3.5 | 4364.7 | ma-71 | 4364.7 | 3.35295 | 0.011738 | 92.1432
2 x BEAM | +10.390 | +10.590 | 3 | 14 | 88.8 | 0.3 | 3.1 | 3964.7 | ma-70 | 3964.7 | 3.04568 | 0.0106481 | 83.5873
2 x BEAM | +10.390 | +10.590 | 3 | 14 | 88.8 | 0.3 | 3.1 | 3964.7 | ma-78 | 3964.7 | 3.04568 | 0.0106481 | 83.5873
BEAM | +10.390 | +10.590 | 3 | 14 | 97.8 | 0.3 | 3.5 | 4364.7 | ma-82 | 4364.7 | 3.35295 | 0.011738 | 92.1432
BEAM | +10.390 | +10.590 | 3 | 14 | 97.8 | 0.3 | 3.5 | 4364.7 | ma-67 | 4364.7 | 3.35295 | 0.011738 | 92.1432
2 x BEAM | +15.500 | +15.700 | 5 | 23 | 89.6 | 0.3 | 3.1 | 3999.7 | mc-227 | 3999.7 | 3.07256 | 0.0107434 | 84.336
BEAM | +15.500 | +15.700 | 5 | 23 | 44.6 | 0.2 | 1.5 | 1991.6 | mc-249 | 1991.55 | 1.52991 | 0.0052646 | 41.3271
BEAM | +48.500 | +48.700 | 7 | 14 | 56.5 | 0.2 | 1.9 | 2521.6 | me-62 | 2521.55 | 1.93705 | 0.00670875 | 52.6637
BEAM | +10.390 | +10.590 | 3 | 14 | 97.8 | 0.3 | 3.5 | 4364.7 | ma-76 | 4364.72 | 3.35297 | 0.0117417 | 92.1722
5 x BEAM | +5.500 | +5.700 | 3 | 23 | 97.8 | 0.3 | 3.5 | 4364.7 | ma-77 | 4364.7 | 3.35295 | 0.011738 | 92.1432
3 x BEAM | +5.500 | +5.700 | 3 | 23 | 88.8 | 0.3 | 3.1 | 3964.7 | ma-78 | 3964.7 | 3.04568 | 0.0106481 | 83.5873
BEAM | +5.500 | +5.700 | 3 | 23 | 88.8 | 0.3 | 3.1 | 3964.7 | ma-81 | 3964.7 | 3.04568 | 0.0106481 | 83.5873
BEAM | +5.500 | +5.700 | 3 | 23 | 97.8 | 0.3 | 3.5 | 4364.7 | ma-76 | 4364.72 | 3.35297 | 0.0117417 | 92.1722
3 x BEAM | +5.500 | +5.700 | 3 | 23 | 117.9 | 0.5 | 4.1 | 5265.5 | ma-89 | 5265.55 | 4.04499 | 0.0141856 | 111.357
BEAM | +5.500 | +5.700 | 3 | 23 | 156 | 0.6 | 5.5 | 6964.7 | ma-87 | 6964.7 | 5.35027 | 0.0188225 | 147.756
BEAM | +5.500 | +5.700 | 3 | 23 | 117.9 | 0.5 | 4.1 | 5265.5 | ma-65 | 5265.55 | 4.04499 | 0.0141856 | 111.357
2 x BEAM | +5.500 | +5.700 | 3 | 23 | 37.3 | 0.2 | 1.3 | 1665.5 | ma-95 | 1665.55 | 1.27947 | 0.00437632 | 34.3541
BEAM | +5.500 | +5.700 | 5 | 23 | 25.5 | 0.1 | 0.8 | 1139.7 | mc-237 | 1139.7 | 0.875516 | 0.00295051 | 23.1615
6 x BEAM | +5.500 | +5.700 | 5 | 23 | 25.5 | 0.1 | 0.8 | 1139.7 | mc-204 | 1139.7 | 0.875516 | 0.00295051 | 23.1615
2 x BEAM | +5.500 | +5.700 | 3 | 23 | 59.7 | 0.3 | 2.1 | 2664.7 | ma-80 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
2 x BEAM | +5.500 | +5.700 | 3 | 23 | 59.7 | 0.3 | 2.1 | 2664.7 | ma-75 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
2 x BEAM | +5.500 | +5.700 | 5 | 23 | 66.4 | 0.3 | 2.3 | 2964.7 | mc-213 | 2964.7 | 2.27748 | 0.00792327 | 62.1977
2 x BEAM | +5.500 | +5.700 | 5 | 23 | 18.6 | 0.1 | 0.6 | 828.6 | mc-248 | 828.55 | 0.636491 | 0.00209566 | 16.4509
BEAM | +17.850 | +18.050 | 4 | 14 | 156 | 0.6 | 5.5 | 6964.7 | mb-58 | 6964.7 | 5.35027 | 0.0188225 | 147.756
2 x BEAM | +17.850 | +18.050 | 4 | 14 | 44 | 0.2 | 1.5 | 1965.6 | mb-57 | 1965.55 | 1.50993 | 0.0051925 | 40.7611
4 x BEAM | +17.850 | +18.050 | 4 | 14 | 44 | 0.2 | 1.5 | 1965.6 | mb-76 | 1965.55 | 1.50993 | 0.00519376 | 40.771
BEAM | +17.850 | +18.050 | 4 | 14 | 21.4 | 0.1 | 0.8 | 956.4 | mb-83 | 956.4 | 0.734705 | 0.002606 | 20.4571
BEAM | +17.850 | +18.050 | 4 | 14 | 25.1 | 0.1 | 0.8 | 1120.4 | mb-79 | 1120.35 | 0.860651 | 0.00297526 | 23.3558
6 x BEAM | +15.500 | +15.700 | 4 | 23 | 37.3 | 0.2 | 1.3 | 1665.3 | mb-86 | 1665.3 | 1.27928 | 0.00439237 | 34.4801
3 x BEAM | +17.850 | +18.050 | 4 | 14 | 59.7 | 0.3 | 2.1 | 2664.7 | mb-85 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +52.840 | +53.040 | 8 | 3 | 59.7 | 0.3 | 2.1 | 2664.7 | mf-131 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +36.070 | +36.270 | 6 | 14 | 59.7 | 0.3 | 2.1 | 2664.7 | md-45 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +31.528 | +31.728 | 6 | 3 | 59.7 | 0.3 | 2.1 | 2664.7 | md-44 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +24.118 | +24.318 | 4 | 3 | 59.7 | 0.3 | 2.1 | 2664.7 | mb-82 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +17.850 | +18.050 | 4 | 3 | 59.7 | 0.3 | 2.1 | 2664.7 | mb-82 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +5.500 | +5.700 | 3 | 23 | 44 | 0.2 | 1.5 | 1965.6 | ma-64 | 1965.55 | 1.50993 | 0.0051925 | 40.7611
BEAM | +5.500 | +5.700 | 3 | 23 | 156 | 0.6 | 5.5 | 6964.7 | ma-63 | 6964.7 | 5.35027 | 0.0188225 | 147.756
BEAM | +5.500 | +5.700 | 3 | 23 | 44 | 0.2 | 1.5 | 1965.6 | ma-62 | 1965.55 | 1.50993 | 0.0051925 | 40.7611
BEAM | +48.500 | +48.700 | 7 | 14 | 29.9 | 0.1 | 1 | 1340.6 | me-87 | 1340.55 | 1.02981 | 0.00349076 | 27.4025
BEAM | +63.250 | +63.450 | 8 | 3 | 59.7 | 0.3 | 2.1 | 2664.7 | mf-113 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +5.500 | +5.700 | 3 | 23 | 32.7 | 0.1 | 1.1 | 1460.7 | ma-74 | 1460.7 | 1.12211 | 0.00382293 | 30.01
2 x BEAM | +10.390 | +10.590 | 3 | 14 | 88.8 | 0.3 | 3.1 | 3964.7 | ma-69 | 3964.7 | 3.04568 | 0.0106481 | 83.5873
BEAM | +10.390 | +10.590 | 3 | 14 | 32.9 | 0.1 | 1.1 | 1466.4 | ma-91 | 1466.4 | 1.12649 | 0.00382665 | 30.0392
BEAM | +10.390 | +10.590 | 3 | 14 | 32.9 | 0.1 | 1.1 | 1466.4 | ma-61 | 1466.4 | 1.12649 | 0.00382665 | 30.0392
BEAM | +10.390 | +10.590 | 3 | 14 | 59.7 | 0.3 | 2.1 | 2664.7 | ma-79 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +10.390 | +10.590 | 3 | 14 | 59.7 | 0.3 | 2.1 | 2664.7 | ma-66 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +10.390 | +10.590 | 3 | 14 | 59.7 | 0.3 | 2.1 | 2664.7 | ma-68 | 2664.7 | 2.04702 | 0.00710583 | 55.7808
BEAM | +66.050 | +66.250 | 8 | 14 | 25 | 0.1 | 0.8 | 1116.5 | mf-136 | 1116.4 | 0.857616 | 0.00287297 | 22.5528
BEAM | +48.500 | +48.700 | 7 | 14 | 156 | 0.6 | 5.5 | 6964.7 | me-61 | 6964.7 | 5.35027 | 0.0188225 | 147.756
BEAM | +12.300 | +12.500 | 5 | 7 | 52.1 | 0.2 | 1.7 | 2327.4 | mc-193 | 2327.35 | 1.78787 | 0.00626409 | 49.1731
10 x BEAM | +12.300 | +12.500 | 5 | 7 | 47.1 | 0.2 | 1.6 | 2104.7 | mc-206 | 2104.7 | 1.61683 | 0.00557994 | 43.8025
BEAM | +12.300 | +12.500 | 5 | 7 | 72.7 | 0.3 | 2.5 | 3240.7 | mc-211 | 3240.7 | 2.4895 | 0.00867919 | 68.1317
BEAM | +12.300 | +12.500 | 5 | 7 | 30.2 | 0.1 | 1 | 1346.6 | mc-172 | 1346.55 | 1.03442 | 0.00352381 | 27.6619
8 x BEAM | +12.300 | +12.500 | 5 | 7 | 72.7 | 0.3 | 2.5 | 3244.7 | mc-205 | 3244.7 | 2.49257 | 0.00868621 | 68.1867
BEAM | +12.300 | +12.500 | 5 | 7 | 53.6 | 0.2 | 1.9 | 2394.7 | mc-210 | 2394.7 | 1.8396 | 0.00637013 | 50.0055
BEAM | +68.250 | +68.450 | 8 | 3 | 47.4 | 0.2 | 1.6 | 2115.9 | mf-129 | 2115.9 | 1.62543 | 0.00562987 | 44.1945
BEAM | +60.535 | +60.735 | 8 | 3 | 47.4 | 0.2 | 1.6 | 2115.9 | mf-112 | 2115.9 | 1.62543 | 0.00562987 | 44.1945
BEAM | +33.799 | +33.999 | 6 | 3 | 47.4 | 0.2 | 1.6 | 2115.9 | md-43 | 2115.9 | 1.62543 | 0.00562987 | 44.1945
BEAM | +26.215 | +26.415 | 6 | 3 | 47.4 | 0.2 | 1.6 | 2115.9 | md-43 | 2115.9 | 1.62543 | 0.00562987 | 44.1945
BEAM | +19.555 | +19.755 | 4 | 3 | 47.4 | 0.2 | 1.6 | 2115.9 | mb-81 | 2115.9 | 1.62543 | 0.00562987 | 44.1945
BEAM | +7.945 | +8.145 | 3 | 3 | 47.4 | 0.2 | 1.6 | 2115.9 | ma-73 | 2115.9 | 1.62543 | 0.00562987 | 44.1945
BEAM | +15.500 | +15.700 | 5 | 23 | 88.8 | 0.3 | 3.1 | 3964.7 | mc-235 | 3964.7 | 3.04568 | 0.0106481 | 83.5873
BEAM | +15.500 | +15.700 | 5 | 23 | 57.5 | 0.2 | 1.9 | 2565.6 | mc-196 | 2565.55 | 1.97085 | 0.00682864 | 53.6048
BEAM | +15.500 | +15.700 | 5 | 23 | 38.8 | 0.2 | 1.3 | 1730.5 | mc-247 | 1730.55 | 1.32941 | 0.00455343 | 35.7444
BEAM | +15.500 | +15.700 | 5 | 23 | 28.2 | 0.1 | 1 | 1265.6 | mc-177 | 1265.55 | 0.972194 | 0.0032864 | 25.7983
BEAM | +12.945 | +13.145 | 4 | 3 | 47.4 | 0.2 | 1.6 | 2115.9 | mb-84 | 2115.9 | 1.62543 | 0.00562987 | 44.1945
BEAM | +10.390 | +10.590 | 3 | 14 | 32.9 | 0.1 | 1.1 | 1465.6 | ma-93 | 1465.55 | 1.12583 | 0.00383136 | 30.0762
2 x BEAM | +5.500 | +5.700 | 5 | 23 | 53 | 0.2 | 1.7 | 2364.7 | mc-202 | 2364.7 | 1.81656 | 0.00628839 | 49.3638
2 x BEAM | +7.950 | +8.150 | 5 | 14 | 26.3 | 0.1 | 0.8 | 1172.4 | mc-171 | 1172.4 | 0.900636 | 0.00319456 | 25.0773
2 x BEAM | +7.950 | +8.150 | 5 | 14 | 52.8 | 0.2 | 1.9 | 2355 | mc-191 | 2355 | 1.80911 | 0.0064169 | 50.3727
BEAM | +5.500 | +5.700 | 5 | 23 | 88.8 | 0.3 | 3.1 | 3964.1 | mc-226 | 3964.1 | 3.04521 | 0.0106367 | 83.4983
BEAM | +5.500 | +5.700 | 5 | 23 | 77.7 | 0.3 | 2.7 | 3464.1 | mc-201 | 3464.1 | 2.66112 | 0.00927433 | 72.8035
BEAM | +5.500 | +5.700 | 5 | 23 | 97.8 | 0.3 | 3.5 | 4364.7 | mc-234 | 4364.7 | 3.35295 | 0.011738 | 92.1432
BEAM | +5.500 | +5.700 | 5 | 23 | 77.7 | 0.3 | 2.7 | 3464.1 | mc-233 | 3464.1 | 2.66112 | 0.00927433 | 72.8035
BEAM | +5.500 | +5.700 | 5 | 23 | 31.7 | 0.1 | 1.1 | 1417 | mc-232 | 1416.95 | 1.0885 | 0.00370111 | 29.0537
BEAM | +5.500 | +5.700 | 5 | 23 | 77.7 | 0.3 | 2.7 | 3464.1 | mc-170 | 3464.1 | 2.66112 | 0.00927433 | 72.8035
BEAM | +2.550 | +2.750 | 5 | 7 | 60.6 | 0.3 | 2.1 | 2706.5 | mc-169 | 2706.45 | 2.07909 | 0.00737453 | 57.8901
BEAM | +2.550 | +2.750 | 5 | 7 | 29.4 | 0.1 | 1 | 1310.8 | mc-190 | 1310.8 | 1.00695 | 0.00357167 | 28.0376
BEAM | +3.050 | +3.250 | 5 | 13 | 58.5 | 0.3 | 2.1 | 2610.8 | mc-168 | 2610.8 | 2.00561 | 0.00711391 | 55.8442
BEAM | +3.050 | +3.250 | 5 | 13 | 63.1 | 0.3 | 2.2 | 2816.4 | mc-167 | 2816.4 | 2.16355 | 0.00750513 | 58.9153
BEAM | +3.050 | +3.250 | 5 | 13 | 60.6 | 0.3 | 2.1 | 2706.5 | mc-182 | 2706.45 | 2.07909 | 0.00737453 | 57.8901
BEAM | +3.050 | +3.250 | 5 | 13 | 63.9 | 0.3 | 2.3 | 2856.7 | mc-166 | 2856.7 | 2.19451 | 0.00778394 | 61.1039
2 x BEAM | +3.050 | +3.250 | 5 | 13 | 58 | 0.3 | 1.9 | 2591.4 | mc-221 | 2591.4 | 1.99071 | 0.00689205 | 54.1026

# IfcBeam: L125*75*8 (7)
In: Undefined
Description: L125*75*8; Material: STEEL/S355JR
Tekla Common - Class: 7
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 32 m2; Net surface area: 0.3 m2; Height: 125 mm; Width: 75 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BEAM | +56.705 | +56.780 | 8 | 9.3 | 768.2 | mf-328 | 768.2 | 0.300026 | 0.00117996 | 9.26265
BEAM | +56.705 | +56.780 | 8 | 9.3 | 768.2 | mf-327 | 768.2 | 0.300026 | 0.00117996 | 9.26265
SUPPORT | +38.005 | +38.080 | 7 | 9.3 | 768.2 | me-205 | 768.2 | 0.300026 | 0.00117996 | 9.26265
SUPPORT | +38.005 | +38.080 | 7 | 9.3 | 768.2 | me-204 | 768.2 | 0.300026 | 0.00117996 | 9.26265
BEAM | +2.620 | +2.695 | 5 | 9.9 | 820.4 | mc-448 | 820.35 | 0.320394 | 0.00126006 | 9.89145
BEAM | +2.620 | +2.695 | 5 | 9.9 | 820.4 | mc-447 | 820.35 | 0.320394 | 0.00126006 | 9.89145
BEAM | +3.150 | +3.225 | 5 | 8.8 | 733.2 | mc-446 | 733.2 | 0.286357 | 0.0011262 | 8.84063

# IfcBeam: L70*70*6 (1033)
In: Undefined
Description: L70*70*6; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 42.7 m2; Height: 70 mm; Width: 70 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
14 x H/RAIL POST | +66.075 | +67.355 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F309 | 1280 | 0.348511 | 0.00101859 | 7.99593
17 x H/RAIL POST | +66.075 | +67.355 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F310 | 1280 | 0.348511 | 0.00101859 | 7.99593
16 x H/RAIL POST | +48.525 | +49.805 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E204 | 1280 | 0.348511 | 0.00101859 | 7.99593
12 x H/RAIL POST | +55.130 | +56.410 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F310 | 1280 | 0.348511 | 0.00101859 | 7.99593
19 x H/RAIL POST | +55.130 | +56.410 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F309 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +55.130 | +56.410 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F308 | 1280 | 0.348511 | 0.00102912 | 8.07859
19 x H/RAIL POST | +63.275 | +64.555 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F309 | 1280 | 0.348511 | 0.00101859 | 7.99593
12 x H/RAIL POST | +63.275 | +64.555 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F310 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +63.275 | +64.555 | 8 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-G-F307 | 1280 | 0.348511 | 0.00102912 | 8.07859
H/RAIL POST | +38.863 | +40.143 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E202 | 1280 | 0.348511 | 0.00102912 | 8.07859
6 x H/RAIL POST | +38.863 | +40.143 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E203 | 1280 | 0.348511 | 0.00101859 | 7.99593
6 x H/RAIL POST | +38.863 | +40.143 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E204 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +38.863 | +40.143 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E203 | 1280 | 0.348511 | 0.00101858 | 7.99587
17 x H/RAIL POST | +48.525 | +49.805 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E203 | 1280 | 0.348511 | 0.00101859 | 7.99593
21 x H/RAIL POST | +44.400 | +45.680 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E203 | 1280 | 0.348511 | 0.00101859 | 7.99593
12 x H/RAIL POST | +44.400 | +45.680 | 7 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-F-E204 | 1280 | 0.348511 | 0.00101859 | 7.99593
16 x H/RAIL POST | +36.095 | +37.375 | 6 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-E-D153 | 1280 | 0.348511 | 0.00101859 | 7.99593
13 x H/RAIL POST | +28.905 | +30.185 | 6 | 14 | 8.2 | 0 | 0.3 | 1280 | 471-E-D153 | 1280 | 0.348511 | 0.00101859 | 7.99593
H/RAIL POST | +66.260 | +67.355 | 8 | 14 | 7 | 0 | 0.3 | 1095 | mf-241 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +60.745 | +61.840 | 8 | 14 | 7 | 0 | 0.3 | 1095 | mf-242 | 1095 | 0.29814 | 0.00086985 | 6.82832
H/RAIL POST | +60.745 | +61.840 | 8 | 14 | 7 | 0 | 0.3 | 1095 | mf-241 | 1095 | 0.29814 | 0.00086985 | 6.82832
