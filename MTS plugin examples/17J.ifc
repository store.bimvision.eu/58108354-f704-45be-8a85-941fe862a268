Properties of the parts of a building model (IFC2X3), part 13 of 16

# IfcElementAssembly (3904)
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Steel Assembly |  | 0.7 | +54.845 | +55.876 | 10-11/D-E | A448 | 170.044
Steel Assembly |  | 0.7 | +54.927 | +55.958 | 10-11/D-E | A448 | 170.044
Steel Assembly |  | 0.7 | +55.031 | +56.062 | 10-11/D-E | A449 | 170.044
Steel Assembly |  | 0.7 | +55.174 | +56.205 | 10-11/D-E | A448 | 170.044
Steel Assembly |  | 0.7 | +55.298 | +56.329 | 10-11/D-E | A448 | 170.044
Steel Assembly |  | 0.7 | +55.422 | +56.452 | 10-11/D-E | A448 | 170.044
Steel Assembly |  | 0.7 | +55.545 | +56.576 | 10-11/D-E | A448 | 170.044
Steel Assembly |  | 0.7 | +55.669 | +56.700 | 10-11/D-E | A448 | 170.044
Steel Assembly |  | 0.7 | +55.751 | +56.782 | 10-11/D-E | A448 | 170.044
Steel Assembly | RIGID_FRAME | 4.8 | +55.655 | +55.731 | 10-11/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.573 | +55.648 | 10-11/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.449 | +55.525 | 10-11/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.325 | +55.401 | 10-11/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.078 | +55.154 | 10-11/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.955 | +55.030 | 10-11/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.831 | +54.907 | 10-11/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.749 | +54.824 | 10-11/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 104.1 | +54.687 | +54.791 | 10/A-E | A303 | 50
Steel Assembly | RIGID_FRAME | 104.1 | +55.658 | +55.762 | 11/A-E | A303 | 50
Steel Assembly | RIGID_FRAME | 146.7 | +54.779 | +55.895 | 10-11/D-E | A365 | 75
Steel Assembly | RIGID_FRAME | 8.2 | +57.320 | +58.360 | 16/A-B | A540 | 646
Steel Assembly | RIGID_FRAME | 9.3 | +56.835 | +57.835 | 19-20/D-E | A544 | 600
Steel Assembly | RIGID_FRAME | 9.3 | +56.835 | +57.835 | 19-20/C-D | A545 | 600
Steel Assembly | RIGID_FRAME | 0.9 | +57.248 | +57.472 | 19-20/D-E | A796 | 3
2 x Steel Assembly | RIGID_FRAME | 0.9 | +57.248 | +57.472 | 19-20/C-D | A796 | 3
Steel Assembly | RIGID_FRAME | 9.3 | +56.835 | +57.835 | 19-20/C-D | A544 | 600
Steel Assembly | RIGID_FRAME | 9.3 | +56.835 | +57.835 | 19-20/B-C | A545 | 600
2 x Steel Assembly | RIGID_FRAME | 0.9 | +57.248 | +57.472 | 19-20/B-C | A796 | 3
Steel Assembly | RIGID_FRAME | 9.3 | +56.835 | +57.835 | 19-20/B-C | A544 | 600
Steel Assembly | RIGID_FRAME | 9.3 | +56.835 | +57.835 | 19-20/A-B | A545 | 600
Steel Assembly | RIGID_FRAME | 0.9 | +57.248 | +57.472 | 19-20/A-B | A796 | 3
Steel Assembly | RIGID_FRAME | 104.1 | +56.628 | +56.731 | 12/A-E | A303 | 50
2 x Steel Assembly | RIGID_FRAME | 18 | +51.403 | +51.565 | 7/C-D | A733 | 200
Steel Assembly |  | 0 | +57.032 | +57.092 | 17-18/B-C | A676 | 60
Steel Assembly |  | 0 | +56.853 | +56.913 | 17-18/B-C | A676 | 60
Steel Assembly |  | 0 | +57.753 | +57.787 | 17-18/D-E | A589 | 34
Steel Assembly |  | 0 | +58.253 | +58.287 | 17-18/D-E | A589 | 34
Steel Assembly |  | 0 | +57.572 | +57.787 | 17-18/A-B | A588 | 344.037
Steel Assembly |  | 0 | +58.072 | +58.287 | 17-18/A-B | A588 | 344.442
Steel Assembly | RIGID_FRAME | 214.5 |  |  |  | A53 | 200.95
Steel Assembly | RIGID_FRAME | 221.6 |  |  |  | A393 | 200.95
8 x Steel Assembly | RIGID_FRAME | 1.9 | +57.105 | +57.245 | 16-17/B-C | A679 | 90
Steel Assembly | RIGID_FRAME | 12.5 | +57.090 | +57.160 | 16-17/A-B | A211 | 70
Steel Assembly | RIGID_FRAME | 12.5 | +57.090 | +57.160 | 16-17/D-E | A211 | 70
Steel Assembly |  | 0 | +57.753 | +57.787 | 17-18/A-B | A582 | 153.225
Steel Assembly |  | 0 | +57.428 | +58.098 | 17-18/A-B | A592 | 34
Steel Assembly |  | 0 | +58.253 | +58.287 | 17-18/A-B | A582 | 153.229
Steel Assembly |  | 0 | +57.571 | +57.787 | 17-18/D-E | A591 | 34
Steel Assembly |  | 0 | +57.753 | +57.787 | 17-18/D-E | A583 | 147.979
Steel Assembly |  | 0 | +57.428 | +58.098 | 17-18/D-E | A592 | 34
Steel Assembly |  | 0 | +58.072 | +58.287 | 17-18/D-E | A590 | 34
Steel Assembly |  | 0 | +58.253 | +58.287 | 17-18/D-E | A583 | 147.979
Steel Assembly |  | 0 | +57.753 | +57.787 | 13/A-B | A584 | 323
Steel Assembly |  | 0 | +58.253 | +58.287 | 13/A-B | A584 | 323
Steel Assembly |  | 0 | +57.748 | +57.787 | 13/A-B | A585 | 317.184
Steel Assembly |  | 0 | +58.253 | +58.291 | 13/A-B | A585 | 317.184
Steel Assembly |  | 0 | +57.753 | +57.787 | 13/D-E | A584 | 323
Steel Assembly |  | 0 | +58.253 | +58.287 | 13/D-E | A584 | 323
Steel Assembly |  | 0 | +57.748 | +57.787 | 13/D-E | A586 | 317.184
Steel Assembly |  | 0 | +58.253 | +58.291 | 13/D-E | A586 | 317.184
Steel Assembly |  | 0 | +52.910 | +54.076 | 5/D-E | A175 | 1652.47
Steel Assembly |  | 0 | +53.398 | +53.504 | 5-6/C-D | A565 | 34.1401
Steel Assembly |  | 0 | +52.910 | +54.006 | 5/C-D | A176 | 614.468
Steel Assembly |  | 0 | +52.910 | +54.076 | 5/C-D | A175 | 1652.47
Steel Assembly |  | 0 | +53.398 | +53.504 | 5-6/B-C | A565 | 34.1401
Steel Assembly |  | 0 | +52.910 | +54.006 | 5/B-C | A176 | 614.468
Steel Assembly |  | 0 | +52.910 | +54.076 | 5/B-C | A175 | 1652.47
Steel Assembly |  | 0 | +53.398 | +53.504 | 5-6/A-B | A565 | 34.1401
Steel Assembly |  | 0 | +52.910 | +54.006 | 5/A-B | A176 | 614.468
Steel Assembly | RIGID_FRAME | 139.6 | +50.267 | +52.156 | 8/A-C | A183 | 260.441
2 x Steel Assembly | RIGID_FRAME | 15.9 | +51.273 | +52.156 | 8/B-C | A419 | 70
Steel Assembly | RIGID_FRAME | 81.7 | +50.242 | +52.396 | 8/A-B | A24 | 394.1
2 x Steel Assembly | RIGID_FRAME | 27.7 | +51.761 | +53.149 | 9/A-C | A434 | 100
Steel Assembly | RIGID_FRAME | 161.3 | +50.259 | +53.149 | 9/A-C | A184 | 274.872
Steel Assembly | RIGID_FRAME | 111.4 | +50.242 | +53.389 | 9/A-B | A17 | 324.454
Steel Assembly | RIGID_FRAME | 183.2 | +50.266 | +54.141 | 10/A-C | A185 | 254.97
2 x Steel Assembly | RIGID_FRAME | 19.5 | +52.264 | +54.141 | 10/A-C | A284 | 80
Steel Assembly | RIGID_FRAME | 143.3 | +50.242 | +54.381 | 10/A-B | A18 | 301.018
2 x Steel Assembly | RIGID_FRAME | 13 | +52.715 | +52.785 | 11/A-C | A190 | 70
2 x Steel Assembly | RIGID_FRAME | 36.5 | +52.795 | +55.134 | 11/A-C | A432 | 100
Steel Assembly | RIGID_FRAME | 213.8 | +50.264 | +55.134 | 11/A-C | A186 | 301.803
Steel Assembly | RIGID_FRAME | 178.3 | +50.242 | +55.374 | 11/A-B | A19 | 275.951
2 x Steel Assembly |  | 0 | +50.919 | +51.583 | 4-5/C-D | A593 | 34
2 x Steel Assembly | RIGID_FRAME | 1.9 | +50.919 | +51.583 | 4-5/D-E | A594 | 417.789
2 x Steel Assembly |  | 0 | +50.919 | +51.583 | 4-5/B-C | A593 | 34
2 x Steel Assembly | RIGID_FRAME | 13 | +53.191 | +53.261 | 12/A-C | A191 | 70
2 x Steel Assembly | RIGID_FRAME | 41.4 | +53.271 | +56.085 | 12/A-C | A433 | 100
Steel Assembly | RIGID_FRAME | 238.2 | +50.280 | +56.085 | 12/A-C | A187 | 289.899
Steel Assembly | RIGID_FRAME | 76.3 | +52.436 | +55.027 | 13/B-C | A397 | 165.1
Mesh |  | 0 | +57.270 | +57.276 | 14-15/C-D | A769 | 6
Mesh |  | 0 | +57.270 | +57.276 | 13-14/C-D | A764 | 6
2 x Steel Assembly | RIGID_FRAME | 1.9 | +50.919 | +51.583 | 4-5/A-B | A594 | 417.789
Steel Assembly | RIGID_FRAME | 4.8 | +56.744 | +56.818 | 12-13/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.832 | +56.906 | 12-13/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.912 | +56.986 | 12-13/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +57.050 | +57.123 | 12-13/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +57.108 | +57.180 | 12-13/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.663 | +54.739 | 9-10/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.581 | +54.656 | 9-10/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.457 | +54.533 | 9-10/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.333 | +54.409 | 9-10/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.086 | +54.162 | 9-10/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.963 | +54.038 | 9-10/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.839 | +53.915 | 9-10/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.671 | +53.746 | 8-9/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.588 | +53.664 | 8-9/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.465 | +53.540 | 8-9/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.341 | +53.417 | 8-9/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.094 | +53.169 | 8-9/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.970 | +53.046 | 8-9/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.847 | +52.922 | 8-9/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.678 | +52.754 | 7-8/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.596 | +52.672 | 7-8/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.472 | +52.548 | 7-8/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.349 | +52.424 | 7-8/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.102 | +52.177 | 7-8/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.978 | +52.054 | 7-8/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.854 | +51.930 | 7-8/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.683 | +51.758 | 6-7/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.559 | +51.635 | 6-7/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.312 | +51.387 | 6-7/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +50.979 | +51.055 | 5-6/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.103 | +51.179 | 5-6/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +57.181 | +57.253 | 12-13/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.681 | +56.755 | 12-13/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.757 | +53.832 | 9-10/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.764 | +52.840 | 8-9/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.772 | +51.848 | 7-8/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.188 | +51.264 | 6-7/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.831 | +54.907 | 10-11/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.663 | +54.739 | 9-10/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.581 | +54.656 | 9-10/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.457 | +54.533 | 9-10/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.333 | +54.409 | 9-10/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.086 | +54.162 | 9-10/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.963 | +54.038 | 9-10/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.839 | +53.915 | 9-10/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.671 | +53.746 | 8-9/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.588 | +53.664 | 8-9/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.465 | +53.540 | 8-9/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.341 | +53.417 | 8-9/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.094 | +53.169 | 8-9/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.970 | +53.046 | 8-9/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.847 | +52.922 | 8-9/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.678 | +52.754 | 7-8/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.596 | +52.672 | 7-8/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.472 | +52.548 | 7-8/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.349 | +52.424 | 7-8/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.102 | +52.177 | 7-8/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.978 | +52.054 | 7-8/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.854 | +51.930 | 7-8/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.683 | +51.758 | 6-7/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.559 | +51.635 | 6-7/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.312 | +51.387 | 6-7/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +50.979 | +51.055 | 5-6/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.103 | +51.179 | 5-6/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +57.181 | +57.253 | 12-13/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +57.108 | +57.180 | 12-13/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +57.050 | +57.123 | 12-13/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.912 | +56.986 | 12-13/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.832 | +56.906 | 12-13/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.744 | +56.818 | 12-13/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.681 | +56.755 | 12-13/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.613 | +56.688 | 11-12/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.546 | +56.620 | 11-12/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.434 | +56.509 | 11-12/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.316 | +56.391 | 11-12/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.070 | +56.146 | 11-12/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.946 | +56.022 | 11-12/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.823 | +55.898 | 11-12/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.740 | +55.816 | 11-12/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.655 | +55.731 | 10-11/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.573 | +55.648 | 10-11/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.449 | +55.525 | 10-11/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.325 | +55.401 | 10-11/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.078 | +55.154 | 10-11/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.955 | +55.030 | 10-11/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +54.749 | +54.824 | 10-11/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.757 | +53.832 | 9-10/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +52.764 | +52.840 | 8-9/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.772 | +51.848 | 7-8/A-B | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +51.188 | +51.264 | 6-7/A-B | A224 | 70
Steel Assembly |  | 0.7 | +57.253 | +58.286 | 12-13/D-E | A454 | 170
Steel Assembly | RIGID_FRAME | 21.3 | +55.130 | +56.615 | 13/B-C | A294 | 80
Steel Assembly | RIGID_FRAME | 21.3 | +55.130 | +56.615 | 13/C-D | A294 | 80
Steel Assembly | RIGID_FRAME | 23.3 | +55.195 | +56.605 | 13/C-E | A435 | 100
Steel Assembly | RIGID_FRAME | 202.4 | +56.966 | +57.615 | 15-17/B-C | A463 | 343.85
Steel Assembly | RIGID_FRAME | 202.4 | +56.966 | +57.615 | 15-17/B-C | A464 | 343.85
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 13-14/C-D | A681 | 90
6 x Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 13-14/C-D | A680 | 90
7 x Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 13-14/B-C | A680 | 90
Steel Assembly |  | 0.7 | +55.837 | +56.868 | 11-12/D-E | A448 | 170.044
Steel Assembly |  | 0.7 | +55.836 | +56.868 | 11-12/A-B | A448 | 170.044
Steel Assembly |  | 0.7 | +56.412 | +57.443 | 11-12/D-E | A448 | 170.026
Steel Assembly |  | 0.7 | +56.711 | +57.742 | 11-12/D-E | A451 | 170.212
Steel Assembly |  | 0.7 | +56.774 | +57.810 | 12/D-E | A456 | 170.001
Steel Assembly |  | 0.7 | +57.203 | +58.236 | 12-13/D-E | A455 | 170.104
Steel Assembly |  | 0.7 | +51.075 | +52.106 | 5-6/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +51.199 | +52.230 | 5-6/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +57.277 | +58.309 | 12-13/D-E | A454 | 170.006
Steel Assembly |  | 0.7 | +57.146 | +58.178 | 12-13/D-E | A168 | 170.054
Steel Assembly |  | 0.7 | +57.081 | +58.112 | 12-13/D-E | A167 | 170.052
Steel Assembly |  | 0.7 | +57.008 | +58.041 | 12-13/D-E | A168 | 170.05
Steel Assembly |  | 0.7 | +56.928 | +57.961 | 12-13/D-E | A168 | 170.049
Steel Assembly |  | 0.7 | +56.840 | +57.881 | 12-13/D-E | A169 | 170.047
Steel Assembly |  | 0.7 | +56.643 | +57.674 | 11-12/D-E | A451 | 170.111
Steel Assembly |  | 0.7 | +56.531 | +57.561 | 11-12/D-E | A450 | 170.232
Steel Assembly |  | 0.7 | +55.919 | +56.950 | 11-12/D-E | A448 | 170.044
Steel Assembly |  | 0.7 | +56.043 | +57.073 | 11-12/D-E | A448 | 170.044
Steel Assembly |  | 0.7 | +56.166 | +57.197 | 11-12/D-E | A448 | 170.044
Steel Assembly |  | 0.7 | +56.290 | +57.321 | 11-12/D-E | A448 | 170.044
Steel Assembly |  | 0.7 | +54.759 | +55.790 | 9-10/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +53.853 | +54.883 | 9-10/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +53.935 | +54.966 | 9-10/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +54.059 | +55.089 | 9-10/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +54.182 | +55.213 | 9-10/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +54.677 | +55.707 | 9-10/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +54.553 | +55.584 | 9-10/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +54.429 | +55.460 | 9-10/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +54.306 | +55.337 | 9-10/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +53.767 | +54.797 | 8-9/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +52.860 | +53.891 | 8-9/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +52.943 | +53.973 | 8-9/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +53.066 | +54.097 | 8-9/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +53.190 | +54.221 | 8-9/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +53.684 | +54.715 | 8-9/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +53.561 | +54.591 | 8-9/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +53.437 | +54.468 | 8-9/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +53.313 | +54.344 | 8-9/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +52.774 | +53.805 | 7-8/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +51.868 | +52.899 | 7-8/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +51.950 | +52.981 | 7-8/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +52.074 | +53.059 | 7-8/D-E | A170 | 170.008
Steel Assembly |  | 0.7 | +52.198 | +53.228 | 7-8/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +52.692 | +53.723 | 7-8/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +52.568 | +53.558 | 7-8/D-E | A171 | 170.008
Steel Assembly |  | 0.7 | +52.445 | +53.476 | 7-8/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +52.321 | +53.309 | 7-8/D-E | A172 | 170.008
Steel Assembly |  | 0.7 | +51.779 | +52.810 | 6-7/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +51.655 | +52.686 | 6-7/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +51.284 | +52.315 | 6-7/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +51.408 | +52.439 | 6-7/D-E | A167 | 170.042
Steel Assembly |  | 0.7 | +51.531 | +52.512 | 6-7/D-E | A166 | 170.008
Steel Assembly |  | 0 | +57.228 | +57.796 | 12-13/D-E | A595 | 34
Steel Assembly |  | 0 | +57.728 | +58.295 | 12-13/D-E | A598 | 34
Steel Assembly |  | 0 | +57.346 | +57.761 | 11-12/D-E | A602 | 34.0009
Steel Assembly |  | 0 | +56.776 | +57.380 | 11-12/D-E | A566 | 34
Steel Assembly |  | 0 | +56.277 | +56.882 | 11-12/D-E | A566 | 34
Steel Assembly |  | 0 | +56.848 | +57.262 | 11-12/D-E | A601 | 34.0009
Steel Assembly |  | 0 | +55.783 | +56.809 | 10-11/D-E | A560 | 34
Steel Assembly |  | 0 | +55.285 | +56.311 | 10-11/D-E | A560 | 34
Steel Assembly |  | 0 | +54.791 | +55.817 | 9-10/D-E | A560 | 34
Steel Assembly |  | 0 | +54.293 | +55.319 | 9-10/D-E | A560 | 34
Steel Assembly |  | 0 | +53.799 | +54.825 | 8-9/D-E | A560 | 34
Steel Assembly |  | 0 | +53.300 | +54.327 | 8-9/D-E | A560 | 34
Steel Assembly |  | 0 | +52.005 | +52.256 | 5-6/D-E | A562 | 34
Steel Assembly |  | 0 | +51.501 | +51.755 | 5-6/D-E | A561 | 34
Steel Assembly |  | 0 | +52.806 | +53.833 | 7-8/D-E | A560 | 34
Steel Assembly |  | 0 | +52.308 | +53.334 | 7-8/D-E | A560 | 34
Steel Assembly |  | 0 | +52.219 | +52.840 | 6-7/D-E | A559 | 34
Steel Assembly |  | 0 | +51.721 | +52.342 | 6-7/D-E | A559 | 34
Steel Assembly |  | 0 | +57.228 | +57.796 | 12-13/A-B | A596 | 34
Steel Assembly |  | 0 | +57.728 | +58.295 | 12-13/A-B | A597 | 34
Steel Assembly |  | 0.7 | +57.203 | +58.236 | 12-13/A-B | A454 | 170.104
Steel Assembly |  | 0.7 | +51.076 | +52.106 | 5-6/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +51.199 | +52.230 | 5-6/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +56.777 | +57.810 | 12/A-B | A168 | 170.012
Steel Assembly |  | 0.7 | +56.840 | +57.881 | 12-13/A-B | A169 | 170.053
Steel Assembly |  | 0.7 | +56.928 | +57.961 | 12-13/A-B | A168 | 170.052
Steel Assembly |  | 0.7 | +57.008 | +58.041 | 12-13/A-B | A168 | 170.05
Steel Assembly |  | 0.7 | +57.081 | +58.112 | 12-13/A-B | A167 | 170.049
Steel Assembly |  | 0.7 | +57.146 | +58.178 | 12-13/A-B | A168 | 170.047
Steel Assembly |  | 0.7 | +57.253 | +58.270 | 12-13/A-B | A173 | 170.016
Steel Assembly |  | 0.7 | +57.277 | +58.309 | 12-13/A-B | A168 | 170.028
Steel Assembly |  | 0 | +57.346 | +57.761 | 11-12/A-B | A600 | 34.0009
Steel Assembly |  | 0.7 | +56.710 | +57.744 | 11-12/A-B | A457 | 170.002
Steel Assembly |  | 0.7 | +56.641 | +57.674 | 11-12/A-B | A453 | 170.179
Steel Assembly |  | 0.7 | +56.530 | +57.561 | 11-12/A-B | A452 | 170.164
Steel Assembly |  | 0.7 | +56.412 | +57.443 | 11-12/A-B | A448 | 170.159
Steel Assembly |  | 0 | +56.776 | +57.380 | 11-12/A-B | A566 | 34
Steel Assembly |  | 0 | +56.277 | +56.882 | 11-12/A-B | A566 | 34
Steel Assembly |  | 0.7 | +55.919 | +56.950 | 11-12/A-B | A448 | 170.044
Steel Assembly |  | 0.7 | +56.043 | +57.073 | 11-12/A-B | A448 | 170.044
Steel Assembly |  | 0.7 | +56.166 | +57.197 | 11-12/A-B | A448 | 170.044
Steel Assembly |  | 0.7 | +56.290 | +57.321 | 11-12/A-B | A448 | 170.044
Steel Assembly |  | 0.7 | +55.751 | +56.782 | 10-11/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +54.845 | +55.876 | 10-11/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +54.927 | +55.958 | 10-11/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +55.050 | +56.062 | 10-11/A-B | A174 | 170.008
Steel Assembly |  | 0.7 | +55.174 | +56.205 | 10-11/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +55.669 | +56.700 | 10-11/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +55.545 | +56.576 | 10-11/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +55.422 | +56.452 | 10-11/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +55.298 | +56.329 | 10-11/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +54.759 | +55.790 | 9-10/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +53.853 | +54.883 | 9-10/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +53.935 | +54.966 | 9-10/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +54.059 | +55.089 | 9-10/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +54.182 | +55.213 | 9-10/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +54.677 | +55.707 | 9-10/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +54.553 | +55.584 | 9-10/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +54.429 | +55.460 | 9-10/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +54.306 | +55.337 | 9-10/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +53.767 | +54.797 | 8-9/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +52.860 | +53.891 | 8-9/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +52.943 | +53.973 | 8-9/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +53.066 | +54.097 | 8-9/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +53.190 | +54.221 | 8-9/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +53.684 | +54.715 | 8-9/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +53.561 | +54.591 | 8-9/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +53.437 | +54.468 | 8-9/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +53.313 | +54.344 | 8-9/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +52.774 | +53.805 | 7-8/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +51.868 | +52.899 | 7-8/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +51.950 | +52.981 | 7-8/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +52.074 | +53.059 | 7-8/A-B | A170 | 170.008
Steel Assembly |  | 0.7 | +52.198 | +53.228 | 7-8/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +52.692 | +53.723 | 7-8/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +52.568 | +53.558 | 7-8/A-B | A171 | 170.008
Steel Assembly |  | 0.7 | +52.445 | +53.476 | 7-8/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +52.321 | +53.309 | 7-8/A-B | A172 | 170.008
Steel Assembly |  | 0.7 | +51.779 | +52.810 | 6-7/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +51.655 | +52.686 | 6-7/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +51.284 | +52.315 | 6-7/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +51.408 | +52.439 | 6-7/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +51.531 | +52.512 | 6-7/A-B | A166 | 170.008
4 x Steel Assembly | RIGID_FRAME | 1.5 | +57.095 | +57.235 | 15/C-D | A682 | 90
Steel Assembly | RIGID_FRAME | 202.4 | +56.966 | +57.615 | 15-17/C-D | A461 | 343.85
4 x Steel Assembly | RIGID_FRAME | 1.5 | +57.095 | +57.235 | 15/B-C | A682 | 90
2 x Steel Assembly | RIGID_FRAME | 1.5 | +57.095 | +57.235 | 15/A-B | A682 | 90
Steel Assembly | RIGID_FRAME | 202.4 | +56.966 | +57.615 | 15-17/C-D | A465 | 343.85
Steel Assembly | RIGID_FRAME | 202.4 | +56.966 | +57.615 | 15-17/D-E | A462 | 343.85
Steel Assembly | RIGID_FRAME | 202.4 | +56.966 | +57.615 | 15-17/A-B | A465 | 343.85
4 x Steel Assembly | RIGID_FRAME | 1.9 | +57.105 | +57.245 | 16-17/D-E | A679 | 90
2 x Steel Assembly | RIGID_FRAME | 1.5 | +57.095 | +57.235 | 15/D-E | A682 | 90
4 x Steel Assembly | RIGID_FRAME | 1.9 | +57.105 | +57.245 | 16-17/A-B | A679 | 90
Steel Assembly | RIGID_FRAME | 6.3 | +57.320 | +58.274 | 16/D-E | A552 | 337.001
Steel Assembly | RIGID_FRAME | 6.3 | +57.320 | +58.274 | 15/D-E | A553 | 337.001
Steel Assembly | RIGID_FRAME | 6.3 | +57.320 | +58.274 | 16/C-D | A553 | 337.001
Steel Assembly | RIGID_FRAME | 6.3 | +57.320 | +58.274 | 15/C-D | A552 | 337.001
Steel Assembly | RIGID_FRAME | 6.3 | +57.320 | +58.274 | 16/C-D | A552 | 337.001
Steel Assembly | RIGID_FRAME | 6.3 | +57.320 | +58.274 | 15/C-D | A553 | 337.001
Steel Assembly | RIGID_FRAME | 6.3 | +57.320 | +58.274 | 16/B-C | A553 | 337.001
Steel Assembly | RIGID_FRAME | 6.3 | +57.320 | +58.274 | 15/B-C | A552 | 337.001
Steel Assembly | RIGID_FRAME | 6.3 | +57.320 | +58.274 | 16/B-C | A552 | 337.001
Steel Assembly | RIGID_FRAME | 6.3 | +57.320 | +58.274 | 15/B-C | A553 | 337.001
Steel Assembly |  | 0 | +53.049 | +54.091 | 5-6/C-D | A177 | 160.28
Steel Assembly | RIGID_FRAME | 9.3 | +51.216 | +51.994 | 5-6/D-E | A430 | 70
2 x Steel Assembly | RIGID_FRAME | 9.3 | +51.216 | +51.994 | 5-6/C-D | A430 | 70
Steel Assembly | RIGID_FRAME | 4.6 | +50.466 | +51.099 | 5/D-E | A649 | 60
2 x Steel Assembly | RIGID_FRAME | 4.6 | +50.466 | +51.099 | 5/C-D | A649 | 60
Steel Assembly | RIGID_FRAME | 23.9 | +50.944 | +51.234 | 5/C-E | A40 | 289.898
Steel Assembly | RIGID_FRAME | 73.8 | +52.307 | +52.521 | 6-7/C-E | A791 | 1996.27
2 x Liner Plate |  | 0 | +52.872 | +53.301 | 6-7/D | A835 | 16
2 x Liner Plate |  | 0 | +52.843 | +53.278 | 6-7/D | A832 | 16
2 x Liner Plate |  | 0 | +52.814 | +53.249 | 6-7/D | A832 | 16
2 x Liner Plate |  | 0 | +52.748 | +53.184 | 6-7/D | A832 | 16
2 x Liner Plate |  | 0 | +52.719 | +53.155 | 6/D | A832 | 16
2 x Liner Plate |  | 0 | +52.690 | +53.126 | 6/D | A832 | 16
2 x Liner Plate |  | 0 | +52.654 | +53.096 | 5-6/D | A834 | 16
2 x Liner Plate |  | 0 | +52.625 | +53.060 | 5-6/D | A832 | 16
2 x Liner Plate |  | 0 | +52.596 | +53.031 | 5-6/D | A832 | 16
2 x Liner Plate |  | 0 | +52.567 | +53.002 | 5-6/D | A832 | 16
2 x Liner Plate |  | 0 | +52.530 | +52.972 | 5-6/D | A834 | 16
2 x Liner Plate |  | 0 | +52.501 | +52.936 | 5/D | A832 | 16
2 x Liner Plate |  | 0 | +52.472 | +52.907 | 5/D | A832 | 16
2 x Liner Plate |  | 0 | +52.443 | +52.878 | 4-5/D | A832 | 16
2 x Liner Plate |  | 0 | +52.409 | +52.848 | 4-5/D | A833 | 16
2 x Liner Plate |  | 0 | +52.380 | +52.815 | 4-5/D | A832 | 16
2 x Liner Plate |  | 0 | +52.351 | +52.786 | 4-5/D | A832 | 16
2 x Liner Plate |  | 0 | +52.322 | +52.757 | 4-5/D | A832 | 16
2 x Liner Plate |  | 0 | +52.293 | +52.728 | 4-5/D | A832 | 16
2 x Rubber |  | 0 | +52.788 | +52.942 | 4-5/D | A778 | 10
Steel Assembly | RIGID_FRAME | 37.1 | +53.211 | +53.351 | 6-7/D | A814 | 847.6
Steel Assembly | RIGID_FRAME | 62.1 | +53.088 | +53.275 | 6-7/D | A820 | 1347.6
Rubber |  | 0 | +52.937 | +52.965 | 5/D | A774 | 10
Rubber |  | 0 | +52.778 | +52.803 | 4-5/D | A775 | 10
Steel Assembly | RIGID_FRAME | 56.1 | +52.964 | +53.145 | 5-6/D | A823 | 1347.6
Steel Assembly | RIGID_FRAME | 11.5 | +53.294 | +53.378 | 6-7/D | A815 | 173.8
Steel Assembly | RIGID_FRAME | 13.9 | +52.405 | +52.774 | 4/D | A818 | 5
Steel Assembly |  | 0 | +52.349 | +52.367 | 6-7/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.383 | +52.401 | 6-7/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.368 | +52.386 | 6-7/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.402 | +52.420 | 6-7/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.365 | +52.372 | 6-7/D-E | A690 | 30
Steel Assembly |  | 0 | +52.379 | +52.385 | 6-7/D-E | A690 | 30
Steel Assembly |  | 0 | +52.384 | +52.390 | 6-7/D-E | A690 | 30
Steel Assembly |  | 0 | +52.398 | +52.404 | 6-7/D-E | A690 | 30
Steel Assembly |  | 0 | +52.267 | +52.285 | 6-7/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.301 | +52.319 | 6-7/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.286 | +52.304 | 6-7/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.320 | +52.338 | 6-7/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.283 | +52.289 | 6-7/D-E | A690 | 30
Steel Assembly |  | 0 | +52.297 | +52.303 | 6-7/D-E | A690 | 30
Steel Assembly |  | 0 | +52.301 | +52.308 | 6-7/D-E | A690 | 30
Steel Assembly |  | 0 | +52.315 | +52.322 | 6-7/D-E | A690 | 30
2 x Steel Assembly |  | 0 | +52.143 | +52.161 | 5-6/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.177 | +52.195 | 5-6/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.159 | +52.165 | 5-6/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.173 | +52.179 | 5-6/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.162 | +52.180 | 6/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.196 | +52.214 | 6/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.178 | +52.184 | 6/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.192 | +52.198 | 6/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.020 | +52.038 | 5/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.053 | +52.072 | 5/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.035 | +52.042 | 5/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.049 | +52.056 | 5/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.038 | +52.057 | 5-6/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.072 | +52.091 | 5-6/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.054 | +52.061 | 5-6/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.068 | +52.075 | 5-6/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.349 | +52.367 | 6-7/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.383 | +52.401 | 6-7/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.368 | +52.386 | 6-7/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.402 | +52.420 | 6-7/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.365 | +52.372 | 6-7/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.379 | +52.385 | 6-7/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.384 | +52.390 | 6-7/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.398 | +52.404 | 6-7/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.267 | +52.285 | 6-7/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.301 | +52.319 | 6-7/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.286 | +52.304 | 6-7/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.320 | +52.338 | 6-7/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.283 | +52.289 | 6-7/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.297 | +52.303 | 6-7/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.301 | +52.308 | 6-7/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +52.315 | +52.322 | 6-7/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +51.772 | +51.791 | 4/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.806 | +51.824 | 4/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.791 | +51.809 | 4-5/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.825 | +51.843 | 4-5/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.896 | +51.914 | 4-5/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.930 | +51.948 | 4-5/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.915 | +51.933 | 4-5/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.949 | +51.967 | 4-5/C-D | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.788 | +51.795 | 4/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +51.802 | +51.809 | 4/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +51.807 | +51.813 | 4-5/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +51.821 | +51.827 | 4-5/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +51.912 | +51.918 | 4-5/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +51.926 | +51.932 | 4-5/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +51.931 | +51.937 | 4-5/C-D | A690 | 30
2 x Steel Assembly |  | 0 | +51.945 | +51.951 | 4-5/C-D | A690 | 30
Steel Assembly |  | 0 | +51.772 | +51.791 | 4/D-E | A691 | 27.72
Steel Assembly |  | 0 | +51.806 | +51.824 | 4/D-E | A691 | 27.72
Steel Assembly |  | 0 | +51.791 | +51.809 | 4-5/D-E | A691 | 27.72
Steel Assembly |  | 0 | +51.825 | +51.843 | 4-5/D-E | A691 | 27.72
Steel Assembly |  | 0 | +51.788 | +51.795 | 4/D-E | A690 | 30
Steel Assembly |  | 0 | +51.802 | +51.809 | 4/D-E | A690 | 30
Steel Assembly |  | 0 | +51.807 | +51.813 | 4-5/D-E | A690 | 30
Steel Assembly |  | 0 | +51.821 | +51.827 | 4-5/D-E | A690 | 30
Steel Assembly |  | 0 | +51.896 | +51.914 | 4-5/D-E | A691 | 27.72
Steel Assembly |  | 0 | +51.930 | +51.948 | 4-5/D-E | A691 | 27.72
Steel Assembly |  | 0 | +51.915 | +51.933 | 4-5/D-E | A691 | 27.72
Steel Assembly |  | 0 | +51.949 | +51.967 | 4-5/D-E | A691 | 27.72
Steel Assembly |  | 0 | +51.912 | +51.918 | 4-5/D-E | A690 | 30
Steel Assembly |  | 0 | +51.926 | +51.932 | 4-5/D-E | A690 | 30
Steel Assembly |  | 0 | +51.931 | +51.937 | 4-5/D-E | A690 | 30
Steel Assembly |  | 0 | +51.945 | +51.951 | 4-5/D-E | A690 | 30
Steel Assembly |  | 0 | +52.020 | +52.038 | 5/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.053 | +52.072 | 5/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.038 | +52.057 | 5-6/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.072 | +52.091 | 5-6/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.035 | +52.042 | 5/D-E | A690 | 30
Steel Assembly |  | 0 | +52.049 | +52.056 | 5/D-E | A690 | 30
Steel Assembly |  | 0 | +52.054 | +52.061 | 5-6/D-E | A690 | 30
Steel Assembly |  | 0 | +52.068 | +52.075 | 5-6/D-E | A690 | 30
Steel Assembly |  | 0 | +52.143 | +52.161 | 5-6/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.177 | +52.195 | 5-6/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.159 | +52.165 | 5-6/D-E | A690 | 30
Steel Assembly |  | 0 | +52.173 | +52.179 | 5-6/D-E | A690 | 30
Steel Assembly | RIGID_FRAME | 1.9 | +52.960 | +52.969 | 5/D | A821 | 5
Rubber_Curtain |  | 0 | +52.660 | +53.379 | 6-7/D | A776 | 10
Steel Assembly |  | 0 | +52.178 | +52.184 | 6/D-E | A690 | 30
Steel Assembly |  | 0 | +52.162 | +52.180 | 6/D-E | A691 | 27.72
Steel Assembly |  | 0 | +52.192 | +52.198 | 6/D-E | A690 | 30
Steel Assembly |  | 0 | +52.196 | +52.214 | 6/D-E | A691 | 27.72
2 x Steel Assembly | RIGID_FRAME | 3.2 | +52.721 | +52.885 | 6-7/D | A687 | 30
2 x Steel Assembly | RIGID_FRAME | 3.9 | +52.322 | +52.514 | 4-5/D | A689 | 30
Steel Assembly | RIGID_FRAME | 1.9 | +52.409 | +52.459 | 4/D | A819 | 5
Rubber_Curtain |  | 0 | +52.055 | +52.465 | 4/D | A777 | 10
2 x Steel Assembly | RIGID_FRAME | 3.4 | +52.798 | +52.947 | 4-5/D | A817 | 5
Steel Assembly | RIGID_FRAME | 1.9 | +52.788 | +52.797 | 4-5/D | A822 | 5
2 x Steel Assembly | RIGID_FRAME | 0.7 | +53.010 | +53.299 | 6-7/D | A816 | 5
Steel Assembly | RIGID_FRAME | 1.9 | +53.324 | +53.374 | 6-7/D | A819 | 5
2 x Steel Assembly | RIGID_FRAME | 2.1 | +52.845 | +52.967 | 6-7/D | A688 | 30
2 x Skirt Rubber |  | 0 | +52.275 | +53.016 | 4-7/D | A779 | 10
2 x Steel Assembly | RIGID_FRAME | 3.2 | +52.598 | +52.761 | 5-6/D | A687 | 30
2 x Steel Assembly | RIGID_FRAME | 3.2 | +52.474 | +52.638 | 4-6/D | A687 | 30
2 x Steel Assembly | RIGID_FRAME | 1.6 | +50.450 | +50.458 | 5/C-D | A806 | 8
Steel Assembly | RIGID_FRAME | 1.6 | +50.450 | +50.458 | 5/D-E | A806 | 8
Steel Assembly |  | 0 | +53.049 | +54.091 | 5-6/A-B | A177 | 160.28
2 x Steel Assembly | RIGID_FRAME | 9.3 | +51.216 | +51.994 | 5-6/B-C | A430 | 70
Steel Assembly | RIGID_FRAME | 9.3 | +51.216 | +51.994 | 5-6/A-B | A430 | 70
2 x Steel Assembly | RIGID_FRAME | 4.6 | +50.466 | +51.099 | 5/B-C | A649 | 60
Steel Assembly | RIGID_FRAME | 4.6 | +50.466 | +51.099 | 5/A-B | A649 | 60
Steel Assembly | RIGID_FRAME | 23.9 | +50.944 | +51.234 | 5/A-C | A40 | 289.898
2 x Liner Plate |  | 0 | +52.872 | +53.301 | 6-7/B | A835 | 16
2 x Liner Plate |  | 0 | +52.843 | +53.278 | 6-7/B | A832 | 16
2 x Liner Plate |  | 0 | +52.814 | +53.249 | 6-7/B | A832 | 16
2 x Liner Plate |  | 0 | +52.748 | +53.184 | 6-7/B | A832 | 16
2 x Liner Plate |  | 0 | +52.719 | +53.155 | 6/B | A832 | 16
2 x Liner Plate |  | 0 | +52.690 | +53.126 | 6/B | A832 | 16
2 x Liner Plate |  | 0 | +52.654 | +53.096 | 5-6/B | A834 | 16
2 x Liner Plate |  | 0 | +52.625 | +53.060 | 5-6/B | A832 | 16
2 x Liner Plate |  | 0 | +52.596 | +53.031 | 5-6/B | A832 | 16
2 x Liner Plate |  | 0 | +52.567 | +53.002 | 5-6/B | A832 | 16
2 x Liner Plate |  | 0 | +52.530 | +52.972 | 5-6/B | A834 | 16
2 x Liner Plate |  | 0 | +52.501 | +52.936 | 5/B | A832 | 16
2 x Liner Plate |  | 0 | +52.472 | +52.907 | 5/B | A832 | 16
2 x Liner Plate |  | 0 | +52.443 | +52.878 | 4-5/B | A832 | 16
2 x Liner Plate |  | 0 | +52.409 | +52.848 | 4-5/B | A833 | 16
2 x Liner Plate |  | 0 | +52.380 | +52.815 | 4-5/B | A832 | 16
2 x Liner Plate |  | 0 | +52.351 | +52.786 | 4-5/B | A832 | 16
2 x Liner Plate |  | 0 | +52.322 | +52.757 | 4-5/B | A832 | 16
2 x Liner Plate |  | 0 | +52.293 | +52.728 | 4-5/B | A832 | 16
2 x Rubber |  | 0 | +52.788 | +52.942 | 4-5/B | A778 | 10
Steel Assembly | RIGID_FRAME | 37.1 | +53.211 | +53.351 | 6-7/B | A814 | 847.6
Steel Assembly | RIGID_FRAME | 62.1 | +53.088 | +53.275 | 6-7/B | A820 | 1347.6
Rubber |  | 0 | +52.937 | +52.965 | 5/B | A774 | 10
Rubber |  | 0 | +52.778 | +52.803 | 4-5/B | A773 | 10
Steel Assembly | RIGID_FRAME | 56.1 | +52.964 | +53.145 | 5-6/B | A823 | 1347.6
Steel Assembly | RIGID_FRAME | 11.5 | +53.294 | +53.378 | 6-7/B | A815 | 173.8
Steel Assembly | RIGID_FRAME | 13.9 | +52.405 | +52.774 | 4/B | A818 | 5
2 x Steel Assembly |  | 0 | +52.349 | +52.367 | 6-7/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.383 | +52.401 | 6-7/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.368 | +52.386 | 6-7/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.402 | +52.420 | 6-7/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.365 | +52.372 | 6-7/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.379 | +52.385 | 6-7/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.384 | +52.390 | 6-7/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.398 | +52.404 | 6-7/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.267 | +52.285 | 6-7/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.301 | +52.319 | 6-7/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.286 | +52.304 | 6-7/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.320 | +52.338 | 6-7/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.283 | +52.289 | 6-7/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.297 | +52.303 | 6-7/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.301 | +52.308 | 6-7/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.315 | +52.322 | 6-7/B-C | A690 | 30
Steel Assembly |  | 0 | +52.143 | +52.161 | 5-6/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.177 | +52.195 | 5-6/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.159 | +52.165 | 5-6/A-B | A690 | 30
Steel Assembly |  | 0 | +52.173 | +52.179 | 5-6/A-B | A690 | 30
Steel Assembly |  | 0 | +52.162 | +52.180 | 6/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.196 | +52.214 | 6/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.178 | +52.184 | 6/A-B | A690 | 30
Steel Assembly |  | 0 | +52.192 | +52.198 | 6/A-B | A690 | 30
Steel Assembly |  | 0 | +52.020 | +52.038 | 5/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.053 | +52.072 | 5/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.035 | +52.042 | 5/A-B | A690 | 30
Steel Assembly |  | 0 | +52.049 | +52.056 | 5/A-B | A690 | 30
Steel Assembly |  | 0 | +52.038 | +52.057 | 5-6/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.072 | +52.091 | 5-6/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.054 | +52.061 | 5-6/A-B | A690 | 30
Steel Assembly |  | 0 | +52.068 | +52.075 | 5-6/A-B | A690 | 30
Steel Assembly |  | 0 | +52.349 | +52.367 | 6-7/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.383 | +52.401 | 6-7/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.368 | +52.386 | 6-7/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.402 | +52.420 | 6-7/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.365 | +52.372 | 6-7/A-B | A690 | 30
Steel Assembly |  | 0 | +52.379 | +52.385 | 6-7/A-B | A690 | 30
Steel Assembly |  | 0 | +52.384 | +52.390 | 6-7/A-B | A690 | 30
Steel Assembly |  | 0 | +52.398 | +52.404 | 6-7/A-B | A690 | 30
Steel Assembly |  | 0 | +52.267 | +52.285 | 6-7/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.301 | +52.319 | 6-7/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.286 | +52.304 | 6-7/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.320 | +52.338 | 6-7/A-B | A691 | 27.72
Steel Assembly |  | 0 | +52.283 | +52.289 | 6-7/A-B | A690 | 30
Steel Assembly |  | 0 | +52.297 | +52.303 | 6-7/A-B | A690 | 30
Steel Assembly |  | 0 | +52.301 | +52.308 | 6-7/A-B | A690 | 30
Steel Assembly |  | 0 | +52.315 | +52.322 | 6-7/A-B | A690 | 30
Steel Assembly |  | 0 | +51.772 | +51.791 | 4/A-B | A691 | 27.72
Steel Assembly |  | 0 | +51.806 | +51.824 | 4/A-B | A691 | 27.72
Steel Assembly |  | 0 | +51.791 | +51.809 | 4-5/A-B | A691 | 27.72
Steel Assembly |  | 0 | +51.825 | +51.843 | 4-5/A-B | A691 | 27.72
Steel Assembly |  | 0 | +51.896 | +51.914 | 4-5/A-B | A691 | 27.72
Steel Assembly |  | 0 | +51.930 | +51.948 | 4-5/A-B | A691 | 27.72
Steel Assembly |  | 0 | +51.915 | +51.933 | 4-5/A-B | A691 | 27.72
Steel Assembly |  | 0 | +51.949 | +51.967 | 4-5/A-B | A691 | 27.72
Steel Assembly |  | 0 | +51.788 | +51.795 | 4/A-B | A690 | 30
Steel Assembly |  | 0 | +51.802 | +51.809 | 4/A-B | A690 | 30
Steel Assembly |  | 0 | +51.807 | +51.813 | 4-5/A-B | A690 | 30
Steel Assembly |  | 0 | +51.821 | +51.827 | 4-5/A-B | A690 | 30
Steel Assembly |  | 0 | +51.912 | +51.918 | 4-5/A-B | A690 | 30
Steel Assembly |  | 0 | +51.926 | +51.932 | 4-5/A-B | A690 | 30
Steel Assembly |  | 0 | +51.931 | +51.937 | 4-5/A-B | A690 | 30
Steel Assembly |  | 0 | +51.945 | +51.951 | 4-5/A-B | A690 | 30
2 x Steel Assembly |  | 0 | +51.772 | +51.791 | 4/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.806 | +51.824 | 4/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.791 | +51.809 | 4-5/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.825 | +51.843 | 4-5/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.788 | +51.795 | 4/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +51.802 | +51.809 | 4/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +51.807 | +51.813 | 4-5/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +51.821 | +51.827 | 4-5/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +51.896 | +51.914 | 4-5/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.930 | +51.948 | 4-5/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.915 | +51.933 | 4-5/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.949 | +51.967 | 4-5/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +51.912 | +51.918 | 4-5/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +51.926 | +51.932 | 4-5/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +51.931 | +51.937 | 4-5/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +51.945 | +51.951 | 4-5/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.020 | +52.038 | 5/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.053 | +52.072 | 5/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.038 | +52.057 | 5-6/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.072 | +52.091 | 5-6/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.035 | +52.042 | 5/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.049 | +52.056 | 5/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.054 | +52.061 | 5-6/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.068 | +52.075 | 5-6/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.143 | +52.161 | 5-6/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.177 | +52.195 | 5-6/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.159 | +52.165 | 5-6/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.173 | +52.179 | 5-6/B-C | A690 | 30
Steel Assembly | RIGID_FRAME | 1.9 | +52.960 | +52.969 | 5/B | A821 | 5
Rubber_Curtain |  | 0 | +52.660 | +53.379 | 6-7/B | A776 | 10
2 x Steel Assembly |  | 0 | +52.178 | +52.184 | 6/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.162 | +52.180 | 6/B-C | A691 | 27.72
2 x Steel Assembly |  | 0 | +52.192 | +52.198 | 6/B-C | A690 | 30
2 x Steel Assembly |  | 0 | +52.196 | +52.214 | 6/B-C | A691 | 27.72
2 x Steel Assembly | RIGID_FRAME | 3.2 | +52.721 | +52.885 | 6-7/B | A687 | 30
2 x Steel Assembly | RIGID_FRAME | 3.9 | +52.322 | +52.514 | 4-5/B | A689 | 30
Steel Assembly | RIGID_FRAME | 1.9 | +52.409 | +52.459 | 4/B | A819 | 5
Rubber_Curtain |  | 0 | +52.055 | +52.465 | 4/B | A777 | 10
2 x Steel Assembly | RIGID_FRAME | 3.4 | +52.798 | +52.947 | 4-5/B | A817 | 5
Steel Assembly | RIGID_FRAME | 1.9 | +52.788 | +52.797 | 4-5/B | A821 | 5
2 x Steel Assembly | RIGID_FRAME | 0.7 | +53.010 | +53.299 | 6-7/B | A816 | 5
Steel Assembly | RIGID_FRAME | 1.9 | +53.324 | +53.374 | 6-7/B | A819 | 5
2 x Steel Assembly | RIGID_FRAME | 2.1 | +52.845 | +52.967 | 6-7/B | A688 | 30
2 x Skirt Rubber |  | 0 | +52.275 | +53.016 | 4-7/B | A779 | 10
2 x Steel Assembly | RIGID_FRAME | 3.2 | +52.598 | +52.761 | 5-6/B | A687 | 30
2 x Steel Assembly | RIGID_FRAME | 3.2 | +52.474 | +52.638 | 4-6/B | A687 | 30
Steel Assembly | RIGID_FRAME | 1.6 | +50.450 | +50.458 | 5/A-B | A806 | 8
2 x Steel Assembly | RIGID_FRAME | 1.6 | +50.450 | +50.458 | 5/B-C | A806 | 8
Steel Assembly | RIGID_FRAME | 147.6 | +56.721 | +57.387 | 12-13/C-D | A351 | 75.0311
Steel Assembly | RIGID_FRAME | 147.6 | +56.721 | +57.387 | 12-13/B-C | A350 | 75.0023
Steel Assembly | RIGID_FRAME | 147.6 | +56.721 | +57.387 | 12-13/A-B | A353 | 75.0244
Steel Assembly | RIGID_FRAME | 147.6 | +56.721 | +57.387 | 12-13/B-C | A351 | 75.0244
Steel Assembly | RIGID_FRAME | 147.6 | +56.721 | +57.387 | 12-13/D-E | A354 | 75.003
Steel Assembly | RIGID_FRAME | 147.6 | +56.721 | +57.387 | 12-13/A-B | A355 | 75.0006
Steel Assembly | RIGID_FRAME | 147.6 | +56.721 | +57.387 | 12-13/C-D | A350 | 75.0274
Steel Assembly | RIGID_FRAME | 147.6 | +56.721 | +57.387 | 12-13/D-E | A352 | 75.0268
Steel Assembly | RIGID_FRAME | 8.7 | +56.835 | +57.835 | 20/D-E | A548 | 641
Steel Assembly | RIGID_FRAME | 15.9 | +57.720 | +57.790 | 19-20/D-E | A223 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +56.835 | +57.835 | 19-20/D-E | A546 | 600
Steel Assembly | RIGID_FRAME | 8.7 | +56.835 | +57.835 | 20/C-D | A547 | 641
Steel Assembly | RIGID_FRAME | 15.9 | +57.720 | +57.790 | 19-20/C-D | A221 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +56.835 | +57.835 | 19-20/C-D | A546 | 600
Steel Assembly | RIGID_FRAME | 8.7 | +56.835 | +57.835 | 20/C-D | A548 | 641
Steel Assembly | RIGID_FRAME | 15.9 | +57.720 | +57.790 | 19-20/C-D | A223 | 70
Steel Assembly | RIGID_FRAME | 8.7 | +56.835 | +57.835 | 20/B-C | A547 | 641
Steel Assembly | RIGID_FRAME | 15.9 | +57.720 | +57.790 | 19-20/B-C | A221 | 70
2 x Steel Assembly | RIGID_FRAME | 8.2 | +56.835 | +57.835 | 19-20/B-C | A546 | 600
Steel Assembly | RIGID_FRAME | 8.7 | +56.835 | +57.835 | 20/B-C | A548 | 641
Steel Assembly | RIGID_FRAME | 15.9 | +57.720 | +57.790 | 19-20/B-C | A223 | 70
Steel Assembly | RIGID_FRAME | 8.7 | +56.835 | +57.835 | 20/A-B | A547 | 641
Steel Assembly | RIGID_FRAME | 15.9 | +57.720 | +57.790 | 19-20/A-B | A221 | 70
Steel Assembly | RIGID_FRAME | 8.2 | +56.835 | +57.835 | 19-20/A-B | A546 | 600
Steel Assembly | RIGID_FRAME | 8.2 | +57.320 | +58.360 | 15/A-B | A543 | 671
Steel Assembly | RIGID_FRAME | 30 | +57.161 | +57.881 | 19/D-E | A828 | 80.0052
2 x Steel Assembly | RIGID_FRAME | 30 | +57.161 | +57.881 | 19/C-D | A828 | 80.0052
2 x Steel Assembly | RIGID_FRAME | 30 | +57.161 | +57.881 | 19/B-C | A828 | 80.0052
Steel Assembly | RIGID_FRAME | 30 | +57.161 | +57.881 | 19/A-B | A828 | 80.0052
Steel Assembly | RIGID_FRAME | 30 | +57.995 | +58.715 | 20-21/D-E | A828 | 80.0053
2 x Steel Assembly | RIGID_FRAME | 30 | +57.995 | +58.715 | 20-21/C-D | A828 | 80.0053
2 x Steel Assembly | RIGID_FRAME | 30 | +57.995 | +58.715 | 20-21/B-C | A828 | 80.0053
Steel Assembly | RIGID_FRAME | 30 | +57.995 | +58.715 | 20-21/A-B | A828 | 80.0053
Steel Assembly | RIGID_FRAME | 127.2 | +56.735 | +57.307 | 19-20/D | A70 | 906
Steel Assembly | RIGID_FRAME | 127.2 | +56.735 | +57.307 | 19-20/C | A70 | 906
2 x Steel Assembly | RIGID_FRAME | 30 | +56.930 | +57.010 | 19-20/B-C | A827 | 80.0016
2 x Steel Assembly | RIGID_FRAME | 30 | +56.930 | +57.010 | 19-20/C-D | A827 | 80.0016
Steel Assembly | RIGID_FRAME | 30 | +56.930 | +57.010 | 19-20/D-E | A827 | 80.0016
Steel Assembly | RIGID_FRAME | 9.1 | +55.180 | +55.770 | 19-20/B-C | A750 | 62.0053
Steel Assembly | RIGID_FRAME | 30 | +56.930 | +57.010 | 19-20/A-B | A827 | 80.0016
Steel Assembly | RIGID_FRAME | 127.2 | +56.735 | +57.307 | 19-20/B | A70 | 906
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 17-18/D-E | A326 | 80
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 17-18/C-D | A327 | 80
Steel Assembly | RIGID_FRAME | 13.2 | +57.810 | +58.191 | 19/C-E | A474 | 973.192
Steel Assembly | RIGID_FRAME | 9.1 | +57.051 | +57.810 | 18-19/C-E | A473 | 120
Steel Assembly | RIGID_FRAME | 21.5 | +58.539 | +59.395 | 20-21/D-E | A657 | 856.28
Steel Assembly | RIGID_FRAME | 13.2 | +57.810 | +58.191 | 19/A-C | A474 | 973.192
Steel Assembly | RIGID_FRAME | 9.1 | +57.051 | +57.810 | 18-19/A-C | A473 | 120
Steel Assembly | RIGID_FRAME | 21.5 | +58.539 | +59.395 | 20-21/B-C | A657 | 856.28
Steel Assembly | RIGID_FRAME | 13.2 | +57.810 | +58.191 | 19/B-D | A474 | 973.192
Steel Assembly | RIGID_FRAME | 9.1 | +57.051 | +57.810 | 18-19/B-D | A473 | 120
Steel Assembly | RIGID_FRAME | 21.5 | +58.539 | +59.395 | 20-21/C-D | A657 | 856.28
Steel Assembly | RIGID_FRAME | 9.1 | +57.635 | +57.697 | 15-16/D-E | A750 | 62.0053
2 x Steel Assembly | RIGID_FRAME | 9.1 | +57.635 | +57.697 | 15-16/C-D | A750 | 62.0053
2 x Steel Assembly | RIGID_FRAME | 9.1 | +57.635 | +57.697 | 15-16/B-C | A750 | 62.0053
Steel Assembly | RIGID_FRAME | 9.1 | +57.635 | +57.697 | 15-16/A-B | A750 | 62.0053
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 17-18/B-C | A326 | 80
Steel Assembly | RIGID_FRAME | 24.5 | +57.270 | +58.317 | 17-18/A-B | A325 | 80
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 17-18/C-D | A326 | 80
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 17-18/B-C | A327 | 80
2 x Steel Assembly | RIGID_FRAME | 9.3 | +56.817 | +56.967 | 13/C-D | A771 | 200
2 x Steel Assembly | RIGID_FRAME | 9.3 | +56.817 | +56.967 | 13/B-C | A771 | 200
Steel Assembly | RIGID_FRAME | 9.3 | +56.817 | +56.967 | 13/D-E | A771 | 200
2 x Steel Assembly | RIGID_FRAME | 0 | +58.367 | +58.387 | 18-19/A-B | A839 | 5
2 x Steel Assembly | RIGID_FRAME | 1.5 | +58.261 | +58.411 | 18-19/A-B | A838 | 70
2 x Roller |  | 0 | +58.269 | +58.304 | 18-19/A-B | A674 | 35
2 x Steel Assembly | RIGID_FRAME | 0 | +58.120 | +58.140 | 18-19/A-B | A839 | 5
2 x Steel Assembly | RIGID_FRAME | 1.5 | +58.014 | +58.164 | 18-19/A-B | A838 | 70
2 x Roller |  | 0 | +58.022 | +58.057 | 18-19/A-B | A674 | 35
2 x Steel Assembly | RIGID_FRAME | 0 | +58.367 | +58.387 | 17-18/A-B | A839 | 5
2 x Steel Assembly | RIGID_FRAME | 1.5 | +58.261 | +58.411 | 17-18/A-B | A838 | 70
2 x Roller |  | 0 | +58.269 | +58.304 | 17-18/A-B | A674 | 35
2 x Steel Assembly | RIGID_FRAME | 0 | +58.120 | +58.140 | 17-18/A-B | A839 | 5
2 x Steel Assembly | RIGID_FRAME | 1.5 | +58.014 | +58.164 | 17-18/A-B | A838 | 70
2 x Roller |  | 0 | +58.022 | +58.057 | 17-18/A-B | A674 | 35
Steel Assembly | RIGID_FRAME | 0 | +58.120 | +58.140 | 16-17/A-B | A839 | 5
Steel Assembly | RIGID_FRAME | 1.5 | +58.014 | +58.164 | 16-17/A-B | A838 | 70
Roller |  | 0 | +58.022 | +58.057 | 16-17/A-B | A674 | 35
2 x Steel Assembly | RIGID_FRAME | 0 | +58.120 | +58.140 | 16-17/B-C | A839 | 5
2 x Steel Assembly | RIGID_FRAME | 1.5 | +58.014 | +58.164 | 16-17/B-C | A838 | 70
2 x Roller |  | 0 | +58.022 | +58.057 | 16-17/B-C | A674 | 35
4 x Steel Assembly | RIGID_FRAME | 0 | +58.120 | +58.140 | 17-18/B-C | A839 | 5
4 x Steel Assembly | RIGID_FRAME | 1.5 | +58.014 | +58.164 | 17-18/B-C | A838 | 70
4 x Roller |  | 0 | +58.022 | +58.057 | 17-18/B-C | A674 | 35
4 x Steel Assembly | RIGID_FRAME | 0 | +58.367 | +58.387 | 17-18/B-C | A839 | 5
4 x Steel Assembly | RIGID_FRAME | 1.5 | +58.261 | +58.411 | 17-18/B-C | A838 | 70
4 x Roller |  | 0 | +58.269 | +58.304 | 17-18/B-C | A674 | 35
4 x Steel Assembly | RIGID_FRAME | 0 | +58.120 | +58.140 | 18-19/B-C | A839 | 5
4 x Steel Assembly | RIGID_FRAME | 1.5 | +58.014 | +58.164 | 18-19/B-C | A838 | 70
4 x Roller |  | 0 | +58.022 | +58.057 | 18-19/B-C | A674 | 35
4 x Steel Assembly | RIGID_FRAME | 0 | +58.367 | +58.387 | 18-19/B-C | A839 | 5
4 x Steel Assembly | RIGID_FRAME | 1.5 | +58.261 | +58.411 | 18-19/B-C | A838 | 70
4 x Roller |  | 0 | +58.269 | +58.304 | 18-19/B-C | A674 | 35
2 x Steel Assembly | RIGID_FRAME | 0 | +58.120 | +58.140 | 16-17/C-D | A839 | 5
2 x Steel Assembly | RIGID_FRAME | 1.5 | +58.014 | +58.164 | 16-17/C-D | A838 | 70
2 x Roller |  | 0 | +58.022 | +58.057 | 16-17/C-D | A674 | 35
4 x Steel Assembly | RIGID_FRAME | 0 | +58.120 | +58.140 | 17-18/C-D | A839 | 5
4 x Steel Assembly | RIGID_FRAME | 1.5 | +58.014 | +58.164 | 17-18/C-D | A838 | 70
4 x Roller |  | 0 | +58.022 | +58.057 | 17-18/C-D | A674 | 35
4 x Steel Assembly | RIGID_FRAME | 0 | +58.367 | +58.387 | 17-18/C-D | A839 | 5
4 x Steel Assembly | RIGID_FRAME | 1.5 | +58.261 | +58.411 | 17-18/C-D | A838 | 70
4 x Roller |  | 0 | +58.269 | +58.304 | 17-18/C-D | A674 | 35
4 x Steel Assembly | RIGID_FRAME | 0 | +58.120 | +58.140 | 18-19/C-D | A839 | 5
4 x Steel Assembly | RIGID_FRAME | 1.5 | +58.014 | +58.164 | 18-19/C-D | A838 | 70
4 x Roller |  | 0 | +58.022 | +58.057 | 18-19/C-D | A674 | 35
4 x Steel Assembly | RIGID_FRAME | 0 | +58.367 | +58.387 | 18-19/C-D | A839 | 5
4 x Steel Assembly | RIGID_FRAME | 1.5 | +58.261 | +58.411 | 18-19/C-D | A838 | 70
4 x Roller |  | 0 | +58.269 | +58.304 | 18-19/C-D | A674 | 35
Steel Assembly | RIGID_FRAME | 0 | +58.120 | +58.140 | 16-17/D-E | A839 | 5
Steel Assembly | RIGID_FRAME | 1.5 | +58.014 | +58.164 | 16-17/D-E | A838 | 70
Roller |  | 0 | +58.022 | +58.057 | 16-17/D-E | A674 | 35
2 x Steel Assembly | RIGID_FRAME | 0 | +58.120 | +58.140 | 17-18/D-E | A839 | 5
2 x Steel Assembly | RIGID_FRAME | 1.5 | +58.014 | +58.164 | 17-18/D-E | A838 | 70
2 x Roller |  | 0 | +58.022 | +58.057 | 17-18/D-E | A674 | 35
2 x Steel Assembly | RIGID_FRAME | 0 | +58.367 | +58.387 | 17-18/D-E | A839 | 5
2 x Steel Assembly | RIGID_FRAME | 1.5 | +58.261 | +58.411 | 17-18/D-E | A838 | 70
2 x Roller |  | 0 | +58.269 | +58.304 | 17-18/D-E | A674 | 35
2 x Steel Assembly | RIGID_FRAME | 0 | +58.120 | +58.140 | 18-19/D-E | A839 | 5
2 x Steel Assembly | RIGID_FRAME | 1.5 | +58.014 | +58.164 | 18-19/D-E | A838 | 70
2 x Roller |  | 0 | +58.022 | +58.057 | 18-19/D-E | A674 | 35
2 x Steel Assembly | RIGID_FRAME | 0 | +58.367 | +58.387 | 18-19/D-E | A839 | 5
2 x Steel Assembly | RIGID_FRAME | 1.5 | +58.261 | +58.411 | 18-19/D-E | A838 | 70
2 x Roller |  | 0 | +58.269 | +58.304 | 18-19/D-E | A674 | 35
Steel Assembly | RIGID_FRAME | 0 | +58.367 | +58.387 | 19/A-B | A839 | 5
Steel Assembly | RIGID_FRAME | 1.5 | +58.261 | +58.411 | 19/A-B | A838 | 70
2 x Steel Assembly | RIGID_FRAME | 0 | +58.367 | +58.387 | 19/B-C | A839 | 5
2 x Steel Assembly | RIGID_FRAME | 1.5 | +58.261 | +58.411 | 19/B-C | A838 | 70
2 x Steel Assembly | RIGID_FRAME | 0 | +58.367 | +58.387 | 19/C-D | A839 | 5
2 x Steel Assembly | RIGID_FRAME | 1.5 | +58.261 | +58.411 | 19/C-D | A838 | 70
2 x Roller |  | 0 | +58.269 | +58.304 | 19/C-D | A674 | 35
Roller |  | 0 | +58.269 | +58.304 | 19/A-B | A674 | 35
2 x Roller |  | 0 | +58.269 | +58.304 | 19/B-C | A674 | 35
Steel Assembly | RIGID_FRAME | 0 | +58.367 | +58.387 | 19/D-E | A839 | 5
Steel Assembly | RIGID_FRAME | 1.5 | +58.261 | +58.411 | 19/D-E | A838 | 70
Roller |  | 0 | +58.269 | +58.304 | 19/D-E | A674 | 35
Steel Assembly | RIGID_FRAME | 11.3 | +57.335 | +57.893 | 19-20/D-E | A86 | 170
Steel Assembly | RIGID_FRAME | 11.3 | +57.335 | +57.893 | 19-20/C-D | A85 | 170
Steel Assembly | RIGID_FRAME | 30.8 | +57.345 | +57.565 | 19-20/C-E | A107 | 168.774
Steel Assembly | RIGID_FRAME | 11.3 | +57.335 | +57.893 | 19-20/B-C | A86 | 170
Steel Assembly | RIGID_FRAME | 11.3 | +57.335 | +57.893 | 19-20/A-B | A85 | 170
Steel Assembly | RIGID_FRAME | 30.8 | +57.345 | +57.565 | 19-20/A-C | A107 | 168.774
Steel Assembly | RIGID_FRAME | 11.3 | +57.335 | +57.893 | 19-20/C-D | A86 | 170
Steel Assembly | RIGID_FRAME | 11.3 | +57.335 | +57.893 | 19-20/B-C | A85 | 170
Steel Assembly | RIGID_FRAME | 9.9 | +57.791 | +58.411 | 15-16/B-C | A442 | 60
Steel Assembly | RIGID_FRAME | 25.8 | +57.791 | +58.024 | 15-16/A-C | A108 | 120
Steel Assembly | RIGID_FRAME | 25.8 | +57.791 | +58.024 | 15-16/C-E | A108 | 120
Steel Assembly | RIGID_FRAME | 30.8 | +57.345 | +57.565 | 19-20/B-D | A107 | 168.774
Steel Assembly | RIGID_FRAME | 25.8 | +57.791 | +58.024 | 15-16/B-D | A108 | 120
Steel Assembly | RIGID_FRAME | 10.8 | +56.735 | +57.790 | 19-20/D-E | A292 | 140
Steel Assembly | RIGID_FRAME | 10.8 | +56.735 | +57.790 | 19-20/C-D | A293 | 140
Steel Assembly | RIGID_FRAME | 10.8 | +56.735 | +57.790 | 20/D-E | A293 | 140.002
Steel Assembly | RIGID_FRAME | 15.4 | +57.145 | +57.215 | 19-20/D-E | A222 | 70
Steel Assembly | RIGID_FRAME | 10.8 | +56.735 | +57.790 | 20/C-D | A292 | 140.002
Steel Assembly | RIGID_FRAME | 15.4 | +57.145 | +57.215 | 19-20/C-D | A220 | 70
Steel Assembly | RIGID_FRAME | 10.8 | +56.735 | +57.790 | 19-20/C-D | A292 | 140
Steel Assembly | RIGID_FRAME | 10.8 | +56.735 | +57.790 | 19-20/B-C | A293 | 140
Steel Assembly | RIGID_FRAME | 10.8 | +56.735 | +57.790 | 20/C-D | A293 | 140.002
Steel Assembly | RIGID_FRAME | 15.4 | +57.145 | +57.215 | 19-20/C-D | A222 | 70
Steel Assembly | RIGID_FRAME | 10.8 | +56.735 | +57.790 | 20/B-C | A292 | 140.002
Steel Assembly | RIGID_FRAME | 15.4 | +57.145 | +57.215 | 19-20/B-C | A220 | 70
Steel Assembly | RIGID_FRAME | 10.8 | +56.735 | +57.790 | 19-20/B-C | A292 | 140
Steel Assembly | RIGID_FRAME | 10.8 | +56.735 | +57.790 | 19-20/A-B | A293 | 140
Steel Assembly | RIGID_FRAME | 10.8 | +56.735 | +57.790 | 20/B-C | A293 | 140.002
Steel Assembly | RIGID_FRAME | 15.4 | +57.145 | +57.215 | 19-20/B-C | A222 | 70
Steel Assembly | RIGID_FRAME | 10.8 | +56.735 | +57.790 | 20/A-B | A292 | 140
Steel Assembly | RIGID_FRAME | 15.4 | +57.145 | +57.215 | 19-20/A-B | A220 | 70
Steel Assembly | RIGID_FRAME | 46.2 | +58.317 | +58.477 | 16/A-C | A425 | 205
Steel Assembly | RIGID_FRAME | 46.2 | +58.317 | +58.477 | 16/C-E | A425 | 205
Steel Assembly | RIGID_FRAME | 21.1 | +57.110 | +57.270 | 16-17/C-D | A52 | 150
Steel Assembly | RIGID_FRAME | 21.1 | +57.110 | +57.270 | 17-18/C-D | A52 | 150
Steel Assembly | RIGID_FRAME | 10.5 | +57.307 | +57.323 | 19-20/D | A831 | 16
Steel Assembly | RIGID_FRAME | 10.5 | +57.307 | +57.323 | 20/D | A831 | 16.0001
Steel Assembly | RIGID_FRAME | 10.5 | +57.307 | +57.323 | 19-20/C | A831 | 16
Steel Assembly | RIGID_FRAME | 10.5 | +57.307 | +57.323 | 20/C | A831 | 16.0001
Steel Assembly | RIGID_FRAME | 10.5 | +57.307 | +57.323 | 19-20/B | A831 | 16
Steel Assembly | RIGID_FRAME | 10.5 | +57.307 | +57.323 | 20/B | A831 | 16.0001
2 x Steel Assembly | RIGID_FRAME | 14.9 | +56.759 | +58.285 | 17-19/C-D | A295 | 80
2 x Rubber |  | 0 | +58.266 | +58.316 | 16-17/D-E | A837 | 28
Steel Assembly | RIGID_FRAME | 0.7 | +58.266 | +58.399 | 16-17/D-E | A772 | 10
4 x Rubber |  | 0 | +58.266 | +58.316 | 16-17/C-D | A837 | 28
2 x Steel Assembly | RIGID_FRAME | 0.7 | +58.266 | +58.399 | 16-17/C-D | A772 | 10
Steel Assembly | RIGID_FRAME | 0.7 | +58.183 | +58.316 | 16-17/D-E | A772 | 10
2 x Steel Assembly | RIGID_FRAME | 0.7 | +58.183 | +58.316 | 16-17/C-D | A772 | 10
