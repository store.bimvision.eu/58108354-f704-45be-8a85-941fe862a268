Properties of the parts of a building model (IFC2X3), part 6 of 16

# IfcDiscreteAccessory: DUMMY (4163)
Name | Description | Material | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x DUMMY | L70*70*6 | STEEL/S355JR | +52.227 | +52.297 | 11 | 2 | 9.6 | 0.1 | 42.7 | 0.3 | 70 | 70 | 1500 | m54 | 0.408411 | 0.408411 | 0.000812739 | 0.001206 | 0.00121911
3 x DUMMY | L70*70*6 | STEEL/S355JR | +53.627 | +53.697 | 11 | 2 | 9.6 | 0.1 | 42.7 | 0.3 | 70 | 70 | 1500 | m51 | 0.408411 | 0.408411 | 0.000812739 | 0.001206 | 0.00121911
DUMMY | C160*65 | STEEL/S355JR | +53.537 | +53.697 | 11 | 2 | 28.3 | 0.1 | 29.3 | 0.9 | 160 | 65 | 1496 | m444 | 0.824693 | 0.824693 | 0.00240764 | 0.00355005 | 0.00360183
3 x DUMMY | PC200*75 | STEEL/S355JR | +50.387 | +50.462 | 11 | 2 | 36.4 | 0.3 | 27.8 | 0.9 | 200 | 75 | 1500 | m465 | 1.01282 | 1.01282 | 0.00309554 | 0.0045585 | 0.00464331
3 x DUMMY | L100*100*8 | STEEL/S355JR | +50.254 | +56.734 | 11 | 2 | 79.1 | 0 | 32 | 2.6 | 100 | 100 | 6480 | m382 | 2.52525 | 2.52525 | 0.00155414 | 0.00995328 | 0.0100708
3 x DUMMY | L100*100*8 | STEEL/S355JR | +50.262 | +56.742 | 11 | 2 | 79.1 | 0 | 32 | 2.6 | 100 | 100 | 6480 | m380 | 2.52525 | 2.52525 | 0.00155414 | 0.00995328 | 0.0100708
DUMMY | PLT3*964 | STEEL/S355JR | +52.699 | +52.702 | 11 | 2 | 26.8 | 1.1 | 85.3 | 2.3 | 964 | 3 | 1180 | p390 | 2.28791 | 1.13752 | 0.000009 | 0.00341256 | 0.00341256
2 x DUMMY | L70*70*6 | STEEL/S355JR | +52.227 | +52.297 | 11 | 2 | 9.6 | 0.1 | 42.7 | 0.3 | 70 | 70 | 1500 | m52 | 0.408411 | 0.408411 | 0.000812739 | 0.001206 | 0.00121911
2 x DUMMY | C160*65 | STEEL/S355JR | +53.537 | +53.697 | 11 | 2 | 28.3 | 0.1 | 29.3 | 0.9 | 160 | 65 | 1496 | m443 | 0.824693 | 0.824693 | 0.00240764 | 0.00355005 | 0.00360183
DUMMY | C160*65 | STEEL/S355JR | +53.537 | +53.697 | 11 | 2 | 11.1 | 0 | 29.3 | 0.3 | 160 | 65 | 591.5 | m445 | 0.326074 | 0.326074 | 0.00240764 | 0.00132416 | 0.00142412
2 x DUMMY | PL3*970 | STEEL/S355JR | +51.065 | +52.699 | 11 | 2 | 37.3 | 0 | 85.3 | 3.2 | 970 | 3 | 1634 | p330 | 3.18559 | 1.58498 | 0.000009 | 0.00475495 | 0.00475495
DUMMY | PLT3*967 | STEEL/S355JR | +51.062 | +51.065 | 11 | 2 | 26.9 | 1.1 | 85.3 | 2.3 | 967 | 3 | 1180 | p391 | 2.295 | 1.14106 | 0.000009 | 0.00342318 | 0.00342318
DUMMY | C160*65 | STEEL/S355JR | +53.537 | +53.697 | 11 | 2 | 18.9 | 0.1 | 29.3 | 0.6 | 160 | 65 | 1000 | m442 | 0.551266 | 0.551266 | 0.00240764 | 0.00237303 | 0.00240764
DUMMY | C160*65 | STEEL/S355JR | +53.537 | +53.697 | 11 | 2 | 42.5 | 0.1 | 29.3 | 1.3 | 160 | 65 | 2250 | m449 | 1.24035 | 1.24035 | 0.00240764 | 0.00533932 | 0.0054172
DUMMY | C160*65 | STEEL/S355JR | +53.537 | +53.697 | 11 | 2 | 47.2 | 0.2 | 29.3 | 1.4 | 160 | 65 | 2500 | m441 | 1.37816 | 1.37816 | 0.00240764 | 0.00593257 | 0.00601911
6 x DUMMY | PLATE20*216 | STEEL/S355JR | +53.762 | +54.082 | 11 | 2 | 8.8 | 0 | 14.8 | 0.1 | 215.9 | 20 | 320 | A782 | 0.130161 | 0.15968 | 0.00432 | 0.00111441 | 0.0013824
DUMMY | FL10*65 | STEEL/S355JR | +50.252 | +53.757 | 11 | 2 | 17.9 | 0 | 29.5 | 0.5 | 65 | 10 | 3505 | p9 | 0.526791 | 0.526791 | 0.00065 | 0.0022769 | 0.0022769

# IfcDiscreteAccessory: Duct (3)
In: Undefined
Description: FL6*50; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +53.268; Top elevation: +53.275; Phase: 6; Class: 99
Tekla Quantity - Weight: 1.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 48 m2; Net surface area: 0.1 m2; Height: 50 mm; Width: 6 mm
BaseQuantities - CrossSectionArea: 0.0003 m2
Pset_PlateCommon - LoadBearing: yes; Reference: p664
Name | Length (mm) | NetArea (m2) = GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x Duct | 612 | 0.0691404 | 0.00018359
Duct | 612.1 | 0.0691522 | 0.000183622

# IfcDiscreteAccessory: Dummy (183)
In: Undefined
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Material | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Area per tons (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x Dummy | FL8*70 | STEEL/S355JR | +50.932 | +51.002 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
8 x Dummy | FL10*60 | MISCELLANEOUS/COMPONENT | +51.017 | +51.027 | 7 | 6 | 0 |  | 60 | 10 | 160 | Dummy11 | 0.0236 | 0.0236 | 0.0016 | 0.000096
5 x Dummy | FL8*70 | STEEL/S355JR | +51.105 | +51.189 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
5 x Dummy | FL8*70 | STEEL/S355JR | +51.228 | +51.312 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +51.119 | +51.203 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +51.243 | +51.326 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
3 x Dummy | FL6*40 | STEEL/S355JR | +52.102 | +52.142 | 25 | 2 | 0.2 | 51.8 | 40 | 6 | 85 | p653 | 0.0082999 | 0.00339996 | 0.000036 | 0.0000203998
3 x Dummy | FL5*40 | STEEL/S355JR | +51.448 | +51.488 | 25 | 2 | 0.7 | 57.8 | 40 | 5 | 520 | p569 | 0.0472 | 0.0472 | 0.0002 | 0.000104
Dummy | FL5*40 | STEEL/S355JR | +51.448 | +51.488 | 25 | 2 | 0.7 | 57.8 | 40 | 5 | 516 | p568 | 0.046841 | 0.046841 | 0.0002 | 0.000103202
Dummy | FL8*70 | STEEL/S355JR | +54.859 | +54.943 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +54.942 | +55.026 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +55.064 | +55.148 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +55.189 | +55.273 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +55.312 | +55.396 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +55.436 | +55.519 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +55.559 | +55.643 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +55.683 | +55.767 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +55.765 | +55.849 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +57.272 | +57.346 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +55.851 | +55.935 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +56.427 | +56.510 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +56.725 | +56.806 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +56.794 | +56.873 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +51.090 | +51.174 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +51.214 | +51.298 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +57.295 | +57.369 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +57.163 | +57.240 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +57.098 | +57.175 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +57.025 | +57.103 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +56.945 | +57.024 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +56.857 | +56.936 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +56.656 | +56.738 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +56.545 | +56.628 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +55.933 | +56.017 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +56.057 | +56.141 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +56.181 | +56.265 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +56.304 | +56.388 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +54.774 | +54.858 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +53.867 | +53.951 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +53.950 | +54.033 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +54.073 | +54.157 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +54.197 | +54.281 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +54.691 | +54.775 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +54.568 | +54.651 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +54.444 | +54.528 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +54.320 | +54.404 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +53.781 | +53.865 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +52.875 | +52.959 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +52.957 | +53.041 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +53.081 | +53.165 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +53.205 | +53.288 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +53.699 | +53.783 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +53.575 | +53.659 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +53.452 | +53.536 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +53.328 | +53.412 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +52.789 | +52.873 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +51.883 | +51.966 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +51.965 | +52.049 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +52.088 | +52.172 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +52.212 | +52.296 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +52.707 | +52.791 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +52.583 | +52.667 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +52.460 | +52.543 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +52.336 | +52.419 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +51.793 | +51.877 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +51.670 | +51.754 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +51.299 | +51.383 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +51.423 | +51.506 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +51.546 | +51.630 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
2 x Dummy | FL8*70 | STEEL/S355JR | +57.221 | +57.297 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +56.793 | +56.874 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +56.857 | +56.937 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +57.272 | +57.346 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +57.295 | +57.369 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +56.427 | +56.511 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | p507 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +55.766 | +55.850 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +54.859 | +54.943 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +54.942 | +55.026 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +55.065 | +55.149 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +55.189 | +55.273 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +55.684 | +55.767 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +55.560 | +55.644 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +55.436 | +55.520 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +55.313 | +55.397 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +54.774 | +54.857 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
Dummy | FL8*70 | STEEL/S355JR | +52.707 | +52.790 | 7 | 46 | 0.7 | 37 | 70 | 8 | 170 | HR17 | 0.02764 | 0.02764 | 0.00056 | 0.0000952
18 x Dummy | FL8*70 | MISCELLANEOUS/COMPONENT | +57.160 | +57.230 | 7 | 46 | 0 |  | 70 | 8 | 160 | Dummy12 | 0.02608 | 0.0112 | 0.000064 | 0.0000896
2 x Dummy | FL8*70 | MISCELLANEOUS/COMPONENT | +57.165 | +57.235 | 7 | 99 | 0 |  | 70 | 8 | 160 | m470 | 0.02608 | 0.0112 | 0.000064 | 0.0000896
2 x Dummy | PLT10*59.5 | MISCELLANEOUS/COMPONENT | +57.040 | +57.171 | 7 | 47 | 0 |  | 59.5 | 10 | 190 | Dummy10 | 0.027592 | 0.027592 | 0.0019 | 0.000113012
8 x Dummy | FL10*60 | MISCELLANEOUS/COMPONENT | +50.538 | +50.668 | 7 | 47 | 0 |  | 60 | 10 | 190 | Dummy10 | 0.0278 | 0.0278 | 0.0019 | 0.000114

# IfcDiscreteAccessory: Dummy_Beam (2)
In: Undefined
Description: FL40*300; Material: STEEL/S355JR
Tekla Common - Phase: 3; Class: 2
Tekla Quantity - Weight: 1576.3 kg; Volume: 0.2 m3; Gross footprint area: 5 m2; Area per tons: 7.2 m2; Net surface area: 11.4 m2; Height: 300 mm; Width: 40 mm; Length: 16734 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - NetArea: 11.4031 m2; GrossArea: 11.4031 m2; CrossSectionArea: 0.012 m2; NetVolume: 0.200808 m3; GrossVolume: 0.200808 m3
Name | Bottom elevation | Top elevation | Reference
Dummy_Beam | +55.735 | +55.775 | Dummy9002
Dummy_Beam | +56.695 | +56.735 | Dummy9003

# IfcDiscreteAccessory: Dummy_Plate (2)
In: Undefined
Description: PL50*400; Material: MISCELLANEOUS/ZERO
Tekla Common - Phase: 12; Class: 2
Tekla Quantity - Weight: 0 kg; Volume: 0.4 m3; Gross footprint area: 6.7 m2; Net surface area: 15.1 m2; Height: 400 mm; Width: 50 mm; Length: 16734 mm
Pset_PlateCommon - LoadBearing: yes; Reference: m662
BaseQuantities - NetArea: 15.1006 m2; GrossArea: 15.1006 m2; CrossSectionArea: 0.02 m2; NetVolume: 0.33468 m3; GrossVolume: 0.33468 m3
Name | Bottom elevation | Top elevation
Dummy_Plate | +55.035 | +55.085
Dummy_Plate | +56.185 | +56.235

# IfcDiscreteAccessory: Frame
In: Undefined
Description: L70*70*6; Material: STEEL/S355JR
Tekla Quantity - Weight: 11 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 42.7 m2; Net surface area: 0.5 m2; Height: 70 mm; Width: 70 mm; Length: 1725 mm
Tekla Common - Bottom elevation: +58.150; Top elevation: +58.220; Phase: 9; Class: 3
Pset_PlateCommon - LoadBearing: yes; Reference: m86
BaseQuantities - NetArea: 0.469674 m2; GrossArea: 0.469674 m2; CrossSectionArea: 0.000812739 m2; NetVolume: 0.0013869 m3; GrossVolume: 0.00140198 m3

# IfcDiscreteAccessory: Gantry (6)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Phase: 2; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) = Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x Gantry | L80*80*8 | +56.736 | +57.762 | 115.7 | 32.3 | 3.8 | 80 | 12017.9 | m885 | 3.74258 | 0.00122675 | 0.0146142 | 0.014743
Gantry | L60*60*8 | +51.215 | +51.859 | 50.2 | 32.9 | 1.7 | 60 | 7084.4 | m765 | 1.6516 | 0.000903185 | 0.00634761 | 0.00639851
2 x Gantry | L60*60*8 | +51.215 | +51.859 | 50.2 | 32.9 | 1.7 | 60 | 7084.4 | m766 | 1.6516 | 0.000903185 | 0.00634761 | 0.00639851

# IfcDiscreteAccessory: Guard (7)
In: Undefined
Description: L75*50*6; Material: STEEL/S355JR
Tekla Common - Phase: 5; Class: 3
Tekla Quantity - Weight: 4.4 kg; Volume: 0 m3; Area per tons: 43.2 m2; Net surface area: 0.2 m2; Height: 75 mm; Width: 50 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.000719745 m2
Name | Bottom elevation | Top elevation | Gross footprint area (m2) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x Guard | +58.545 | +58.608 | 0 | 788.7 | m689 | 0.192425 | 0.000562634 | 0.000567632
3 x Guard | +58.545 | +58.608 | 0 | 788.7 | m688 | 0.192425 | 0.000562634 | 0.000567632
Guard | +59.345 | +59.395 | 0.1 | 788 | m687 | 0.192249 | 0.000562586 | 0.000567113

# IfcDiscreteAccessory: HANDRAIL (56)
In: Undefined
Material: MISCELLANEOUS/COMPONENT
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
HANDRAIL | CHS34*2.5 | +57.572 | +57.787 | 1 | 40 | 0 | 34 | 34 | 381.4 | m615 | 0.0404828 | 0.0404828 | 0.00023625 | 0.0000899414 | 0.0000899414
HANDRAIL | CHS34*2.5 | +58.072 | +58.287 | 1 | 40 | 0 | 34 | 34 | 381.9 | m615 | 0.0405396 | 0.0405396 | 0.00023625 | 0.0000900684 | 0.0000900684
3 x HANDRAIL | CHS34*2.5 | +53.516 | +53.574 | 6 | 41 | 0.1 | 34 | 34 | 557 | m611 | 0.0589835 | 0.0589835 | 0.00023625 | 0.000131273 | 0.000131273
3 x HANDRAIL | CHS34*2.5 | +54.017 | +54.076 | 6 | 41 | 0.1 | 34 | 34 | 557 | m611 | 0.0589835 | 0.0589835 | 0.00023625 | 0.000131273 | 0.000131273
3 x HANDRAIL | CHS34*2.5 | +53.446 | +53.504 | 6 | 41 | 0.1 | 34 | 34 | 557.1 | m611 | 0.0589948 | 0.0589948 | 0.00023625 | 0.000131299 | 0.000131299
3 x HANDRAIL | CHS34*2.5 | +53.947 | +54.006 | 6 | 41 | 0.1 | 34 | 34 | 557.1 | m611 | 0.0589948 | 0.0589948 | 0.00023625 | 0.000131299 | 0.000131299
3 x HANDRAIL | CHS34*2.5 | +54.042 | +54.076 | 6 | 40 | 0.1 | 34 | 34 | 1316.5 | m589 | 0.139275 | 0.139275 | 0.00023625 | 0.000311022 | 0.000311022
3 x HANDRAIL | CHS34*2.5 | +53.540 | +53.574 | 6 | 40 | 0.1 | 34 | 34 | 1316.5 | m589 | 0.139275 | 0.139275 | 0.00023625 | 0.000311023 | 0.000311023
3 x HANDRAIL | CHS34*2.5 | +53.398 | +53.550 | 6 | 40 | 0.2 | 34 | 34 | 1426.5 | m588 | 0.150895 | 0.150895 | 0.00023625 | 0.000337021 | 0.000337021
3 x HANDRAIL | CHS34*2.5 | +53.972 | +54.006 | 6 | 40 | 0 | 34 | 34 | 286.5 | m587 | 0.0305088 | 0.0305088 | 0.00023625 | 0.0000676855 | 0.0000676855
3 x HANDRAIL | CHS34*2.5 | +53.471 | +53.504 | 6 | 40 | 0 | 34 | 34 | 286.5 | m587 | 0.0305089 | 0.0305089 | 0.00023625 | 0.0000676857 | 0.0000676857
3 x HANDRAIL | CHS34*2.5 | +53.896 | +54.051 | 6 | 40 | 0.2 | 34 | 34 | 1468.3 | m585 | 0.155303 | 0.155303 | 0.00023625 | 0.000346881 | 0.000346881
3 x HANDRAIL | CHS34*2.5 | +53.896 | +53.981 | 6 | 40 | 0.1 | 34 | 34 | 611.7 | m584 | 0.064846 | 0.064846 | 0.00023625 | 0.000144506 | 0.000144506
3 x HANDRAIL | FL10*60 | +53.049 | +53.072 | 6 | 6 | 0 | 60 | 10 | 160 | HR86 | 0.0236 | 0.0236 | 0.0016 | 0.000096 | 0.000096
3 x HANDRAIL | FL10*60 | +53.009 | +53.032 | 6 | 6 | 0 | 60 | 10 | 160 | HR86 | 0.0236 | 0.0236 | 0.0016 | 0.000096 | 0.000096
6 x HANDRAIL | FL10*60 | +52.910 | +52.933 | 6 | 6 | 0 | 60 | 10 | 160 | HR86 | 0.0236 | 0.0236 | 0.0016 | 0.000096 | 0.000096
3 x HANDRAIL | CHS43*3 | +52.925 | +53.946 | 6 | 48 | 0.1 | 60 | 60 | 1020 | m425 | 0.143028 | 0.144364 | 0.00036 | 0.000755999 | 0.000759599
2 x HANDRAIL | CHS43*3 | +53.024 | +54.045 | 6 | 48 | 0.1 | 60 | 60 | 1020 | m425 | 0.143028 | 0.144364 | 0.00036 | 0.000755998 | 0.000759599
3 x HANDRAIL | CHS43*3 | +52.925 | +53.946 | 6 | 48 | 0.1 | 60 | 60 | 1020 | m425 | 0.143028 | 0.144364 | 0.00036 | 0.000755998 | 0.000759598
HANDRAIL | CHS43*3 | +53.024 | +54.045 | 6 | 48 | 0.1 | 60 | 60 | 1020 | m425 | 0.143028 | 0.144364 | 0.00036 | 0.000755998 | 0.0007596

# IfcDiscreteAccessory: HB (516)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x HB | L50*50*4 | +56.767 | +56.887 | 2 | 5 | 5 | 63.4 | 0.3 | 50 | 50 | 1643 | m868 | 0.318726 | 0.000389809 | 0.000614558 | 0.000640454
3 x HB | L50*50*4 | +55.735 | +55.852 | 2 | 5 | 4.7 | 63.4 | 0.3 | 50 | 50 | 1545.9 | m847 | 0.299887 | 0.000389809 | 0.000569775 | 0.000602598
3 x HB | L50*50*4 | +55.642 | +55.757 | 2 | 5 | 4.8 | 63.4 | 0.3 | 50 | 50 | 1561.1 | m841 | 0.302841 | 0.000389809 | 0.000577104 | 0.000608534
3 x HB | L50*50*4 | +54.742 | +54.859 | 2 | 5 | 4.8 | 63.4 | 0.3 | 50 | 50 | 1565.6 | m846 | 0.303713 | 0.000389809 | 0.000579342 | 0.000610286
3 x HB | L50*50*4 | +52.664 | +52.780 | 2 | 5 | 4.8 | 63.4 | 0.3 | 50.1 | 50 | 1566 | m866 | 0.303794 | 0.000389809 | 0.000579374 | 0.000610449
3 x HB | L50*50*4 | +57.640 | +57.748 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1662.4 | m821 | 0.322483 | 0.000389809 | 0.000621851 | 0.000648003
3 x HB | L50*50*4 | +57.716 | +57.818 | 2 | 5 | 5 | 63.4 | 0.3 | 50 | 50 | 1633.4 | m822 | 0.31686 | 0.000389809 | 0.000608785 | 0.000636703
3 x HB | L50*50*4 | +57.192 | +57.260 | 2 | 5 | 4.7 | 63.4 | 0.3 | 50 | 50 | 1532.6 | m860 | 0.297306 | 0.000389809 | 0.000568236 | 0.000597411
2 x HB | L50*50*4 | +56.223 | +56.346 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1658.2 | m859 | 0.321678 | 0.000389809 | 0.0006193 | 0.000646385
3 x HB | L50*50*4 | +56.608 | +56.710 | 2 | 5 | 4.8 | 63.4 | 0.3 | 50 | 50 | 1567.6 | m855 | 0.30411 | 0.000389809 | 0.000576316 | 0.000611083
3 x HB | L50*50*4 | +56.538 | +56.650 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1658.8 | m842 | 0.321795 | 0.000389809 | 0.000619495 | 0.000646621
3 x HB | L50*50*4 | +56.461 | +56.582 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m844 | 0.331192 | 0.000389809 | 0.000645386 | 0.000665502
3 x HB | L50*50*4 | +56.385 | +56.504 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m842 | 0.321836 | 0.000389809 | 0.000619703 | 0.000646702
3 x HB | L50*50*4 | +56.304 | +56.429 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.5 | m844 | 0.331249 | 0.000389809 | 0.000645608 | 0.000665617
3 x HB | L50*50*4 | +57.569 | +57.684 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.7 | m830 | 0.326243 | 0.000389809 | 0.000630352 | 0.000655558
3 x HB | L50*50*4 | +57.494 | +57.613 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326247 | 0.000389809 | 0.000630434 | 0.000655565
3 x HB | L50*50*4 | +57.422 | +57.538 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.32625 | 0.000389809 | 0.00063038 | 0.000655571
3 x HB | L50*50*4 | +57.339 | +57.466 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1682.4 | m856 | 0.326362 | 0.000389809 | 0.000630319 | 0.000655797
3 x HB | L50*50*4 | +56.682 | +56.783 | 2 | 5 | 4.8 | 63.4 | 0.3 | 50 | 50 | 1567.5 | m814 | 0.304081 | 0.000389809 | 0.000573937 | 0.000611026
3 x HB | L50*50*4 | +56.738 | +56.845 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1705.2 | m848 | 0.330795 | 0.000389809 | 0.000636249 | 0.000664704
3 x HB | L50*50*4 | +56.800 | +56.902 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1655.5 | m849 | 0.321155 | 0.000389809 | 0.000616402 | 0.000645335
3 x HB | L50*50*4 | +56.856 | +56.957 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.5 | m850 | 0.331234 | 0.000389809 | 0.0006371 | 0.000665588
3 x HB | L50*50*4 | +56.911 | +57.007 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1656 | m849 | 0.321254 | 0.000389809 | 0.000616601 | 0.000645534
3 x HB | L50*50*4 | +56.961 | +57.056 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m850 | 0.331197 | 0.000389809 | 0.000637092 | 0.000665513
3 x HB | L50*50*4 | +57.010 | +57.098 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m842 | 0.321839 | 0.000389809 | 0.000619758 | 0.000646709
3 x HB | L50*50*4 | +57.052 | +57.140 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.5 | m844 | 0.331231 | 0.000389809 | 0.000645543 | 0.000665581
3 x HB | L50*50*4 | +57.094 | +57.177 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1655.8 | m851 | 0.321203 | 0.000389809 | 0.000618656 | 0.000645431
3 x HB | L50*50*4 | +57.131 | +57.212 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.6 | m844 | 0.331262 | 0.000389809 | 0.000645599 | 0.000665643
3 x HB | L50*50*4 | +57.164 | +57.239 | 2 | 5 | 5 | 63.4 | 0.3 | 50 | 50 | 1642.2 | m852 | 0.318567 | 0.000389809 | 0.000617303 | 0.000640134
3 x HB | L50*50*4 | +57.775 | +57.879 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326246 | 0.000389809 | 0.000630347 | 0.000655564
3 x HB | L50*50*4 | +57.836 | +57.938 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.7 | m825 | 0.326241 | 0.000389809 | 0.000630359 | 0.000655553
HB | L50*50*4 | +57.894 | +57.991 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326263 | 0.000389809 | 0.000630421 | 0.000655599
3 x HB | L50*50*4 | +57.947 | +58.043 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326249 | 0.000389809 | 0.000630381 | 0.000655569
3 x HB | L50*50*4 | +57.998 | +58.091 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.32627 | 0.000389809 | 0.000630388 | 0.000655613
3 x HB | L50*50*4 | +58.045 | +58.135 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1684.8 | m853 | 0.326829 | 0.000389809 | 0.000631381 | 0.000656735
3 x HB | L50*50*4 | +58.088 | +58.175 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.32627 | 0.000389809 | 0.000630414 | 0.000655612
3 x HB | L50*50*4 | +58.129 | +58.214 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1682 | m830 | 0.326294 | 0.000389809 | 0.000630485 | 0.00065566
3 x HB | L50*50*4 | +58.167 | +58.247 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1682.1 | m830 | 0.326317 | 0.000389809 | 0.000630474 | 0.000655707
3 x HB | L50*50*4 | +58.200 | +58.278 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1682.1 | m830 | 0.326329 | 0.000389809 | 0.000630558 | 0.00065573
3 x HB | L50*50*4 | +58.231 | +58.307 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1682.7 | m854 | 0.326437 | 0.000389809 | 0.000630664 | 0.000655948
3 x HB | L50*50*4 | +52.721 | +52.827 | 2 | 5 | 4.8 | 63.4 | 0.3 | 50 | 50 | 1563.7 | m826 | 0.303337 | 0.000389809 | 0.000574325 | 0.00060953
HB | L50*50*4 | +52.662 | +52.765 | 2 | 5 | 4.7 | 63.4 | 0.3 | 50 | 50 | 1546.5 | m827 | 0.299998 | 0.000389809 | 0.000567575 | 0.00060282
2 x HB | L50*50*4 | +51.464 | +51.588 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m831 | 0.32183 | 0.000389809 | 0.000616866 | 0.000646691
3 x HB | L50*50*4 | +51.544 | +51.670 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1693.6 | m832 | 0.328547 | 0.000389809 | 0.000633384 | 0.000660188
2 x HB | L50*50*4 | +51.629 | +51.729 | 2 | 5 | 4.7 | 63.4 | 0.3 | 50 | 50 | 1499.7 | m833 | 0.290927 | 0.000389809 | 0.000547224 | 0.000584593
3 x HB | L50*50*4 | +51.686 | +51.788 | 2 | 5 | 4.4 | 63.4 | 0.3 | 50 | 50 | 1426.7 | m834 | 0.276762 | 0.000389809 | 0.000528182 | 0.00055613
2 x HB | L50*50*4 | +51.381 | +51.507 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m835 | 0.33121 | 0.000389809 | 0.000645499 | 0.000665539
3 x HB | L50*50*4 | +51.300 | +51.423 | 2 | 5 | 5 | 63.4 | 0.3 | 50 | 50 | 1626.4 | m836 | 0.315511 | 0.000389809 | 0.000607951 | 0.000633993
3 x HB | L50*50*4 | +52.210 | +52.316 | 2 | 5 | 4.8 | 63.4 | 0.3 | 50 | 50 | 1563.7 | m823 | 0.303338 | 0.000389809 | 0.00057583 | 0.000609533
3 x HB | L50*50*4 | +52.274 | +52.376 | 2 | 5 | 4.7 | 63.4 | 0.3 | 50 | 50 | 1546.5 | m824 | 0.299998 | 0.000389809 | 0.000567535 | 0.00060282
3 x HB | L50*50*4 | +52.334 | +52.458 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +52.417 | +52.541 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.000630443 | 0.000655627
3 x HB | L50*50*4 | +51.238 | +51.342 | 2 | 5 | 4.8 | 63.4 | 0.3 | 50 | 50 | 1569.8 | m828 | 0.304527 | 0.000389809 | 0.000587134 | 0.000611921
3 x HB | L50*50*4 | +51.179 | +51.281 | 2 | 5 | 4.4 | 63.4 | 0.3 | 50 | 50 | 1446.3 | m829 | 0.280576 | 0.000389809 | 0.000530326 | 0.000563794
3 x HB | L50*50*4 | +52.580 | +52.705 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +52.497 | +52.623 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
2 x HB | L50*50*4 | +55.809 | +55.936 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1706.7 | m837 | 0.331079 | 0.000389809 | 0.000636848 | 0.000665275
3 x HB | L50*50*4 | +56.846 | +56.969 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.7 | m825 | 0.326236 | 0.000389809 | 0.000630412 | 0.000655545
3 x HB | L50*50*4 | +56.138 | +56.266 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1706.7 | m837 | 0.331081 | 0.000389809 | 0.000636462 | 0.00066528
3 x HB | L50*50*4 | +56.058 | +56.181 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m838 | 0.321831 | 0.000389809 | 0.000616866 | 0.000646692
3 x HB | L50*50*4 | +55.973 | +56.101 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1706.7 | m837 | 0.33108 | 0.000389809 | 0.000636434 | 0.000665277
3 x HB | L50*50*4 | +55.893 | +56.017 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659.6 | m838 | 0.321956 | 0.000389809 | 0.000617164 | 0.000646944
3 x HB | L50*50*4 | +57.256 | +57.382 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.000630439 | 0.000655626
3 x HB | L50*50*4 | +57.175 | +57.299 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655626
3 x HB | L50*50*4 | +57.093 | +57.217 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.7 | m825 | 0.326236 | 0.000389809 | 0.000630412 | 0.000655545
3 x HB | L50*50*4 | +57.011 | +57.134 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.7 | m825 | 0.326236 | 0.000389809 | 0.000630412 | 0.000655545
3 x HB | L50*50*4 | +56.928 | +57.052 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.7 | m825 | 0.326237 | 0.000389809 | 0.000630409 | 0.000655545
3 x HB | L50*50*4 | +54.816 | +54.942 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1693.6 | m840 | 0.328547 | 0.000389809 | 0.000633394 | 0.000660187
3 x HB | L50*50*4 | +55.561 | +55.683 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m842 | 0.321831 | 0.000389809 | 0.00061973 | 0.000646692
3 x HB | L50*50*4 | +56.676 | +56.797 | 2 | 5 | 5 | 63.4 | 0.3 | 50 | 50 | 1649.5 | m843 | 0.319979 | 0.000389809 | 0.000616091 | 0.000642972
3 x HB | L50*50*4 | +56.593 | +56.719 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +56.511 | +56.636 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
HB | L50*50*4 | +55.774 | +55.895 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1654.8 | m867 | 0.32101 | 0.000389809 | 0.000618463 | 0.000645042
3 x HB | L50*50*4 | +55.854 | +55.977 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +55.477 | +55.603 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m844 | 0.33121 | 0.000389809 | 0.000645491 | 0.000665539
3 x HB | L50*50*4 | +55.396 | +55.519 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m842 | 0.32183 | 0.000389809 | 0.00061973 | 0.000646691
3 x HB | L50*50*4 | +55.231 | +55.354 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m842 | 0.32183 | 0.000389809 | 0.00061973 | 0.000646691
3 x HB | L50*50*4 | +55.312 | +55.435 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1686.8 | m845 | 0.327232 | 0.000389809 | 0.000625957 | 0.000657546
HB | L50*50*4 | +55.146 | +55.274 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m837 | 0.33121 | 0.000389809 | 0.000637123 | 0.000665539
3 x HB | L50*50*4 | +55.065 | +55.189 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m838 | 0.321831 | 0.000389809 | 0.000616866 | 0.000646692
HB | L50*50*4 | +54.981 | +55.109 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m837 | 0.33121 | 0.000389809 | 0.000637123 | 0.000665539
3 x HB | L50*50*4 | +54.901 | +55.024 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1658.7 | m838 | 0.321777 | 0.000389809 | 0.000616857 | 0.000646584
3 x HB | L50*50*4 | +56.428 | +56.554 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +56.346 | +56.472 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655626
3 x HB | L50*50*4 | +56.264 | +56.389 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +56.183 | +56.307 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +56.101 | +56.224 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655626
3 x HB | L50*50*4 | +56.018 | +56.142 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +55.936 | +56.060 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655626
3 x HB | L50*50*4 | +53.750 | +53.867 | 2 | 5 | 4.8 | 63.4 | 0.3 | 50 | 50 | 1565.6 | m846 | 0.303713 | 0.000389809 | 0.00057939 | 0.000610286
3 x HB | L50*50*4 | +53.824 | +53.950 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1693.6 | m840 | 0.328547 | 0.000389809 | 0.000633394 | 0.000660187
3 x HB | L50*50*4 | +54.649 | +54.765 | 2 | 5 | 4.8 | 63.4 | 0.3 | 50 | 50 | 1561.1 | m841 | 0.302841 | 0.000389809 | 0.000577103 | 0.000608534
2 x HB | L50*50*4 | +54.568 | +54.691 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m842 | 0.321831 | 0.000389809 | 0.00061973 | 0.000646692
3 x HB | L50*50*4 | +55.683 | +55.804 | 2 | 5 | 5 | 63.4 | 0.3 | 50 | 50 | 1649.5 | m843 | 0.319979 | 0.000389809 | 0.000616091 | 0.000642971
3 x HB | L50*50*4 | +55.601 | +55.727 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +55.519 | +55.644 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
HB | L50*50*4 | +54.782 | +54.903 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1654.8 | m867 | 0.321008 | 0.000389809 | 0.000618461 | 0.000645039
3 x HB | L50*50*4 | +54.861 | +54.985 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +54.485 | +54.611 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m844 | 0.33121 | 0.000389809 | 0.000645491 | 0.000665539
2 x HB | L50*50*4 | +54.404 | +54.526 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m842 | 0.32183 | 0.000389809 | 0.00061973 | 0.000646691
2 x HB | L50*50*4 | +54.239 | +54.362 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m842 | 0.32183 | 0.000389809 | 0.00061973 | 0.000646691
3 x HB | L50*50*4 | +54.320 | +54.443 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1686.8 | m845 | 0.327232 | 0.000389809 | 0.000625888 | 0.000657545
HB | L50*50*4 | +54.154 | +54.281 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m837 | 0.33121 | 0.000389809 | 0.000637123 | 0.000665539
3 x HB | L50*50*4 | +54.073 | +54.197 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m838 | 0.321831 | 0.000389809 | 0.000616866 | 0.000646692
HB | L50*50*4 | +53.989 | +54.116 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m837 | 0.33121 | 0.000389809 | 0.000637123 | 0.000665539
3 x HB | L50*50*4 | +53.908 | +54.032 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m838 | 0.32183 | 0.000389809 | 0.000616866 | 0.000646691
3 x HB | L50*50*4 | +55.436 | +55.562 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +55.354 | +55.479 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655626
3 x HB | L50*50*4 | +55.271 | +55.397 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +55.191 | +55.315 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +55.108 | +55.232 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655626
3 x HB | L50*50*4 | +55.026 | +55.150 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +54.944 | +55.067 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655626
3 x HB | L50*50*4 | +52.758 | +52.875 | 2 | 5 | 4.8 | 63.4 | 0.3 | 50 | 50 | 1566.1 | m839 | 0.3038 | 0.000389809 | 0.000579367 | 0.000610461
3 x HB | L50*50*4 | +52.832 | +52.957 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1693.6 | m840 | 0.328547 | 0.000389809 | 0.000633394 | 0.000660187
2 x HB | L50*50*4 | +53.657 | +53.772 | 2 | 5 | 4.8 | 63.4 | 0.3 | 50 | 50 | 1561.1 | m841 | 0.302847 | 0.000389809 | 0.000577172 | 0.000608546
3 x HB | L50*50*4 | +53.576 | +53.699 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m842 | 0.321831 | 0.000389809 | 0.00061973 | 0.000646692
3 x HB | L50*50*4 | +54.691 | +54.812 | 2 | 5 | 5 | 63.4 | 0.3 | 50 | 50 | 1649.5 | m843 | 0.319979 | 0.000389809 | 0.00061609 | 0.000642971
3 x HB | L50*50*4 | +54.609 | +54.734 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +54.526 | +54.652 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
HB | L50*50*4 | +53.789 | +53.910 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1654.8 | m867 | 0.321011 | 0.000389809 | 0.000618467 | 0.000645044
3 x HB | L50*50*4 | +53.869 | +53.993 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +53.492 | +53.619 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m844 | 0.33121 | 0.000389809 | 0.000645491 | 0.000665539
3 x HB | L50*50*4 | +53.411 | +53.534 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m842 | 0.32183 | 0.000389809 | 0.00061973 | 0.000646691
3 x HB | L50*50*4 | +53.246 | +53.369 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m842 | 0.32183 | 0.000389809 | 0.00061973 | 0.000646691
3 x HB | L50*50*4 | +53.328 | +53.451 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1686.8 | m845 | 0.327232 | 0.000389809 | 0.000625964 | 0.000657546
3 x HB | L50*50*4 | +53.161 | +53.289 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m850 | 0.33121 | 0.000389809 | 0.000637123 | 0.000665539
3 x HB | L50*50*4 | +53.081 | +53.204 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m838 | 0.321831 | 0.000389809 | 0.000616866 | 0.000646692
3 x HB | L50*50*4 | +52.996 | +53.124 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m850 | 0.33121 | 0.000389809 | 0.000637123 | 0.000665539
3 x HB | L50*50*4 | +52.916 | +53.040 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m838 | 0.32183 | 0.000389809 | 0.000616866 | 0.000646691
3 x HB | L50*50*4 | +54.444 | +54.570 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +54.361 | +54.487 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655626
3 x HB | L50*50*4 | +54.279 | +54.405 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +54.199 | +54.322 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +54.116 | +54.240 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655626
3 x HB | L50*50*4 | +54.034 | +54.157 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +53.951 | +54.075 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655626
2 x HB | L50*50*4 | +51.765 | +51.883 | 2 | 5 | 4.8 | 63.4 | 0.3 | 50 | 50 | 1566.1 | m846 | 0.303813 | 0.000389809 | 0.000579336 | 0.000610487
3 x HB | L50*50*4 | +51.839 | +51.965 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1693.6 | m840 | 0.328547 | 0.000389809 | 0.000633394 | 0.000660187
3 x HB | L50*50*4 | +52.584 | +52.707 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m842 | 0.321831 | 0.000389809 | 0.00061973 | 0.000646692
3 x HB | L50*50*4 | +53.699 | +53.820 | 2 | 5 | 5 | 63.4 | 0.3 | 50 | 50 | 1649.5 | m843 | 0.319979 | 0.000389809 | 0.00061609 | 0.00064297
3 x HB | L50*50*4 | +53.616 | +53.742 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +53.534 | +53.660 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
HB | L50*50*4 | +52.797 | +52.918 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1654.8 | m867 | 0.321011 | 0.000389809 | 0.000618467 | 0.000645045
3 x HB | L50*50*4 | +52.877 | +53.000 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +52.500 | +52.626 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m844 | 0.33121 | 0.000389809 | 0.000645491 | 0.000665539
3 x HB | L50*50*4 | +52.419 | +52.542 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m842 | 0.32183 | 0.000389809 | 0.00061973 | 0.000646691
2 x HB | L50*50*4 | +52.254 | +52.377 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m842 | 0.32183 | 0.000389809 | 0.00061973 | 0.000646691
3 x HB | L50*50*4 | +52.335 | +52.461 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m844 | 0.33121 | 0.000389809 | 0.000645508 | 0.000665538
3 x HB | L50*50*4 | +52.169 | +52.297 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m850 | 0.33121 | 0.000389809 | 0.000637123 | 0.000665539
3 x HB | L50*50*4 | +52.089 | +52.212 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m838 | 0.321831 | 0.000389809 | 0.000616866 | 0.000646692
3 x HB | L50*50*4 | +52.004 | +52.132 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m850 | 0.33121 | 0.000389809 | 0.000637123 | 0.000665539
3 x HB | L50*50*4 | +51.924 | +52.047 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1659 | m838 | 0.32183 | 0.000389809 | 0.000616866 | 0.000646691
3 x HB | L50*50*4 | +53.452 | +53.577 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +53.369 | +53.495 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655626
3 x HB | L50*50*4 | +53.287 | +53.412 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m830 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +53.206 | +53.330 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +53.124 | +53.248 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655626
3 x HB | L50*50*4 | +53.041 | +53.165 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655627
3 x HB | L50*50*4 | +52.959 | +53.083 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m825 | 0.326277 | 0.000389809 | 0.00063044 | 0.000655626
HB | L50*50*4 | +57.894 | +57.990 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1671 | m861 | 0.324167 | 0.000389809 | 0.000618765 | 0.000651386
2 x HB | L50*50*4 | +52.662 | +52.765 | 2 | 5 | 4.7 | 63.4 | 0.3 | 50 | 50 | 1546.5 | m827 | 0.299998 | 0.000389809 | 0.000568079 | 0.00060282
HB | L50*50*4 | +51.464 | +51.588 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1680.2 | m862 | 0.325939 | 0.000389809 | 0.000628617 | 0.000654947
HB | L50*50*4 | +51.629 | +51.730 | 2 | 5 | 4.7 | 63.4 | 0.3 | 50 | 50 | 1532.9 | m863 | 0.297367 | 0.000389809 | 0.000566245 | 0.000597534
HB | L50*50*4 | +51.381 | +51.507 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707 | m864 | 0.331135 | 0.000389809 | 0.000638214 | 0.000665387
HB | L50*50*4 | +55.809 | +55.936 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1706.7 | m850 | 0.331079 | 0.000389809 | 0.000636848 | 0.000665275
HB | L50*50*4 | +55.774 | +55.895 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1654.8 | m768 | 0.32101 | 0.000389809 | 0.000618463 | 0.000645042
2 x HB | L50*50*4 | +55.146 | +55.274 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m850 | 0.33121 | 0.000389809 | 0.000637123 | 0.000665539
2 x HB | L50*50*4 | +54.981 | +55.109 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m850 | 0.33121 | 0.000389809 | 0.000637123 | 0.000665539
2 x HB | L50*50*4 | +54.782 | +54.903 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1654.8 | m767 | 0.321008 | 0.000389809 | 0.000618461 | 0.000645039
2 x HB | L50*50*4 | +54.154 | +54.281 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m850 | 0.33121 | 0.000389809 | 0.000637123 | 0.000665539
2 x HB | L50*50*4 | +53.989 | +54.116 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1707.3 | m850 | 0.33121 | 0.000389809 | 0.000637123 | 0.000665539
HB | L50*50*4 | +53.657 | +53.772 | 2 | 5 | 4.8 | 63.4 | 0.3 | 50 | 50 | 1561.1 | m841 | 0.302847 | 0.000389809 | 0.00057717 | 0.000608546
2 x HB | L50*50*4 | +53.789 | +53.910 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1654.8 | m767 | 0.321011 | 0.000389809 | 0.000618467 | 0.000645044
HB | L50*50*4 | +51.765 | +51.883 | 2 | 5 | 4.7 | 63.4 | 0.3 | 50 | 50 | 1549.2 | m865 | 0.300535 | 0.000389809 | 0.000572773 | 0.000603901
2 x HB | L50*50*4 | +52.797 | +52.918 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1654.8 | m767 | 0.321011 | 0.000389809 | 0.000618467 | 0.000645045
3 x HB | PC100*50 | +58.306 | +58.407 | 5 | 3 | 18.4 | 37.9 | 0.6 | 100 | 50 | 1823.9 | m163 | 0.69817 | 0.00128662 | 0.00229082 | 0.00234667
3 x HB | PC100*50 | +58.330 | +58.431 | 5 | 3 | 18.4 | 37.9 | 0.6 | 100 | 50 | 1823.9 | m163 | 0.69817 | 0.00128662 | 0.00229082 | 0.00234667
3 x HB | PC100*50 | +58.354 | +58.455 | 5 | 3 | 18.4 | 37.9 | 0.6 | 100 | 50 | 1823.9 | m163 | 0.69817 | 0.00128662 | 0.00229082 | 0.00234667
3 x HB | PC100*50 | +58.378 | +58.479 | 5 | 3 | 18.4 | 37.9 | 0.6 | 100 | 50 | 1823.9 | m163 | 0.69817 | 0.00128662 | 0.00229082 | 0.00234667
3 x HB | PC100*50 | +58.402 | +58.503 | 5 | 3 | 18.4 | 37.9 | 0.6 | 100 | 50 | 1823.9 | m163 | 0.69817 | 0.00128662 | 0.00229082 | 0.00234667
3 x HB | L70*70*6 | +58.458 | +58.539 | 5 | 3 | 10.8 | 42.7 | 0.5 | 70 | 70 | 1691.2 | m84 | 0.460464 | 0.000812739 | 0.00135446 | 0.00137449
3 x HB | L70*70*6 | +58.434 | +58.526 | 5 | 3 | 13.8 | 42.7 | 0.6 | 70 | 70 | 2168.3 | m82 | 0.590384 | 0.000812739 | 0.00174334 | 0.0017623
3 x HB | L70*70*6 | +58.410 | +58.502 | 5 | 3 | 13.8 | 42.7 | 0.6 | 70 | 70 | 2168.3 | m82 | 0.590384 | 0.000812739 | 0.00174335 | 0.0017623
3 x HB | L70*70*6 | +58.385 | +58.478 | 5 | 3 | 13.8 | 42.7 | 0.6 | 70 | 70 | 2168.3 | m82 | 0.590384 | 0.000812739 | 0.00174335 | 0.0017623
3 x HB | L70*70*6 | +58.362 | +58.454 | 5 | 3 | 13.8 | 42.7 | 0.6 | 70 | 70 | 2168.3 | m82 | 0.590384 | 0.000812739 | 0.00174335 | 0.0017623
3 x HB | L70*70*6 | +58.337 | +58.430 | 5 | 3 | 13.8 | 42.7 | 0.6 | 70 | 70 | 2168.3 | m82 | 0.590384 | 0.000812739 | 0.00174335 | 0.0017623
3 x HB | L70*70*6 | +58.329 | +58.406 | 5 | 3 | 10.1 | 42.7 | 0.3 | 70 | 70 | 1606.3 | m83 | 0.437356 | 0.000812739 | 0.00126597 | 0.00130551
HB | L50*50*4 | +56.222 | +56.346 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.8 | m857 | 0.326264 | 0.000389809 | 0.000626762 | 0.0006556
HB | L50*50*4 | +57.894 | +57.991 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1681.7 | m825 | 0.326238 | 0.000389809 | 0.000630294 | 0.000655547
HB | L50*50*4 | +55.774 | +55.895 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1654.8 | m767 | 0.32101 | 0.000389809 | 0.000618463 | 0.000645042
HB | L50*50*4 | +54.567 | +54.691 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1682.7 | m858 | 0.326408 | 0.000389809 | 0.000627499 | 0.000655889
HB | L50*50*4 | +54.402 | +54.526 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1686.2 | m813 | 0.327111 | 0.000389809 | 0.000627802 | 0.000657302
HB | L50*50*4 | +54.238 | +54.362 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1682.7 | m858 | 0.326416 | 0.000389809 | 0.000627506 | 0.000655906
HB | L50*50*4 | +52.253 | +52.377 | 2 | 5 | 5.1 | 63.4 | 0.3 | 50 | 50 | 1677.1 | m812 | 0.325345 | 0.000389809 | 0.000624306 | 0.000653753

# IfcDiscreteAccessory: H_Brace (381)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Phase: 2; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Height (mm) = Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x H_Brace | L70*70*8 | +57.679 | +57.754 | 11.4 | 32.6 | 70 | 1362 | m374 | 0.370838 | 0.00106497 | 0.00143827 | 0.00145049
3 x H_Brace | L50*50*4 | +52.574 | +52.628 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +56.602 | +56.655 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +56.455 | +56.509 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +57.636 | +57.689 | 4.2 | 63.4 | 50 | 1407.8 | m815 | 0.273091 | 0.000389809 | 0.000540576 | 0.000548753
3 x H_Brace | L50*50*4 | +57.565 | +57.618 | 4.2 | 63.4 | 50 | 1407.8 | m815 | 0.27312 | 0.000389809 | 0.000540633 | 0.000548812
3 x H_Brace | L50*50*4 | +57.489 | +57.543 | 4.2 | 63.4 | 50 | 1407.8 | m815 | 0.273129 | 0.000389809 | 0.000540627 | 0.000548829
3 x H_Brace | L50*50*4 | +57.417 | +57.471 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273133 | 0.000389809 | 0.000540636 | 0.000548838
3 x H_Brace | L50*50*4 | +56.737 | +56.787 | 4.4 | 63.4 | 50 | 1422 | m818 | 0.275855 | 0.000389809 | 0.000546048 | 0.000554308
3 x H_Brace | L50*50*4 | +56.855 | +56.905 | 4.4 | 63.4 | 50 | 1422 | m818 | 0.275855 | 0.000389809 | 0.000546048 | 0.000554308
3 x H_Brace | L50*50*4 | +56.960 | +57.010 | 4.4 | 63.4 | 50 | 1422 | m818 | 0.275855 | 0.000389809 | 0.000546048 | 0.000554308
3 x H_Brace | L50*50*4 | +57.049 | +57.101 | 4.4 | 63.4 | 50 | 1422 | m818 | 0.275855 | 0.000389809 | 0.000546048 | 0.000554308
3 x H_Brace | L50*50*4 | +57.128 | +57.180 | 4.4 | 63.4 | 50 | 1422 | m818 | 0.275855 | 0.000389809 | 0.000546048 | 0.000554308
3 x H_Brace | L50*50*4 | +57.190 | +57.241 | 4.2 | 63.4 | 50 | 1382 | m817 | 0.268096 | 0.000389809 | 0.000530688 | 0.000538716
H_Brace | L70*70*8 | +57.695 | +57.765 | 11.4 | 32.6 | 70 | 1358 | m371 | 0.369749 | 0.00106497 | 0.00143405 | 0.00144623
3 x H_Brace | L50*50*4 | +57.772 | +57.822 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +57.833 | +57.883 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +57.891 | +57.941 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +57.945 | +57.995 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
2 x H_Brace | L50*50*4 | +57.996 | +58.047 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +58.044 | +58.094 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +58.085 | +58.137 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +58.126 | +58.178 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +58.165 | +58.216 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +58.198 | +58.250 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +58.229 | +58.280 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
H_Brace | L70*70*8 | +58.237 | +58.309 | 11.4 | 32.6 | 70 | 1358 | m371 | 0.369749 | 0.00106497 | 0.00143405 | 0.00144623
2 x H_Brace | L70*70*8 | +52.188 | +52.258 | 11.4 | 32.6 | 70 | 1360 | m374 | 0.370293 | 0.00106497 | 0.00143616 | 0.00144836
3 x H_Brace | L50*50*4 | +51.539 | +51.593 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +51.681 | +51.735 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +52.272 | +52.322 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +52.331 | +52.381 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +52.413 | +52.464 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +51.378 | +51.428 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +51.236 | +51.286 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
2 x H_Brace | L70*70*8 | +52.759 | +52.834 | 11.4 | 32.6 | 70 | 1358 | m371 | 0.369748 | 0.00106497 | 0.00143405 | 0.00144623
3 x H_Brace | L50*50*4 | +52.716 | +52.770 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +52.657 | +52.711 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +52.496 | +52.546 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +55.807 | +55.857 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +56.842 | +56.892 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +56.925 | +56.975 | 4.2 | 63.4 | 50 | 1407.8 | m815 | 0.273091 | 0.000389809 | 0.000540576 | 0.000548753
3 x H_Brace | L50*50*4 | +56.298 | +56.352 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +56.137 | +56.187 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +55.972 | +56.022 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +57.333 | +57.387 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +57.250 | +57.304 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +57.172 | +57.222 | 4.2 | 63.4 | 50 | 1407.8 | m815 | 0.273091 | 0.000389809 | 0.000540576 | 0.000548753
3 x H_Brace | L50*50*4 | +57.090 | +57.140 | 4.2 | 63.4 | 50 | 1407.8 | m815 | 0.273091 | 0.000389809 | 0.000540576 | 0.000548753
3 x H_Brace | L50*50*4 | +57.007 | +57.057 | 4.2 | 63.4 | 50 | 1407.8 | m815 | 0.273091 | 0.000389809 | 0.000540576 | 0.000548753
3 x H_Brace | L70*70*8 | +56.744 | +56.814 | 11.4 | 32.6 | 70 | 1358 | m371 | 0.369749 | 0.00106497 | 0.00143405 | 0.00144623
3 x H_Brace | L50*50*4 | +55.635 | +55.689 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +56.670 | +56.724 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +56.588 | +56.642 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +54.815 | +54.865 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +55.850 | +55.900 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +55.932 | +55.983 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +55.470 | +55.524 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +55.305 | +55.359 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +55.144 | +55.194 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +54.979 | +55.030 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L70*70*8 | +56.728 | +56.804 | 11.4 | 32.6 | 70 | 1358 | m371 | 0.369749 | 0.00106497 | 0.00143405 | 0.00144623
