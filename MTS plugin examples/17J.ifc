Properties of the parts of a building model (IFC2X3), part 7 of 16

# IfcDiscreteAccessory: H_Brace (381)
Name | Description | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Height (mm) = Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x H_Brace | L50*50*4 | +56.505 | +56.559 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +56.423 | +56.477 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +56.341 | +56.395 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +56.258 | +56.312 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +56.180 | +56.230 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +56.097 | +56.147 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +56.015 | +56.065 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L70*70*8 | +55.752 | +55.822 | 11.4 | 32.6 | 70 | 1358 | m371 | 0.369749 | 0.00106497 | 0.00143405 | 0.00144623
3 x H_Brace | L50*50*4 | +54.643 | +54.697 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +55.678 | +55.732 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +55.596 | +55.650 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +53.822 | +53.872 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +54.858 | +54.908 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +54.940 | +54.990 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +54.478 | +54.532 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +54.313 | +54.367 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +54.152 | +54.202 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +53.987 | +54.037 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L70*70*8 | +55.736 | +55.811 | 11.4 | 32.6 | 70 | 1358 | m371 | 0.369749 | 0.00106497 | 0.00143405 | 0.00144623
3 x H_Brace | L50*50*4 | +55.513 | +55.567 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +55.431 | +55.485 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +55.348 | +55.402 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +55.266 | +55.320 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +55.187 | +55.238 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +55.105 | +55.155 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +55.023 | +55.073 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L70*70*8 | +54.759 | +54.830 | 11.4 | 32.6 | 70 | 1358 | m371 | 0.369749 | 0.00106497 | 0.00143405 | 0.00144623
3 x H_Brace | L50*50*4 | +53.650 | +53.704 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +54.686 | +54.740 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +54.603 | +54.657 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +52.830 | +52.880 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +53.865 | +53.916 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +53.948 | +53.998 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +53.485 | +53.539 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +53.321 | +53.375 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +53.160 | +53.210 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +52.995 | +53.045 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L70*70*8 | +54.743 | +54.819 | 11.4 | 32.6 | 70 | 1358 | m371 | 0.369749 | 0.00106497 | 0.00143405 | 0.00144623
3 x H_Brace | L50*50*4 | +54.521 | +54.575 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +54.439 | +54.492 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +54.356 | +54.410 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +54.274 | +54.328 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +54.195 | +54.245 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +54.113 | +54.163 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +54.030 | +54.080 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L70*70*8 | +53.767 | +53.838 | 11.4 | 32.6 | 70 | 1358 | m371 | 0.369749 | 0.00106497 | 0.00143405 | 0.00144623
3 x H_Brace | L50*50*4 | +52.658 | +52.712 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +53.693 | +53.747 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +53.611 | +53.665 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +51.838 | +51.888 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +52.873 | +52.923 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +52.956 | +53.006 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +52.493 | +52.547 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +52.328 | +52.382 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +52.167 | +52.218 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L50*50*4 | +52.003 | +52.053 | 4.7 | 63.4 | 50 | 1492 | m816 | 0.289435 | 0.000389809 | 0.000572928 | 0.000581595
3 x H_Brace | L70*70*8 | +53.751 | +53.827 | 11.4 | 32.6 | 70 | 1358 | m371 | 0.369749 | 0.00106497 | 0.00143405 | 0.00144623
3 x H_Brace | L50*50*4 | +53.529 | +53.583 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +53.446 | +53.500 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +53.364 | +53.418 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +53.281 | +53.335 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +53.203 | +53.253 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +53.120 | +53.171 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L50*50*4 | +53.038 | +53.088 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.27314 | 0.000389809 | 0.000540672 | 0.000548851
3 x H_Brace | L70*70*8 | +52.775 | +52.845 | 11.4 | 32.6 | 70 | 1358 | m371 | 0.369749 | 0.00106497 | 0.00143405 | 0.00144623
H_Brace | L70*70*8 | +57.695 | +57.765 | 11.4 | 32.6 | 70 | 1368 | m372 | 0.372471 | 0.00106497 | 0.00144461 | 0.00145688
H_Brace | L50*50*4 | +57.996 | +58.046 | 4.2 | 63.4 | 50 | 1408 | m815 | 0.273139 | 0.000389809 | 0.000540672 | 0.000548851
H_Brace | L70*70*8 | +58.237 | +58.309 | 11.4 | 32.6 | 70 | 1363 | m374 | 0.37111 | 0.00106497 | 0.00143933 | 0.00145155
H_Brace | L70*70*8 | +52.759 | +52.834 | 11.6 | 32.6 | 70 | 1382.9 | m375 | 0.376537 | 0.00106497 | 0.00146038 | 0.00147278
H_Brace | L70*70*8 | +57.695 | +57.765 | 11.4 | 32.6 | 70 | 1378 | m373 | 0.375194 | 0.00106497 | 0.00145517 | 0.00146753
H_Brace | L70*70*8 | +58.237 | +58.309 | 11.4 | 32.6 | 70 | 1368 | m372 | 0.372471 | 0.00106497 | 0.00144461 | 0.00145688
H_Brace | L70*70*8 | +52.188 | +52.258 | 11.4 | 32.6 | 70 | 1360 | m371 | 0.370293 | 0.00106497 | 0.00143616 | 0.00144836

# IfcDiscreteAccessory: Handle (87)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Length: 291.4 mm
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Area per tons (m2) | Height (mm) = Width (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
39 x Handle | D12 | +51.361 | +51.523 | 9 | 1 | 47 | 12 | m930 | 0.0108771 | 0.000101823 | 0.0000295288
42 x Handle | D12 | +50.761 | +50.923 | 9 | 1 | 47 | 12 | m930 | 0.0108771 | 0.000101823 | 0.0000295288
3 x Handle | D10 | +58.111 | +58.191 | 5 | 99 | 56.1 | 10 | m714 | 0.00903595 | 0.0000707107 | 0.0000205061
3 x Handle | D12 | +51.231 | +51.393 | 9 | 1 | 47 | 12 | m930 | 0.0108771 | 0.000101823 | 0.0000295288

# IfcDiscreteAccessory: Kick Flat (116)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Bottom elevation: +57.270; Top elevation: +57.400; Phase: 3; Class: 99
Tekla Quantity - Volume: 0 m3; Width: 6 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00078 m2
Name | Description | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
8 x Kick Flat | PL6*130 | 0.9 | 0 | 46.2 | 0 | 130 | 164.9 | p642 | 0.0405378 | 0.0464264 | 0.000111786 | 0.000128661
8 x Kick Flat | PL6*76.2 | 0.5 | 0 | 47.8 | 0 | 76.2 | 130 | p621 | 0.0222864 | 0.0222864 | 0.000059436 | 0.000059436
4 x Kick Flat | PL6*58.3 | 0.3 | 0 | 48.8 | 0 | 58.3 | 130 | p622 | 0.0174043 | 0.0174043 | 0.0000454359 | 0.0000454359
Kick Flat | PL6*110.9 | 0.7 | 0 | 46.7 | 0 | 110.9 | 130 | p623 | 0.0317383 | 0.0317383 | 0.0000865407 | 0.0000865407
4 x Kick Flat | PL6*69 | 0.3 | 0 | 48.1 | 0 | 69 | 130 | p624 | 0.0203171 | 0.0203171 | 0.0000537888 | 0.0000537888
4 x Kick Flat | PL6*130 | 1.4 | 0 | 45.6 | 0.1 | 130 | 221.8 | p625 | 0.0618894 | 0.0618894 | 0.000173003 | 0.000173003
2 x Kick Flat | PL6*58.3 | 0.3 | 0 | 48.8 | 0 | 58.3 | 130 | p622 | 0.0174042 | 0.0174042 | 0.0000454356 | 0.0000454356
Kick Flat | PL6*111 | 0.7 | 0 | 46.7 | 0 | 110.9 | 130 | p623 | 0.0317384 | 0.0317384 | 0.000086541 | 0.000086541
6 x Kick Flat | PL6*130 | 0.9 | 0 | 46.1 | 0 | 130 | 149 | p626 | 0.0420881 | 0.0420881 | 0.00011622 | 0.00011622
6 x Kick Flat | PL6*130 | 2.7 | 0 | 44.9 | 0.1 | 130 | 445.3 | p627 | 0.122682 | 0.122682 | 0.000347334 | 0.000347334
10 x Kick Flat | PL6*130 | 0.9 | 0 | 46 | 0 | 130 | 165.1 | p628 | 0.0464672 | 0.0464672 | 0.000128778 | 0.000128778
4 x Kick Flat | PL6*130 | 0.9 | 0 | 46.1 | 0 | 130 | 150 | p626 | 0.0423464 | 0.0423464 | 0.000116961 | 0.000116961
6 x Kick Flat | PL6*130 | 8.3 | 0 | 44.6 | 0.3 | 130 | 1350.1 | p629 | 0.368785 | 0.368785 | 0.00105307 | 0.00105307
6 x Kick Flat | PL6*130 | 10 | 0 | 44.6 | 0.3 | 130 | 1624.9 | p630 | 0.443546 | 0.443546 | 0.00126746 | 0.00126746
4 x Kick Flat | PL6*130 | 3.1 | 0 | 44.9 | 0.1 | 130 | 499 | p631 | 0.137288 | 0.137288 | 0.000389221 | 0.000389221
5 x Kick Flat | PL6*130 | 13.3 | 0 | 44.5 | 0.6 | 130 | 2161 | p632 | 0.589353 | 0.589353 | 0.00168558 | 0.00168558
6 x Kick Flat | PL6*130 | 11.6 | 0 | 44.6 | 0.5 | 130 | 1915 | p633 | 0.522426 | 0.522426 | 0.00149366 | 0.00149366
6 x Kick Flat | PL6*130 | 0.7 | 0 | 46.3 | 0 | 130 | 133.4 | p634 | 0.0378448 | 0.0378448 | 0.000104052 | 0.000104052
4 x Kick Flat | PL6*130 | 1.2 | 0 | 45.6 | 0.1 | 130 | 215 | p635 | 0.0600264 | 0.0600264 | 0.000167661 | 0.000167661
2 x Kick Flat | PL6*38.8 | 0.2 | 0 | 51 | 0 | 38.8 | 130 | p636 | 0.0121 | 0.0121 | 0.000030225 | 0.000030225
2 x Kick Flat | PL6*130 | 3.6 | 0 | 44.9 | 0.2 | 130 | 591.1 | p637 | 0.162326 | 0.162326 | 0.000461019 | 0.000461019
2 x Kick Flat | PL6*130 | 1.2 | 0 | 45.6 | 0.1 | 130 | 216.8 | p635 | 0.0605294 | 0.0605294 | 0.000169103 | 0.000169103
2 x Kick Flat | PL6*130 | 0.9 | 0 | 46.1 | 0 | 130 | 155 | p638 | 0.0437064 | 0.0437064 | 0.000120861 | 0.000120861
2 x Kick Flat | PL6*130 | 3.1 | 0 | 44.9 | 0.1 | 130 | 499 | p631 | 0.137289 | 0.137289 | 0.000389222 | 0.000389222
Kick Flat | PL6*130 | 13.3 | 0 | 44.5 | 0.6 | 130 | 2161 | p632 | 0.589354 | 0.589354 | 0.00168559 | 0.00168559
2 x Kick Flat | PL6*130 | 0.9 | 0 | 46 | 0 | 130 | 165.1 | p628 | 0.0464671 | 0.0464671 | 0.000128778 | 0.000128778
2 x Kick Flat | PL6*130 | 1.2 | 0 | 45.6 | 0.1 | 130 | 215 | p635 | 0.0600265 | 0.0600265 | 0.000167661 | 0.000167661
Kick Flat | PL6*95 | 0.7 | 0 | 47.1 | 0 | 95 | 130 | p639 | 0.0273864 | 0.0273864 | 0.000074061 | 0.000074061
2 x Kick Flat | FL6*100 | 0.7 | 0 | 47 | 0 | 100 | 130 | p640 | 0.0287601 | 0.0287601 | 0.0000780002 | 0.0000780002
2 x Kick Flat | PL6*130 | 71 | 0.1 | 44.5 | 3.2 | 130 | 11600.7 | p641 | 3.15695 | 3.15695 | 0.00904855 | 0.00904855
Kick Flat | PL6*94.9 | 0.7 | 0 | 47.1 | 0 | 95 | 130 | p639 | 0.0273864 | 0.0273864 | 0.000074061 | 0.000074061

# IfcDiscreteAccessory: Ladder (3)
In: Undefined
Description: FL10*65; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +51.111; Top elevation: +53.987; Phase: 6; Class: 14
Tekla Quantity - Weight: 14.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.5 m2; Net surface area: 0.3 m2; Height: 65 mm; Width: 10 mm; Length: 2916.7 mm
Pset_PlateCommon - LoadBearing: yes; Reference: p254
BaseQuantities - NetArea: 0.440053 m2; GrossArea: 0.440053 m2; CrossSectionArea: 0.00065 m2; NetVolume: 0.00190126 m3; GrossVolume: 0.00190126 m3

# IfcDiscreteAccessory: Mesh (172)
In: Undefined
Tekla Quantity - Weight: 0 kg; Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Material | Gross footprint area (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Bottom elevation | Top elevation | Phase | Class | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
3 x Mesh | PL3*544 | Undefined/VEM 6320H | 0 | 2.4 | 544 | 3 | 2196 | +50.370 | +52.566 | 25 | 2 | p384 | 2.40569 | 1.19462 | 0.000009 | 0.00358387
Mesh | PL3*540 | Undefined/VEM 6320H | 0 | 2.4 | 540 | 3 | 2196 | +50.370 | +52.566 | 25 | 2 | p385 | 2.38814 | 1.18586 | 0.000009 | 0.00355759
Mesh | PL6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +56.440 | +56.598 | 2 | 8 | p616 | 2.91392 | 2.91392 | 0.004344 | 0.00864407
2 x Mesh | PL6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.6 | +56.968 | +57.072 | 2 | 8 | p612 | 2.9135 | 2.9135 | 0.004344 | 0.00864282
2 x Mesh | PL6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.6 | +56.968 | +57.071 | 2 | 8 | p613 | 6.67356 | 6.67356 | 0.009996 | 0.0198891
2 x Mesh | PL6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 2020.4 | +56.730 | +56.862 | 2 | 8 | p610 | 2.95853 | 2.95853 | 0.004344 | 0.0087768
Mesh | PL6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1984.6 | +56.857 | +56.974 | 2 | 8 | p604 | 2.90621 | 2.90621 | 0.004344 | 0.00862113
2 x Mesh | PL6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 2000.8 | +57.151 | +57.227 | 2 | 8 | p609 | 2.92987 | 2.92987 | 0.004344 | 0.00869153
2 x Mesh | PL6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1990.1 | +57.066 | +57.156 | 2 | 8 | p599 | 2.9142 | 2.9142 | 0.004344 | 0.0086449
2 x Mesh | PL6*724 | Undefined/Vitex W80HR | 0.1 | 2.9 | 724 | 6 | 2033.5 | +57.221 | +57.276 | 2 | 8 | p596 | 2.97772 | 2.97772 | 0.004344 | 0.00883389
Mesh | PL6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +56.440 | +56.598 | 2 | 8 | p603 | 2.91391 | 2.91391 | 0.004344 | 0.00864402
Mesh | PL6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1994.6 | +56.857 | +56.974 | 2 | 8 | p602 | 2.92081 | 2.92081 | 0.004344 | 0.00866457
2 x Mesh | PL6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1984.5 | +56.857 | +56.973 | 2 | 8 | p601 | 6.65601 | 6.65601 | 0.009996 | 0.0198366
2 x Mesh | PL6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +56.440 | +56.598 | 2 | 8 | p598 | 6.67419 | 6.67419 | 0.009996 | 0.019891
2 x Mesh | PL6*1666 | Undefined/Vitex W80HR | 0.3 | 6.9 | 1666 | 6 | 2053.4 | +57.221 | +57.276 | 2 | 8 | p597 | 6.88685 | 6.88685 | 0.009996 | 0.0205267
4 x Mesh | PLT6*519.8 | Undefined/Vitex W80HR | 0.3 | 0.9 | 519.8 | 6 | 870 | +51.017 | +51.023 | 2 | 8 | p219 | 0.873284 | 0.452223 | 0.000036 | 0.00256514
2 x Mesh | PL6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1990.9 | +57.151 | +57.227 | 2 | 8 | p608 | 6.67766 | 6.67766 | 0.009996 | 0.0199013
2 x Mesh | PL6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +57.066 | +57.156 | 2 | 8 | p611 | 6.67408 | 6.67408 | 0.009996 | 0.0198906
2 x Mesh | PL6*1666 | Undefined/Vitex W80HR | 0 | 6.9 | 1666 | 6 | 2031.8 | +56.729 | +56.862 | 2 | 8 | p600 | 6.81476 | 6.81476 | 0.009996 | 0.0203112
2 x Mesh | PL6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1968.8 | +56.592 | +56.734 | 2 | 8 | p607 | 6.60366 | 6.60366 | 0.009996 | 0.0196801
2 x Mesh | PL6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1988.8 | +56.277 | +56.445 | 2 | 8 | p615 | 6.67052 | 6.67052 | 0.009996 | 0.01988
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1991.2 | +56.113 | +56.283 | 7008 | 8 | p208 | 6.67864 | 3.31738 | 0.000036 | 0.0199043
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1991.2 | +55.948 | +56.118 | 7008 | 8 | p208 | 6.67864 | 3.31738 | 0.000036 | 0.0199043
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.9 | 1666 | 6 | 2037.4 | +55.779 | +55.953 | 7008 | 8 | p207 | 6.83299 | 3.39428 | 0.000036 | 0.0203656
Mesh | PL6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1968.8 | +56.592 | +56.734 | 2 | 8 | p606 | 2.88314 | 2.88314 | 0.004344 | 0.00855247
Mesh | PL6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1988.8 | +56.277 | +56.445 | 2 | 8 | p614 | 2.91228 | 2.91228 | 0.004344 | 0.00863917
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1991.2 | +56.113 | +56.283 | 7008 | 8 | p206 | 2.91587 | 1.44164 | 0.000036 | 0.00864986
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1991.2 | +55.948 | +56.118 | 7008 | 8 | p206 | 2.91587 | 1.44164 | 0.000036 | 0.00864986
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 2037.4 | +55.779 | +55.953 | 7008 | 8 | p205 | 2.98326 | 1.47506 | 0.000036 | 0.00885036
Mesh | PL6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1968.8 | +56.592 | +56.734 | 2 | 8 | p605 | 2.88314 | 2.88314 | 0.004344 | 0.00855247
Mesh | PL6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1988.8 | +56.277 | +56.445 | 2 | 8 | p614 | 2.91233 | 2.91233 | 0.004344 | 0.00863934
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +55.450 | +55.620 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1981.2 | +55.615 | +55.784 | 2 | 8 | p204 | 6.64509 | 3.30066 | 0.000036 | 0.019804
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +55.285 | +55.455 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +55.121 | +55.291 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +54.956 | +55.126 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.9 | 1666 | 6 | 2035.5 | +54.787 | +54.961 | 2 | 8 | p194 | 6.8267 | 3.39114 | 0.000036 | 0.0203468
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1985.5 | +54.623 | +54.792 | 2 | 8 | p203 | 6.6595 | 3.30784 | 0.000036 | 0.019847
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +54.458 | +54.628 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +54.293 | +54.463 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +54.128 | +54.298 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +53.963 | +54.133 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.9 | 1666 | 6 | 2035.5 | +53.795 | +53.969 | 2 | 8 | p194 | 6.8267 | 3.39114 | 0.000036 | 0.0203469
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1985.5 | +53.630 | +53.800 | 2 | 8 | p203 | 6.6595 | 3.30784 | 0.000036 | 0.019847
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +53.466 | +53.636 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +53.301 | +53.471 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +53.136 | +53.306 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +52.971 | +53.141 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.9 | 1666 | 6 | 2035.5 | +52.803 | +52.976 | 2 | 8 | p194 | 6.8267 | 3.39114 | 0.000036 | 0.0203469
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1985.5 | +52.638 | +52.808 | 2 | 8 | p203 | 6.6595 | 3.30784 | 0.000036 | 0.019847
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 8.2 | 1666 | 6 | 2458.6 | +51.022 | +51.231 | 2 | 8 | p202 | 8.24167 | 4.09609 | 0.000036 | 0.0245765
2 x Mesh | PLT6*1551 | Undefined/Vitex W80HR | 0 | 5.1 | 1551 | 6 | 1666 | +51.225 | +51.359 | 2 | 8 | p201 | 5.20654 | 2.58397 | 0.000036 | 0.0155038
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +52.473 | +52.643 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +52.309 | +52.478 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +52.144 | +52.314 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +51.354 | +51.524 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +51.979 | +52.149 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.9 | 1666 | 6 | 2035.5 | +51.810 | +51.984 | 2 | 8 | p194 | 6.8267 | 3.39114 | 0.000036 | 0.0203468
2 x Mesh | PLT6*1527 | Undefined/Vitex W80HR | 0 | 5.1 | 1527 | 6 | 1666 | +51.684 | +51.815 | 2 | 8 | p193 | 5.12628 | 2.54398 | 0.000036 | 0.0152639
2 x Mesh | PLT6*1666 | Undefined/Vitex W80HR | 0 | 6.7 | 1666 | 6 | 1989.9 | +51.519 | +51.689 | 2 | 8 | p192 | 6.67455 | 3.31534 | 0.000036 | 0.019892
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1981.2 | +55.615 | +55.784 | 2 | 8 | p199 | 2.90122 | 1.43438 | 0.000036 | 0.00860628
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +55.450 | +55.620 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +55.285 | +55.455 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +55.121 | +55.291 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +54.956 | +55.126 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 2035.5 | +54.787 | +54.961 | 2 | 8 | p197 | 2.98051 | 1.4737 | 0.000036 | 0.0088422
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1985.5 | +54.623 | +54.792 | 2 | 8 | p198 | 2.90752 | 1.4375 | 0.000036 | 0.008625
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +54.458 | +54.628 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +54.293 | +54.463 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +54.128 | +54.298 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +53.963 | +54.134 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 2035.5 | +53.795 | +53.969 | 2 | 8 | p197 | 2.98051 | 1.4737 | 0.000036 | 0.0088422
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1985.5 | +53.630 | +53.800 | 2 | 8 | p198 | 2.90751 | 1.4375 | 0.000036 | 0.008625
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +53.466 | +53.636 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +53.301 | +53.471 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +53.136 | +53.306 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +52.971 | +53.141 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 2035.5 | +52.803 | +52.976 | 2 | 8 | p197 | 2.98052 | 1.4737 | 0.000036 | 0.0088422
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1985.5 | +52.638 | +52.808 | 2 | 8 | p198 | 2.90751 | 1.4375 | 0.000036 | 0.008625
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +52.473 | +52.643 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +52.309 | +52.479 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +52.144 | +52.314 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +51.979 | +52.149 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864455
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 2035.5 | +51.810 | +51.984 | 2 | 8 | p197 | 2.98051 | 1.4737 | 0.000036 | 0.0088422
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.2 | 724 | 6 | 1527 | +51.684 | +51.816 | 2 | 8 | p196 | 2.23811 | 1.10555 | 0.000036 | 0.00663328
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +51.519 | +51.689 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864456
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.9 | 724 | 6 | 1989.9 | +51.354 | +51.524 | 2 | 8 | p195 | 2.91409 | 1.44076 | 0.000036 | 0.00864456
Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 3.6 | 724 | 6 | 2431.7 | +51.022 | +51.228 | 2 | 8 | p200 | 3.55894 | 1.76054 | 0.000036 | 0.0105632
2 x Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 2.3 | 724 | 6 | 1577.7 | +51.223 | +51.359 | 2 | 8 | p191 | 2.31211 | 1.14225 | 0.000036 | 0.00685348
Mesh | PLT6*724 | Undefined/Vitex W80HR | 0 | 3.6 | 724 | 6 | 2431.7 | +51.022 | +51.228 | 2 | 8 | p183 | 3.55894 | 1.76054 | 0.000036 | 0.0105632

# IfcDiscreteAccessory: Nut (144)
In: Undefined
Description: M16_NUT; Material: Undefined/4.8XOX
Tekla Common - Phase: 6; Class: 10
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 24 mm; Width: 27.7 mm; Length: 16 mm
Pset_PlateCommon - LoadBearing: yes; Reference: m891
BaseQuantities - NetArea: 1.33022e-09 m2; GrossArea: 0.00232831 m2; CrossSectionArea: 0.00049896 m2; NetVolume: 0.00000431773 m3; GrossVolume: 0.00000798338 m3
Name | Bottom elevation | Top elevation
6 x Nut | +52.838 | +52.856
6 x Nut | +52.847 | +52.866
6 x Nut | +52.857 | +52.875
6 x Nut | +52.866 | +52.885
6 x Nut | +52.876 | +52.894
6 x Nut | +52.885 | +52.904
6 x Nut | +52.895 | +52.913
6 x Nut | +52.904 | +52.923
6 x Nut | +52.827 | +52.845
6 x Nut | +52.817 | +52.835
6 x Nut | +52.808 | +52.826
6 x Nut | +52.798 | +52.816
6 x Nut | +52.789 | +52.807
6 x Nut | +52.779 | +52.797
6 x Nut | +52.770 | +52.788
21 x Nut | +52.930 | +52.948
21 x Nut | +52.758 | +52.777
6 x Nut | +52.924 | +52.942
6 x Nut | +52.752 | +52.770

# IfcDiscreteAccessory: PLATE (10)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Phase: 999; Class: 100
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Width: 10 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.0001 m2
Name | Description | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Height (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLATE | PLT10*240.3 | +53.146 | +53.366 | 3.1 | 28.2 | 240.3 | 265.8 | p92 | 0.0878595 | 0.0638711 | 0.000397047
2 x PLATE | PLT10*234.1 | +52.674 | +52.884 | 3.1 | 28.2 | 234.1 | 283.4 | p91 | 0.0864697 | 0.0663354 | 0.000389994
2 x PLATE | PLT10*223.7 | +52.184 | +52.377 | 3 | 28.2 | 223.7 | 305.1 | p90 | 0.0842088 | 0.0682558 | 0.000378501
2 x PLATE | PLT10*207.2 | +51.701 | +51.870 | 2.8 | 28.5 | 207.2 | 326.5 | p89 | 0.0802647 | 0.0676324 | 0.000358686
2 x PLATE | PLT10*181.5 | +51.212 | +51.367 | 3 | 28.6 | 181.5 | 376.9 | p88 | 0.0832268 | 0.0684213 | 0.000370223

# IfcDiscreteAccessory: Plate (5440)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
11 x Plate | FL6*80 | +58.280 | +58.360 | 9 | 99 | 0.2 | 0 | 51.2 | 0 | 46 | 6 | 46 | p647 | 0.008872 | 0.002116 | 0.000036 | 0.00002208 | 0.00002208
8 x Plate | PLT6*97.1 | +57.075 | +57.270 | 3 | 99 | 0.7 | 0 | 47 | 0 | 97.1 | 6 | 195.4 | p235 | 0.0324287 | 0.0189733 | 0.000036 | 0.0000879317 | 0.0000879317
6 x Plate | PL8*72 | +51.303 | +51.385 | 6 | 99 | 0.3 | 0 | 38.4 | 0 | 72 | 8 | 82 | p308 | 0.0131899 | 0.00590385 | 0.000064 | 0.0000437488 | 0.0000437488
6 x Plate | FL10*70 | +51.542 | +51.568 | 6 | 99 | 1.1 | 0 | 30.4 | 0 | 70 | 10 | 200 | p252 | 0.0334 | 0.0334 | 0.0007 | 0.00014 | 0.00014
6 x Plate | FL6*40 | +52.152 | +52.192 | 9 | 99 | 0.2 | 0 | 51.8 | 0 | 40 | 6 | 85 | p645 | 0.00829689 | 0.00339865 | 0.000036 | 0.0000203919 | 0.0000203919
3 x Plate | FL8*110 | +56.808 | +56.830 | 2 | 99 | 1.2 | 0 | 35.6 | 0 | 110 | 8 | 175.2 | p517 | 0.0430959 | 0.0192667 | 0.000064 | 0.000154134 | 0.000154134
3 x Plate | FL6*80 | +51.886 | +51.960 | 9 | 99 | 0.2 | 0 | 50.4 | 0 | 73.9 | 6 | 73.9 | p644 | 0.0101748 | 0.00546121 | 0.000036 | 0.000025722 | 0.000025722
3 x Plate | FL6*80 | +51.639 | +51.713 | 9 | 99 | 0.2 | 0 | 50.4 | 0 | 73.7 | 6 | 73.7 | p644 | 0.010146 | 0.00543651 | 0.000036 | 0.0000256417 | 0.0000256417
3 x Plate | FL6*80 | +51.390 | +51.464 | 9 | 99 | 0.2 | 0 | 50.4 | 0 | 73.9 | 6 | 73.9 | p644 | 0.0101748 | 0.00546121 | 0.000036 | 0.000025722 | 0.000025722
3 x Plate | FL8*130 | +55.780 | +55.799 | 2 | 99 | 2.2 | 0 | 34.8 | 0.1 | 130 | 8 | 265 | p539 | 0.07522 | 0.03445 | 0.000064 | 0.0002756 | 0.0002756
3 x Plate | FL8*130 | +55.751 | +55.770 | 2 | 99 | 2.1 | 0 | 34.8 | 0.1 | 130 | 8 | 260 | p532 | 0.07384 | 0.0338 | 0.000064 | 0.0002704 | 0.0002704
3 x Plate | FL8*130 | +54.788 | +54.806 | 2 | 99 | 2.1 | 0 | 34.8 | 0.1 | 130 | 8 | 260 | p536 | 0.07384 | 0.0338 | 0.000064 | 0.0002704 | 0.0002704
3 x Plate | FL8*130 | +52.774 | +52.793 | 2 | 99 | 2.1 | 0 | 34.8 | 0.1 | 130 | 8 | 260 | p536 | 0.07384 | 0.0338 | 0.000064 | 0.0002704 | 0.0002704
2 x Plate | PLT10*363.3 | +55.095 | +55.469 | 1 | 99 | 6.9 | 0 | 27.2 | 0.2 | 363.3 | 10 | 374.3 | p94 | 0.187688 | 0.135973 | 0.0001 | 0.000878317 | 0.000878317
2 x Plate | PLT12*230.7 | +54.659 | +55.087 | 1 | 99 | 8.8 | 0 | 23 | 0.2 | 230.7 | 12 | 428.2 | p110 | 0.202892 | 0.0987604 | 0.000144 | 0.00112618 | 0.00112618
2 x Plate | FL12*180 | +54.659 | +55.295 | 1 | 99 | 10.8 | 0 | 23 | 0.2 | 180 | 12 | 636.2 | p158 | 0.248607 | 0.248607 | 0.00216 | 0.00137411 | 0.00137411
2 x Plate | FL8*150 | +52.195 | +52.516 | 1 | 99 | 3.9 | 0 | 34.2 | 0.1 | 150 | 8 | 416.7 | p310 | 0.134078 | 0.134078 | 0.0012 | 0.000500043 | 0.000500043
3 x Plate | PL10*173 | +56.817 | +56.827 | 1 | 99 | 2.3 | 0 | 28.5 | 0.1 | 173 | 10 | 173 | p253 | 0.066778 | 0.029929 | 0.0001 | 0.00029929 | 0.00029929
3 x Plate | PL10*173 | +57.057 | +57.067 | 1 | 99 | 2.3 | 0 | 28.5 | 0.1 | 173 | 10 | 173 | p253 | 0.066778 | 0.029929 | 0.0001 | 0.00029929 | 0.00029929
6 x Plate | FL5*40 | +51.448 | +51.488 | 9 | 99 | 0.7 | 0 | 57.9 | 0 | 40 | 5 | 427 | p587 | 0.03883 | 0.03883 | 0.0002 | 0.0000854 | 0.0000854
3 x Plate | FL8*60 | +58.307 | +58.318 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90 | p520 | 0.013204 | 0.00540175 | 0.000064 | 0.000043214 | 0.000043214
3 x Plate | FL8*60 | +57.748 | +57.762 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90.2 | p520 | 0.0132071 | 0.00541314 | 0.000064 | 0.0000432252 | 0.0000432252
3 x Plate | FL8*60 | +57.760 | +57.773 | 2 | 99 | 0.3 | 0 | 39.1 | 0 | 60 | 8 | 85.4 | p518 | 0.0125496 | 0.00512504 | 0.000064 | 0.0000409046 | 0.0000409046
12 x Plate | PLT10*79.5 | +57.861 | +57.871 | 5 | 99 | 1.7 | 0 | 29.5 | 0.1 | 79.5 | 10 | 283.4 | p96 | 0.0501671 | 0.0225303 | 0.0001 | 0.000216303 | 0.000216303
6 x Plate | PL6*228.6 | +51.611 | +51.835 | 9 | 99 | 1.1 | 0 | 48.9 | 0.1 | 228.6 | 6 | 228.6 | p648 | 0.0536779 | 0.0522368 | 0.000036 | 0.000139751 | 0.000241001
6 x Plate | PL6*228.6 | +50.760 | +50.984 | 9 | 99 | 1.1 | 0 | 48.9 | 0.1 | 228.6 | 6 | 228.6 | p648 | 0.0536779 | 0.0522368 | 0.000036 | 0.000139751 | 0.000241001
6 x Plate | FL8*50 | +55.912 | +55.968 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | FL8*50 | +55.744 | +55.799 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | FL8*50 | +53.759 | +53.815 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | FL8*50 | +52.767 | +52.823 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
4 x Plate | PLT6*67 | +58.096 | +58.260 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 164.1 | p229 | 0.0244906 | 0.0109939 | 0.000036 | 0.0000653635 | 0.0000653635
4 x Plate | PLT6*67 | +57.943 | +58.107 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 164.3 | p229 | 0.0245236 | 0.011009 | 0.000036 | 0.0000654542 | 0.0000654542
Plate | PLT10*237.2 | +57.160 | +57.170 | 3 | 99 | 3.1 | 0 | 28.1 | 0.1 | 237.2 | 10 | 242.1 | -38ANp292 | 0.0882371 | 0.0574257 | 0.0001 | 0.000400373 | 0.000401452
Plate | PLT10*243.6 | +57.160 | +57.170 | 3 | 99 | 3.3 | 0 | 28 | 0.1 | 243.6 | 10 | 249.7 | -38ANp288 | 0.0927722 | 0.0608153 | 0.0001 | 0.000421832 | 0.000422911
Plate | PLT10*244 | +57.160 | +57.170 | 3 | 99 | 3.3 | 0 | 28 | 0.1 | 244 | 10 | 249.7 | -38ANp289 | 0.0927522 | 0.0609138 | 0.0001 | 0.000421712 | 0.000422791
Plate | PLT10*229.7 | +57.160 | +57.170 | 3 | 99 | 3.2 | 0 | 28.1 | 0.1 | 229.7 | 10 | 253.9 | -38ANp291 | 0.0894237 | 0.0583149 | 0.0001 | 0.000405852 | 0.000406931
Plate | PLT10*230.1 | +57.160 | +57.170 | 3 | 99 | 3.2 | 0 | 28.1 | 0.1 | 230.1 | 10 | 253.9 | -38ANp291 | 0.0894405 | 0.0584286 | 0.0001 | 0.000405912 | 0.000406991
Plate | PLT10*234.5 | +57.160 | +57.170 | 3 | 99 | 3.8 | 0 | 27.8 | 0.1 | 234.5 | 10 | 326 | -38ANp290 | 0.106103 | 0.0764414 | 0.0001 | 0.000485531 | 0.00048661
Plate | PLT10*245.4 | +57.160 | +57.170 | 3 | 99 | 3.3 | 0 | 28 | 0.1 | 245.4 | 10 | 249.7 | -38ANp289 | 0.0931147 | 0.0612697 | 0.0001 | 0.000423414 | 0.000424493
2 x Plate | PLT10*243.6 | +57.160 | +57.170 | 3 | 99 | 3.3 | 0 | 28 | 0.1 | 243.6 | 10 | 249.7 | -38ANp288 | 0.0927721 | 0.0608152 | 0.0001 | 0.000421831 | 0.000422911
Plate | PLT10*244 | +57.160 | +57.170 | 3 | 99 | 3.3 | 0 | 28 | 0.1 | 244 | 10 | 249.7 | -38ANp288 | 0.0927523 | 0.0609139 | 0.0001 | 0.000421712 | 0.000422791
3 x Plate | FL10*100 | +51.635 | +51.810 | 9 | 99 | 1.2 | 0 | 29.5 | 0 | 100 | 10 | 167.9 | -38AMp134 | 0.038938 | 0.038938 | 0.001 | 0.0001679 | 0.0001679
3 x Plate | FL10*100 | +51.635 | +51.810 | 6 | 99 | 1.2 | 0 | 29.5 | 0 | 100 | 10 | 167.9 | -38AMp120 | 0.03896 | 0.03896 | 0.001 | 0.000168 | 0.000168
3 x Plate | FL10*100 | +51.882 | +52.058 | 9 | 99 | 1.2 | 0 | 29.5 | 0 | 100 | 10 | 167.9 | -38AMp134 | 0.038938 | 0.038938 | 0.001 | 0.0001679 | 0.0001679
3 x Plate | FL10*100 | +51.882 | +52.058 | 6 | 99 | 1.2 | 0 | 29.5 | 0 | 100 | 10 | 167.9 | -38AMp120 | 0.03896 | 0.03896 | 0.001 | 0.000168 | 0.000168
3 x Plate | FL10*100 | +51.387 | +51.562 | 9 | 99 | 1.2 | 0 | 29.5 | 0 | 100 | 10 | 167.9 | -38AMp134 | 0.038938 | 0.038938 | 0.001 | 0.0001679 | 0.0001679
3 x Plate | FL10*100 | +51.386 | +51.562 | 6 | 99 | 1.2 | 0 | 29.5 | 0 | 100 | 10 | 167.9 | -38AMp120 | 0.03896 | 0.03896 | 0.001 | 0.000168 | 0.000168
3 x Plate | FL10*100 | +51.883 | +52.058 | 9 | 99 | 1.2 | 0 | 29.5 | 0 | 100 | 10 | 167.4 | p98 | 0.038828 | 0.038828 | 0.001 | 0.0001674 | 0.0001674
3 x Plate | PLT6*63 | +51.891 | +52.049 | 6 | 99 | 0.5 | 0 | 48 | 0 | 63 | 6 | 158.2 | p232 | 0.0220322 | 0.0099666 | 0.000036 | 0.0000584496 | 0.0000584496
3 x Plate | FL10*100 | +51.883 | +52.058 | 6 | 99 | 1.2 | 0 | 29.5 | 0 | 100 | 10 | 167.4 | p99 | 0.0388203 | 0.0388203 | 0.001 | 0.000167365 | 0.000167365
3 x Plate | FL10*100 | +51.635 | +51.810 | 9 | 99 | 1.2 | 0 | 29.5 | 0 | 100 | 10 | 167.9 | p98 | 0.038938 | 0.038938 | 0.001 | 0.0001679 | 0.0001679
3 x Plate | PLT6*63 | +51.643 | +51.801 | 6 | 99 | 0.5 | 0 | 48 | 0 | 63 | 6 | 158.2 | p232 | 0.0220322 | 0.0099666 | 0.000036 | 0.0000584496 | 0.0000584496
3 x Plate | FL10*100 | +51.634 | +51.810 | 6 | 99 | 1.2 | 0 | 29.5 | 0 | 100 | 10 | 167.9 | p99 | 0.03896 | 0.03896 | 0.001 | 0.000168 | 0.000168
3 x Plate | FL6*80 | +51.638 | +51.713 | 9 | 99 | 0.2 | 0 | 50.4 | 0 | 73.9 | 6 | 73.9 | p644 | 0.0101919 | 0.00547598 | 0.000036 | 0.0000257699 | 0.0000257699
3 x Plate | FL6*80 | +51.886 | +51.960 | 9 | 99 | 0.2 | 0 | 50.4 | 0 | 73.4 | 6 | 73.4 | p644 | 0.0100888 | 0.00538758 | 0.000036 | 0.0000254821 | 0.0000254821
3 x Plate | FL10*100 | +51.386 | +51.562 | 9 | 99 | 1.2 | 0 | 29.5 | 0 | 100 | 10 | 167.9 | p98 | 0.038938 | 0.038938 | 0.001 | 0.0001679 | 0.0001679
3 x Plate | PLT6*63 | +51.395 | +51.553 | 6 | 99 | 0.5 | 0 | 48 | 0 | 63 | 6 | 158.2 | p232 | 0.0220322 | 0.0099666 | 0.000036 | 0.0000584496 | 0.0000584496
3 x Plate | FL10*100 | +51.386 | +51.562 | 6 | 99 | 1.2 | 0 | 29.5 | 0 | 100 | 10 | 167.9 | p99 | 0.03896 | 0.03896 | 0.001 | 0.000168 | 0.000168
3 x Plate | FL6*80 | +51.390 | +51.464 | 9 | 99 | 0.2 | 0 | 50.4 | 0 | 73.9 | 6 | 73.9 | p644 | 0.0101748 | 0.00546122 | 0.000036 | 0.000025722 | 0.000025722
3 x Plate | PLT8*180.3 | +52.044 | +52.075 | 6 | 99 | 3.1 | 0 | 34.2 | 0.1 | 180.3 | 8 | 274.4 | -38AMp138 | 0.106215 | 0.04947 | 0.000064 | 0.00039576 | 0.00039576
Plate | PLT8*125.7 | +51.713 | +51.731 | 6 | 99 | 1.1 | 0 | 35.6 | 0 | 125.7 | 8 | 141.8 | -38AMp126 | 0.0383519 | 0.0178228 | 0.000064 | 0.000137242 | 0.00014258
3 x Plate | PLT8*156.7 | +51.825 | +51.856 | 6 | 99 | 2.8 | 0 | 34.4 | 0.1 | 156.7 | 8 | 283.4 | -38AMp137 | 0.0958787 | 0.0444182 | 0.000064 | 0.000355345 | 0.000355345
Plate | PLT8*126 | +51.464 | +51.483 | 6 | 99 | 1.1 | 0 | 35.6 | 0 | 126 | 8 | 142 | -38AMp126 | 0.038513 | 0.0178989 | 0.000064 | 0.00013785 | 0.000143188
3 x Plate | PLT8*156.7 | +51.577 | +51.608 | 6 | 99 | 2.8 | 0 | 34.4 | 0.1 | 156.7 | 8 | 283.4 | -38AMp137 | 0.0959078 | 0.0444321 | 0.000064 | 0.000355456 | 0.000355456
Plate | PLT8*126.2 | +51.702 | +51.720 | 6 | 99 | 1.1 | 0 | 35.6 | 0 | 126.2 | 8 | 142 | -38AMp125 | 0.0380184 | 0.0179217 | 0.000064 | 0.000136038 | 0.000143215
3 x Plate | PLT8*144.3 | +51.190 | +51.210 | 6 | 99 | 1.2 | 0 | 35.3 | 0 | 144.3 | 8 | 148.4 | -38AMp135 | 0.0475047 | 0.0214109 | 0.000064 | 0.000171287 | 0.000171287
3 x Plate | PLT8*151.8 | +51.315 | +51.348 | 6 | 99 | 2.8 | 0 | 34.4 | 0.1 | 151.8 | 8 | 292.6 | -38AMp136 | 0.095926 | 0.044408 | 0.000064 | 0.000355264 | 0.000355264
Plate | PLT8*134.7 | +51.453 | +51.472 | 6 | 99 | 1.1 | 0 | 35.5 | 0 | 134.7 | 8 | 142 | -38AMp124 | 0.0405547 | 0.0191222 | 0.000064 | 0.000145642 | 0.000152819
3 x Plate | FL8*130 | +52.133 | +52.157 | 6 | 99 | 1.4 | 0 | 35.2 | 0.1 | 130 | 8 | 207.3 | p513 | 0.0501658 | 0.0269486 | 0.000064 | 0.000181488 | 0.000181488
Plate | PLT8*146.1 | +51.948 | +51.968 | 6 | 99 | 1.4 | 0 | 35.1 | 0.1 | 146.1 | 8 | 161.9 | p514 | 0.0511917 | 0.023645 | 0.000064 | 0.000185616 | 0.000189159
Plate | PLT8*147.6 | +51.961 | +51.981 | 6 | 99 | 1.4 | 0 | 35.1 | 0.1 | 147.6 | 8 | 161.9 | p511 | 0.0507202 | 0.0239167 | 0.000064 | 0.000184186 | 0.000191325
Plate | PLT8*125.7 | +51.713 | +51.731 | 6 | 99 | 1.1 | 0 | 35.6 | 0 | 125.7 | 8 | 141.8 | -38AMp126 | 0.0383398 | 0.0178228 | 0.000064 | 0.000137198 | 0.00014258
Plate | PLT8*126 | +51.464 | +51.483 | 6 | 99 | 1.1 | 0 | 35.6 | 0 | 126 | 8 | 142.2 | -38AMp126 | 0.0385502 | 0.0179265 | 0.000064 | 0.000137971 | 0.000143409
Plate | PLT8*126.2 | +51.702 | +51.720 | 6 | 99 | 1.1 | 0 | 35.6 | 0 | 126.2 | 8 | 142.2 | -38AMp125 | 0.0380544 | 0.0179441 | 0.000064 | 0.000136174 | 0.000143393
2 x Plate | PLT8*134.7 | +51.453 | +51.472 | 6 | 99 | 1.1 | 0 | 35.5 | 0 | 134.7 | 8 | 142 | -38AMp124 | 0.0405545 | 0.0191222 | 0.000064 | 0.000145641 | 0.000152819
2 x Plate | PLT8*146.1 | +51.948 | +51.968 | 6 | 99 | 1.4 | 0 | 35.1 | 0.1 | 146.1 | 8 | 161.9 | p512 | 0.0501677 | 0.0236449 | 0.000064 | 0.000182078 | 0.000189159
Plate | PLT8*147.6 | +51.961 | +51.981 | 6 | 99 | 1.4 | 0 | 35.1 | 0.1 | 147.6 | 8 | 161.9 | p511 | 0.0507 | 0.0239167 | 0.000064 | 0.000184111 | 0.000191325
6 x Plate | PLT8*120 | +56.772 | +56.910 | 12 | 99 | 1.6 | 0 | 35.2 | 0.1 | 120 | 8 | 210 | -38ANp310 | 0.05568 | 0.05568 | 0.00096 | 0.0002016 | 0.0002016
6 x Plate | PL12*20 | +56.898 | +56.910 | 12 | 99 | 0.7 | 0 | 34.8 | 0 | 20 | 12 | 300 | p157 | 0.01968 | 0.01968 | 0.00024 | 0.000072 | 0.000072
6 x Plate | PL12*177 | +56.741 | +56.918 | 12 | 99 | 5 | 0 | 23.5 | 0.1 | 177 | 12 | 300 | p154 | 0.117648 | 0.0531 | 0.000144 | 0.0006372 | 0.0006372
Plate | PLT8*147.6 | +51.961 | +51.981 | 6 | 99 | 1.4 | 0 | 35.1 | 0.1 | 147.6 | 8 | 161.9 | p511 | 0.0507036 | 0.0239167 | 0.000064 | 0.000184124 | 0.000191325
Plate | PLT8*126 | +51.464 | +51.483 | 6 | 99 | 1.1 | 0 | 35.6 | 0 | 126 | 8 | 142.2 | -38AMp127 | 0.0383546 | 0.0179265 | 0.000064 | 0.000137261 | 0.000143409
Plate | PLT8*125.7 | +51.713 | +51.731 | 6 | 99 | 1.1 | 0 | 35.6 | 0 | 125.7 | 8 | 141.8 | -38AMp127 | 0.0381492 | 0.0178228 | 0.000064 | 0.000136506 | 0.00014258
Plate | PLT8*126.2 | +51.702 | +51.720 | 6 | 99 | 1.1 | 0 | 35.6 | 0 | 126.2 | 8 | 142.2 | -38AMp125 | 0.0380542 | 0.0179441 | 0.000064 | 0.000136173 | 0.000143393
6 x Plate | PLT10*211.4 | +57.280 | +57.516 | 3 | 99 | 3.5 | 0 | 28 | 0.1 | 211.4 | 10 | 333.2 | p87 | 0.0975359 | 0.0704288 | 0.0001 | 0.000444165 | 0.000444165
15 x Plate | FL10*90 | +57.270 | +57.280 | 3 | 99 | 1.1 | 0 | 29.9 | 0 | 90 | 10 | 160 | -38ANp251 | 0.0338 | 0.0338 | 0.0009 | 0.000144 | 0.000144
6 x Plate | PLT10*226.1 | +58.092 | +58.318 | 3 | 99 | 3 | 0 | 28.2 | 0.1 | 226.1 | 10 | 250 | p86 | 0.0835214 | 0.0565299 | 0.0001 | 0.000376926 | 0.000376926
6 x Plate | PLT10*237.6 | +57.280 | +57.740 | 3 | 99 | 5.7 | 0 | 27.8 | 0.2 | 237.6 | 10 | 459.8 | p82 | 0.156932 | 0.109256 | 0.0001 | 0.000722886 | 0.000722886
6 x Plate | PLT10*175 | +58.004 | +58.250 | 3 | 99 | 2.4 | 0 | 28.5 | 0.1 | 175 | 10 | 244.7 | p85 | 0.0700318 | 0.0428172 | 0.0001 | 0.000313429 | 0.000313429
3 x Plate | FL8*150 | +58.399 | +58.407 | 3 | 99 | 0.9 | 0 | 35.7 | 0 | 140 | 8 | 140 | p506 | 0.0371209 | 0.0196002 | 0.000064 | 0.000132282 | 0.000132282
3 x Plate | FL8*150 | +58.399 | +58.407 | 3 | 99 | 0.9 | 0 | 35.7 | 0 | 140 | 8 | 140 | p506 | 0.0371207 | 0.0196 | 0.000064 | 0.000132281 | 0.000132281
6 x Plate | FL8*150 | +58.372 | +58.383 | 3 | 99 | 1.1 | 0 | 35.7 | 0 | 150 | 8 | 150 | p505 | 0.0392701 | 0.0225033 | 0.000064 | 0.000140311 | 0.000140311
6 x Plate | FL8*150 | +58.326 | +58.337 | 3 | 99 | 1.1 | 0 | 35.7 | 0 | 150 | 8 | 150 | p505 | 0.0392701 | 0.0225033 | 0.000064 | 0.000140311 | 0.000140311
6 x Plate | PL6*67 | +58.215 | +58.379 | 3 | 99 | 0.5 | 0 | 48 | 0 | 67 | 6 | 163.9 | p619 | 0.0227223 | 0.010983 | 0.000036 | 0.0000604872 | 0.0000604872
3 x Plate | FL10*90 | +57.270 | +57.280 | 3 | 99 | 1.1 | 0 | 29.9 | 0 | 90 | 10 | 160 | p80 | 0.0338 | 0.0338 | 0.0009 | 0.000144 | 0.000144
3 x Plate | FL8*110 | +55.815 | +55.837 | 2 | 99 | 1.1 | 0 | 35.7 | 0 | 110 | 8 | 161 | p521 | 0.0397263 | 0.0176962 | 0.000064 | 0.000141569 | 0.000141569
3 x Plate | FL8*100 | +58.304 | +58.318 | 2 | 99 | 0.9 | 0 | 36.1 | 0 | 100 | 8 | 150 | p450 | 0.0339945 | 0.0149987 | 0.000064 | 0.00011998 | 0.00011998
Plate | FL8*110 | +57.743 | +57.762 | 2 | 99 | 1.2 | 0 | 35.7 | 0 | 110 | 8 | 170.1 | p451 | 0.0418925 | 0.0187058 | 0.000064 | 0.000149647 | 0.000149647
Plate | FL8*110 | +57.760 | +57.777 | 2 | 99 | 0.9 | 0 | 35.9 | 0 | 110 | 8 | 150.3 | p452 | 0.0372377 | 0.0165364 | 0.000064 | 0.00013229 | 0.00013229
2 x Plate | FL8*110 | +57.743 | +57.762 | 2 | 99 | 1.2 | 0 | 35.7 | 0 | 110 | 8 | 170 | p451 | 0.0418627 | 0.0186919 | 0.000064 | 0.000149535 | 0.000149535
2 x Plate | FL8*110 | +57.760 | +57.777 | 2 | 99 | 0.9 | 0 | 35.9 | 0 | 110 | 8 | 150.3 | p452 | 0.0372376 | 0.0165362 | 0.000064 | 0.000132289 | 0.000132289
3 x Plate | PLT8*50.9 | +57.626 | +57.682 | 2 | 99 | 0.3 | 0 | 39.7 | 0 | 50.9 | 8 | 90.9 | p519 | 0.0113315 | 0.00462483 | 0.000064 | 0.0000363352 | 0.0000363352
3 x Plate | PLT8*51.2 | +57.625 | +57.682 | 2 | 99 | 0.3 | 0 | 39.7 | 0 | 51.2 | 8 | 90.9 | p519 | 0.01136 | 0.00465126 | 0.000064 | 0.00003644 | 0.00003644
8 x Plate | PL12*109 | +55.185 | +55.197 | 12 | 99 | 3 | 0 | 24.5 | 0.1 | 109 | 12 | 310 | p151 | 0.0713394 | 0.03379 | 0.000144 | 0.00037128 | 0.00037128
8 x Plate | PL12*109 | +55.469 | +55.481 | 12 | 99 | 3 | 0 | 24.5 | 0.1 | 109 | 12 | 310 | p151 | 0.0713394 | 0.03379 | 0.000144 | 0.00037128 | 0.00037128
8 x Plate | PL12*109 | +55.753 | +55.765 | 12 | 99 | 3 | 0 | 24.5 | 0.1 | 109 | 12 | 310 | p151 | 0.0713394 | 0.03379 | 0.000144 | 0.00037128 | 0.00037128
3 x Plate | PL10*153.5 | +58.404 | +58.419 | 5 | 99 | 4.2 | 0 | 28 | 0.1 | 153.5 | 10 | 350 | p251 | 0.117484 | 0.117484 | 0.0035 | 0.000537075 | 0.000537075
3 x Plate | PL6*75 | +58.307 | +58.408 | 5 | 99 | 0.3 | 0 | 49.4 | 0 | 75 | 6 | 100.2 | p620 | 0.0130276 | 0.00751477 | 0.000036 | 0.0000335092 | 0.0000335092
3 x Plate | PL6*91.6 | +58.314 | +58.406 | 5 | 99 | 0.3 | 0 | 48.4 | 0 | 91.6 | 6 | 120 | p617 | 0.0182054 | 0.0109922 | 0.000036 | 0.000047954 | 0.000047954
3 x Plate | PL10*153.5 | +58.405 | +58.418 | 5 | 99 | 2.4 | 0 | 28.5 | 0.1 | 153.5 | 10 | 200 | p250 | 0.068449 | 0.068449 | 0.002 | 0.0003069 | 0.0003069
3 x Plate | PL10*153.5 | +58.428 | +58.443 | 5 | 99 | 4.2 | 0 | 28 | 0.1 | 153.5 | 10 | 350 | p249 | 0.117484 | 0.117484 | 0.0035 | 0.000537075 | 0.000537075
3 x Plate | PL6*75 | +58.331 | +58.432 | 5 | 99 | 0.3 | 0 | 49.4 | 0 | 75 | 6 | 100.2 | p620 | 0.0130276 | 0.00751477 | 0.000036 | 0.0000335092 | 0.0000335092
3 x Plate | PL6*91.6 | +58.338 | +58.430 | 5 | 99 | 0.3 | 0 | 48.4 | 0 | 91.6 | 6 | 120 | p617 | 0.0182054 | 0.0109922 | 0.000036 | 0.000047954 | 0.000047954
3 x Plate | PL10*153.5 | +58.429 | +58.442 | 5 | 99 | 2.4 | 0 | 28.5 | 0.1 | 153.5 | 10 | 200 | p250 | 0.068449 | 0.068449 | 0.002 | 0.0003069 | 0.0003069
3 x Plate | PL10*153.5 | +58.452 | +58.468 | 5 | 99 | 4.2 | 0 | 28 | 0.1 | 153.5 | 10 | 350 | p249 | 0.117484 | 0.117484 | 0.0035 | 0.000537075 | 0.000537075
3 x Plate | PL6*75 | +58.355 | +58.456 | 5 | 99 | 0.3 | 0 | 49.4 | 0 | 75 | 6 | 100.2 | p620 | 0.0130276 | 0.00751477 | 0.000036 | 0.0000335092 | 0.0000335092
3 x Plate | PL6*91.6 | +58.363 | +58.454 | 5 | 99 | 0.3 | 0 | 48.4 | 0 | 91.6 | 6 | 120 | p617 | 0.0182054 | 0.0109922 | 0.000036 | 0.000047954 | 0.000047954
3 x Plate | PL10*153.5 | +58.453 | +58.466 | 5 | 99 | 2.4 | 0 | 28.5 | 0.1 | 153.5 | 10 | 200 | p250 | 0.068449 | 0.068449 | 0.002 | 0.0003069 | 0.0003069
3 x Plate | PL10*153.5 | +58.476 | +58.492 | 5 | 99 | 4.2 | 0 | 28 | 0.1 | 153.5 | 10 | 350 | p249 | 0.117484 | 0.117484 | 0.0035 | 0.000537075 | 0.000537075
3 x Plate | PL6*75 | +58.379 | +58.480 | 5 | 99 | 0.3 | 0 | 49.4 | 0 | 75 | 6 | 100.2 | p620 | 0.0130276 | 0.00751477 | 0.000036 | 0.0000335092 | 0.0000335092
3 x Plate | PL6*91.6 | +58.387 | +58.478 | 5 | 99 | 0.3 | 0 | 48.4 | 0 | 91.6 | 6 | 120 | p617 | 0.0182054 | 0.0109922 | 0.000036 | 0.000047954 | 0.000047954
3 x Plate | PL10*153.5 | +58.477 | +58.490 | 5 | 99 | 2.4 | 0 | 28.5 | 0.1 | 153.5 | 10 | 200 | p250 | 0.068449 | 0.068449 | 0.002 | 0.0003069 | 0.0003069
3 x Plate | PL10*153.5 | +58.500 | +58.516 | 5 | 99 | 4.2 | 0 | 28 | 0.1 | 153.5 | 10 | 350 | p249 | 0.117484 | 0.117484 | 0.0035 | 0.000537075 | 0.000537075
3 x Plate | PL6*75 | +58.403 | +58.505 | 5 | 99 | 0.3 | 0 | 49.4 | 0 | 75 | 6 | 100.2 | p620 | 0.0130276 | 0.00751477 | 0.000036 | 0.0000335092 | 0.0000335092
3 x Plate | PL6*91.6 | +58.411 | +58.502 | 5 | 99 | 0.3 | 0 | 48.4 | 0 | 91.6 | 6 | 120 | p617 | 0.0182054 | 0.0109922 | 0.000036 | 0.000047954 | 0.000047954
3 x Plate | PL10*153.5 | +58.501 | +58.515 | 5 | 99 | 2.4 | 0 | 28.5 | 0.1 | 153.5 | 10 | 200 | p250 | 0.068449 | 0.068449 | 0.002 | 0.0003069 | 0.0003069
3 x Plate | PL10*153.5 | +58.524 | +58.540 | 5 | 99 | 4.2 | 0 | 28 | 0.1 | 153.5 | 10 | 350 | p248 | 0.117484 | 0.117484 | 0.0035 | 0.000537075 | 0.000537075
3 x Plate | PL6*75 | +58.427 | +58.529 | 5 | 99 | 0.3 | 0 | 49.4 | 0 | 75 | 6 | 100.2 | p620 | 0.0130276 | 0.00751477 | 0.000036 | 0.0000335092 | 0.0000335092
3 x Plate | PL6*91.6 | +58.435 | +58.526 | 5 | 99 | 0.3 | 0 | 48.4 | 0 | 91.6 | 6 | 120 | p617 | 0.0182054 | 0.0109922 | 0.000036 | 0.000047954 | 0.000047954
3 x Plate | PL10*153.5 | +58.525 | +58.539 | 5 | 99 | 2.4 | 0 | 28.5 | 0.1 | 153.5 | 10 | 200 | p250 | 0.068449 | 0.068449 | 0.002 | 0.0003069 | 0.0003069
8 x Plate | FL8*90 | +56.743 | +56.822 | 3 | 99 | 0.3 | 0 | 37.9 | 0 | 78.6 | 8 | 78.6 | p449 | 0.0168452 | 0.0168452 | 0.00072 | 0.0000565905 | 0.0000565905
8 x Plate | FL8*90 | +56.735 | +56.743 | 3 | 99 | 1.1 | 0 | 36 | 0 | 90 | 8 | 200 | p447 | 0.0406406 | 0.0406406 | 0.00072 | 0.000144002 | 0.000144002
4 x Plate | FL8*70 | +50.250 | +50.325 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 70 | 8 | 75.3 | p448 | 0.0128731 | 0.0128731 | 0.00056 | 0.0000421907 | 0.0000421907
8 x Plate | FL8*90 | +50.242 | +50.250 | 2 | 99 | 1.1 | 0 | 36 | 0 | 90 | 8 | 200 | p446 | 0.0406406 | 0.0406406 | 0.00072 | 0.000144002 | 0.000144002
4 x Plate | FL8*70 | +50.250 | +50.325 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 70 | 8 | 75.3 | p448 | 0.0128732 | 0.0128732 | 0.00056 | 0.0000421909 | 0.0000421909
6 x Plate | FL10*90 | +58.411 | +58.509 | 4 | 99 | 0.7 | 0 | 30.8 | 0 | 90 | 10 | 97.5 | p78 | 0.0202657 | 0.0087751 | 0.0001 | 0.0000837503 | 0.0000837503
6 x Plate | FL10*90 | +58.411 | +58.509 | 4 | 99 | 0.7 | 0 | 30.8 | 0 | 90 | 10 | 97.5 | p78 | 0.0202651 | 0.00877481 | 0.0001 | 0.0000837473 | 0.0000837473
6 x Plate | PLT10*104.3 | +58.404 | +58.509 | 5 | 99 | 1.1 | 0 | 29.7 | 0 | 104.3 | 10 | 150 | p76 | 0.0331294 | 0.0156583 | 0.0001 | 0.000142252 | 0.000142252
6 x Plate | PLT10*104.3 | +58.404 | +58.509 | 5 | 99 | 1.1 | 0 | 29.7 | 0 | 104.3 | 10 | 150 | p76 | 0.0331284 | 0.0156578 | 0.0001 | 0.000142248 | 0.000142248
4 x Plate | PLT6*67 | +57.708 | +57.872 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244784 | 0.0109883 | 0.000036 | 0.0000653298 | 0.0000653298
4 x Plate | PL50*50 | +55.180 | +55.230 | 12 | 99 | 0.9 | 0 | 15.3 | 0 | 50 | 50 | 50 | p595 | 0.015 | 0.015 | 0.0025 | 0.000125 | 0.000125
4 x Plate | PL50*50 | +55.720 | +55.770 | 12 | 99 | 0.9 | 0 | 15.3 | 0 | 50 | 50 | 50 | p595 | 0.015 | 0.015 | 0.0025 | 0.000125 | 0.000125
4 x Plate | PL12*310 | +55.185 | +55.765 | 12 | 99 | 15.9 | 0 | 22.7 | 0.3 | 310 | 12 | 580 | p170 | 0.362037 | 0.38096 | 0.00372 | 0.00202373 | 0.0021576
4 x Plate | FL16*200 | +55.175 | +55.775 | 12 | 99 | 15.1 | 0 | 17.6 | 0.3 | 200 | 16 | 600 | p677 | 0.2656 | 0.2656 | 0.0032 | 0.00192 | 0.00192
6 x Plate | PLT6*67 | +57.475 | +57.639 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.4 | p229 | 0.0243903 | 0.0109479 | 0.000036 | 0.0000650872 | 0.0000650872
6 x Plate | FL8*50 | +54.752 | +54.807 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
2 x Plate | PLT6*67 | +58.096 | +58.260 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
2 x Plate | PLT6*67 | +57.943 | +58.107 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
Plate | PLT6*67 | +57.708 | +57.872 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244691 | 0.010984 | 0.000036 | 0.0000653042 | 0.0000653042
12 x Plate | FL6*40 | +58.150 | +58.190 | 9 | 99 | 0.2 | 0 | 51.8 | 0 | 40 | 6 | 85 | p646 | 0.00829963 | 0.00339984 | 0.000036 | 0.000020399 | 0.000020399
6 x Plate | PL6*228.6 | +57.865 | +58.089 | 9 | 99 | 1.1 | 0 | 48.9 | 0.1 | 228.6 | 6 | 228.6 | p648 | 0.0536779 | 0.0522368 | 0.000036 | 0.000139751 | 0.000241001
6 x Plate | PL6*228.6 | +57.248 | +57.472 | 12 | 99 | 1.1 | 0 | 48.9 | 0.1 | 228.6 | 6 | 228.6 | p648 | 0.0536779 | 0.0522368 | 0.000036 | 0.000139751 | 0.000241001
6 x Plate | FL5*40 | +57.185 | +57.225 | 12 | 99 | 0.7 | 0 | 57.8 | 0 | 40 | 5 | 520 | p589 | 0.0472 | 0.0472 | 0.0002 | 0.000104 | 0.000104
2 x Plate | FL10*150 | +57.135 | +57.250 | 3 | 99 | 1.4 | 0 | 29.5 | 0 | 115 | 10 | 115 | p74 | 0.0398 | 0.0398 | 0.0015 | 0.0001725 | 0.0001725
6 x Plate | FL10*150 | +57.135 | +57.250 | 3 | 99 | 1.4 | 0 | 29.5 | 0 | 115 | 10 | 115 | p75 | 0.0398 | 0.0398 | 0.0015 | 0.0001725 | 0.0001725
19 x Plate | PLT8*218.7 | +56.889 | +57.194 | 3 | 99 | 3.2 | 0 | 34 | 0.1 | 218.7 | 8 | 302.4 | p445 | 0.107203 | 0.0661306 | 0.000064 | 0.00040138 | 0.00040138
4 x Plate | PLT8*291.6 | +56.767 | +57.173 | 3 | 99 | 5.7 | 0 | 33.5 | 0.2 | 291.6 | 8 | 402.8 | p444 | 0.187372 | 0.11744 | 0.000064 | 0.000712936 | 0.000712936
Plate | PLT10*95 | +51.413 | +51.553 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p68 | 0.0288431 | 0.0132892 | 0.0001 | 0.000122711 | 0.000135859
6 x Plate | PLT10*140.4 | +56.735 | +56.745 | 3 | 99 | 1.7 | 0 | 28.9 | 0.1 | 140.4 | 10 | 160 | -38ANp4 | 0.050936 | 0.050936 | 0.0016 | 0.00022464 | 0.00022464
2 x Plate | PL8*278.5 | +56.829 | +57.157 | 3 | 99 | 4.7 | 0 | 33.7 | 0.2 | 278.5 | 8 | 328.4 | p303 | 0.153688 | 0.0914471 | 0.000064 | 0.000581092 | 0.000581092
2 x Plate | PL8*278.5 | +56.747 | +57.157 | 3 | 99 | 5.7 | 0 | 33.5 | 0.2 | 278.5 | 8 | 410.4 | p304 | 0.187049 | 0.114281 | 0.000064 | 0.000710397 | 0.000710397
2 x Plate | PLT12*90.7 | +56.747 | +57.093 | 3 | 99 | 3 | 0 | 24.8 | 0.1 | 90.7 | 12 | 345.6 | p112 | 0.0720521 | 0.0313459 | 0.000144 | 0.000370751 | 0.000370751
2 x Plate | PLT12*90.7 | +56.747 | +57.257 | 3 | 99 | 4.2 | 0 | 24.5 | 0.1 | 90.7 | 12 | 510.3 | p116 | 0.104771 | 0.0462842 | 0.000144 | 0.00054461 | 0.00054461
2 x Plate | PL12*190 | +56.735 | +56.747 | 3 | 99 | 7.6 | 0.1 | 23.2 | 0.2 | 190 | 12 | 423 | p145 | 0.175452 | 0.08037 | 0.000144 | 0.00096444 | 0.00096444
4 x Plate | PLT12*90.7 | +56.829 | +57.257 | 3 | 99 | 3.6 | 0 | 24.6 | 0.1 | 90.7 | 12 | 428.2 | p117 | 0.087928 | 0.0388469 | 0.000144 | 0.000455363 | 0.000455363
13 x Plate | PL8*328.2 | +56.700 | +57.157 | 3 | 99 | 7.1 | 0 | 33.3 | 0.2 | 328.2 | 8 | 453.3 | p305 | 0.236042 | 0.148758 | 0.000064 | 0.000903032 | 0.000903032
Plate | PLT10*179.4 | +57.160 | +57.170 | 3 | 99 | 3.2 | 0 | 28.1 | 0.1 | 179.4 | 10 | 297.9 | -38ANp293 | 0.0886173 | 0.0534418 | 0.0001 | 0.000401433 | 0.000402527
Plate | PLT10*179.4 | +57.160 | +57.170 | 3 | 99 | 3.2 | 0 | 28.1 | 0.1 | 179.4 | 10 | 297.9 | -38ANp293 | 0.0886176 | 0.0534418 | 0.0001 | 0.00040142 | 0.000402527
Plate | PLT10*118.3 | +57.160 | +57.170 | 3 | 99 | 2.1 | 0 | 28.9 | 0.1 | 118.3 | 10 | 288.8 | p66 | 0.0595747 | 0.0341675 | 0.0001 | 0.000262233 | 0.000262233
4 x Plate | PLT10*159 | +50.254 | +50.413 | 1 | 99 | 3.5 | 0 | 28 | 0.1 | 159 | 10 | 324.1 | p64 | 0.0959534 | 0.0515226 | 0.0001 | 0.000435963 | 0.000435963
4 x Plate | PLT10*162.5 | +51.205 | +51.400 | 1 | 99 | 2 | 0 | 29.1 | 0.1 | 162.5 | 10 | 246 | p59 | 0.0546052 | 0.0399649 | 0.0001 | 0.000239428 | 0.000239428
4 x Plate | PLT10*137.5 | +52.028 | +52.166 | 1 | 99 | 5.1 | 0 | 28.1 | 0.1 | 137.5 | 10 | 570.8 | p57 | 0.143772 | 0.0784996 | 0.0001 | 0.000651384 | 0.000651384
4 x Plate | PLT10*154.4 | +51.709 | +51.929 | 1 | 99 | 2 | 0 | 28.7 | 0.1 | 154.4 | 10 | 217.5 | p60 | 0.0563481 | 0.0335743 | 0.0001 | 0.000249105 | 0.000249105
4 x Plate | PLT10*164.8 | +50.254 | +50.419 | 1 | 99 | 2.7 | 0 | 28.2 | 0.1 | 164.8 | 10 | 254.5 | p65 | 0.076097 | 0.041923 | 0.0001 | 0.000343403 | 0.000343403
4 x Plate | PLT10*178.2 | +52.981 | +53.159 | 1 | 99 | 4.7 | 0 | 28 | 0.1 | 178.2 | 10 | 476.6 | p58 | 0.130599 | 0.0849194 | 0.0001 | 0.000594291 | 0.000594291
4 x Plate | PLT10*180.2 | +50.254 | +50.434 | 1 | 99 | 2.7 | 0 | 28.2 | 0.1 | 180.3 | 10 | 231 | p61 | 0.0748761 | 0.0416291 | 0.0001 | 0.00033826 | 0.00033826
4 x Plate | PLT10*156.8 | +52.184 | +52.425 | 1 | 99 | 2 | 0 | 28.9 | 0.1 | 156.7 | 10 | 195.4 | p53 | 0.0537888 | 0.0306115 | 0.0001 | 0.000237286 | 0.000237286
4 x Plate | PLT10*170.9 | +53.980 | +54.151 | 1 | 99 | 3.3 | 0 | 28.5 | 0.1 | 170.9 | 10 | 391.6 | p56 | 0.0928079 | 0.0669326 | 0.0001 | 0.000415088 | 0.000415088
4 x Plate | PLT10*241.8 | +52.612 | +52.974 | 1 | 99 | 4.8 | 0 | 27.5 | 0.1 | 241.8 | 10 | 283.1 | p51 | 0.133865 | 0.0684601 | 0.0001 | 0.000620582 | 0.000620582
4 x Plate | PLT10*189 | +54.955 | +55.144 | 1 | 99 | 3.5 | 0 | 28.2 | 0.1 | 189 | 10 | 360.6 | p55 | 0.0955843 | 0.0681424 | 0.0001 | 0.000430886 | 0.000430886
4 x Plate | PLT10*182.7 | +50.254 | +50.437 | 1 | 99 | 2.4 | 0 | 28.2 | 0.1 | 182.7 | 10 | 205.9 | p62 | 0.0686851 | 0.0376286 | 0.0001 | 0.000309133 | 0.000309133
