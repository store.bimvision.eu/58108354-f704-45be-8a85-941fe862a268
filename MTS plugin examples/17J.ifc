Properties of the parts of a building model (IFC2X3), part 14 of 16

# IfcElementAssembly (3904)
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Rubber |  | 0 | +58.349 | +58.399 | 17/D-E | A837 | 28
2 x Rubber |  | 0 | +58.349 | +58.399 | 17/C-D | A837 | 28
4 x Rubber |  | 0 | +58.266 | +58.316 | 17-18/D-E | A837 | 28
2 x Steel Assembly | RIGID_FRAME | 0.7 | +58.266 | +58.399 | 17-18/D-E | A772 | 10
8 x Rubber |  | 0 | +58.266 | +58.316 | 17-18/C-D | A837 | 28
4 x Steel Assembly | RIGID_FRAME | 0.7 | +58.266 | +58.399 | 17-18/C-D | A772 | 10
2 x Steel Assembly | RIGID_FRAME | 0.7 | +58.183 | +58.316 | 17-18/D-E | A772 | 10
4 x Steel Assembly | RIGID_FRAME | 0.7 | +58.183 | +58.316 | 17-18/C-D | A772 | 10
Rubber |  | 0 | +58.349 | +58.399 | 17-18/D-E | A837 | 28
2 x Rubber |  | 0 | +58.349 | +58.399 | 17-18/C-D | A837 | 28
Rubber |  | 0 | +58.349 | +58.399 | 18/D-E | A837 | 28
2 x Rubber |  | 0 | +58.349 | +58.399 | 18/C-D | A837 | 28
2 x Steel Assembly | RIGID_FRAME | 0.7 | +58.266 | +58.399 | 18-19/D-E | A772 | 10
4 x Rubber |  | 0 | +58.266 | +58.316 | 18-19/D-E | A837 | 28
4 x Steel Assembly | RIGID_FRAME | 0.7 | +58.266 | +58.399 | 18-19/C-D | A772 | 10
8 x Rubber |  | 0 | +58.266 | +58.316 | 18-19/C-D | A837 | 28
2 x Steel Assembly | RIGID_FRAME | 0.7 | +58.183 | +58.316 | 18-19/D-E | A772 | 10
4 x Steel Assembly | RIGID_FRAME | 0.7 | +58.183 | +58.316 | 18-19/C-D | A772 | 10
2 x Rubber |  | 0 | +58.349 | +58.399 | 18-19/D-E | A837 | 28
4 x Rubber |  | 0 | +58.349 | +58.399 | 18-19/C-D | A837 | 28
2 x Steel Assembly | RIGID_FRAME | 0.7 | +58.070 | +58.140 | 16-17/C-D | A420 | 70
Steel Assembly | RIGID_FRAME | 0.7 | +58.070 | +58.140 | 16-17/D-E | A420 | 70
Steel Assembly | RIGID_FRAME | 14.9 | +56.759 | +58.285 | 17-19/D-E | A295 | 80
Steel Assembly | RIGID_FRAME | 38.7 | +56.735 | +58.317 | 18-19/D-E | A104 | 246.424
Steel Assembly | RIGID_FRAME | 38.7 | +56.735 | +58.317 | 18-19/C-D | A103 | 246.424
2 x Steel Assembly | RIGID_FRAME | 14.9 | +56.759 | +58.285 | 17-19/B-C | A295 | 80
4 x Rubber |  | 0 | +58.266 | +58.316 | 16-17/B-C | A837 | 28
2 x Steel Assembly | RIGID_FRAME | 0.7 | +58.266 | +58.399 | 16-17/B-C | A772 | 10
2 x Steel Assembly | RIGID_FRAME | 0.7 | +58.183 | +58.316 | 16-17/B-C | A772 | 10
2 x Rubber |  | 0 | +58.349 | +58.399 | 17/B-C | A837 | 28
8 x Rubber |  | 0 | +58.266 | +58.316 | 17-18/B-C | A837 | 28
4 x Steel Assembly | RIGID_FRAME | 0.7 | +58.266 | +58.399 | 17-18/B-C | A772 | 10
4 x Steel Assembly | RIGID_FRAME | 0.7 | +58.183 | +58.316 | 17-18/B-C | A772 | 10
2 x Rubber |  | 0 | +58.349 | +58.399 | 17-18/B-C | A837 | 28
2 x Rubber |  | 0 | +58.349 | +58.399 | 18/B-C | A837 | 28
8 x Rubber |  | 0 | +58.266 | +58.316 | 18-19/B-C | A837 | 28
4 x Steel Assembly | RIGID_FRAME | 0.7 | +58.266 | +58.399 | 18-19/B-C | A772 | 10
4 x Steel Assembly | RIGID_FRAME | 0.7 | +58.183 | +58.316 | 18-19/B-C | A772 | 10
4 x Rubber |  | 0 | +58.349 | +58.399 | 18-19/B-C | A837 | 28
2 x Steel Assembly | RIGID_FRAME | 0.7 | +58.070 | +58.140 | 16-17/B-C | A420 | 70
Steel Assembly | RIGID_FRAME | 46.2 | +58.317 | +58.477 | 16/B-D | A425 | 205
Steel Assembly | RIGID_FRAME | 38.7 | +56.735 | +58.317 | 18-19/C-D | A104 | 246.424
Steel Assembly | RIGID_FRAME | 38.7 | +56.735 | +58.317 | 18-19/B-C | A103 | 246.424
Steel Assembly | RIGID_FRAME | 1.7 | +55.537 | +55.557 | 17-18/B-C | A826 | 20
Steel Assembly | RIGID_FRAME | 1.7 | +55.695 | +55.715 | 17-18/B-C | A826 | 20
Steel Assembly | RIGID_FRAME | 1.7 | +55.537 | +55.557 | 17-18/A-B | A826 | 20
Steel Assembly | RIGID_FRAME | 1.7 | +55.695 | +55.715 | 17-18/A-B | A826 | 20
Steel Assembly | RIGID_FRAME | 21.5 | +58.539 | +59.395 | 20-21/B-C | A655 | 808.037
Steel Assembly | RIGID_FRAME | 21.5 | +58.539 | +59.395 | 20-21/C-D | A656 | 856.28
Steel Assembly | RIGID_FRAME | 21.5 | +58.539 | +59.395 | 20-21/A-B | A656 | 856.28
Steel Assembly | RIGID_FRAME | 9.9 | +57.791 | +58.411 | 15-16/A-B | A441 | 60
2 x Rubber |  | 0 | +58.266 | +58.316 | 16-17/A-B | A837 | 28
Steel Assembly | RIGID_FRAME | 0.7 | +58.266 | +58.399 | 16-17/A-B | A772 | 10
Steel Assembly | RIGID_FRAME | 0.7 | +58.183 | +58.316 | 16-17/A-B | A772 | 10
Rubber |  | 0 | +58.349 | +58.399 | 17/A-B | A837 | 28
4 x Rubber |  | 0 | +58.266 | +58.316 | 17-18/A-B | A837 | 28
2 x Steel Assembly | RIGID_FRAME | 0.7 | +58.266 | +58.399 | 17-18/A-B | A772 | 10
2 x Steel Assembly | RIGID_FRAME | 0.7 | +58.183 | +58.316 | 17-18/A-B | A772 | 10
Rubber |  | 0 | +58.349 | +58.399 | 17-18/A-B | A837 | 28
Rubber |  | 0 | +58.349 | +58.399 | 18/A-B | A837 | 28
4 x Rubber |  | 0 | +58.266 | +58.316 | 18-19/A-B | A837 | 28
2 x Steel Assembly | RIGID_FRAME | 0.7 | +58.266 | +58.399 | 18-19/A-B | A772 | 10
2 x Steel Assembly | RIGID_FRAME | 0.7 | +58.183 | +58.316 | 18-19/A-B | A772 | 10
2 x Rubber |  | 0 | +58.349 | +58.399 | 18-19/A-B | A837 | 28
Steel Assembly | RIGID_FRAME | 0.7 | +58.070 | +58.140 | 16-17/A-B | A420 | 70
Steel Assembly | RIGID_FRAME | 38.7 | +56.735 | +58.317 | 18-19/B-C | A104 | 246.424
Steel Assembly | RIGID_FRAME | 14.9 | +56.759 | +58.285 | 17-19/A-B | A295 | 80
Steel Assembly | RIGID_FRAME | 38.7 | +56.735 | +58.317 | 18-19/A-B | A103 | 246.424
Steel Assembly |  | 0 | +57.160 | +58.300 | 17-18/D-E | A165 | 160
Steel Assembly |  | 0 | +57.165 | +58.300 | 13/D-E | A447 | 160
Steel Assembly |  | 0 | +57.160 | +58.300 | 17/D-E | A165 | 160
Steel Assembly |  | 0 | +57.160 | +58.300 | 16-17/D-E | A165 | 160
Steel Assembly |  | 0 | +57.160 | +58.300 | 16/D-E | A165 | 160
Steel Assembly |  | 0 | +57.160 | +58.300 | 15-16/D-E | A165 | 160
Steel Assembly |  | 0 | +57.160 | +58.300 | 15/D-E | A165 | 160
2 x Steel Assembly |  | 0 | +57.160 | +58.300 | 13-14/D-E | A165 | 160
Steel Assembly |  | 0 | +57.160 | +58.300 | 13/D-E | A165 | 160
Steel Assembly |  | 0 | +57.160 | +58.300 | 17-18/A-B | A165 | 160
Steel Assembly |  | 0 | +57.165 | +58.300 | 13/A-B | A447 | 160
Steel Assembly |  | 0 | +57.160 | +58.300 | 17/A-B | A165 | 160
Steel Assembly |  | 0 | +57.160 | +58.300 | 16-17/A-B | A165 | 160
Steel Assembly |  | 0 | +57.160 | +58.300 | 16/A-B | A165 | 160
Steel Assembly |  | 0 | +57.160 | +58.300 | 15-16/A-B | A165 | 160
Steel Assembly |  | 0 | +57.160 | +58.300 | 15/A-B | A165 | 160
2 x Steel Assembly |  | 0 | +57.160 | +58.300 | 13-14/A-B | A165 | 160
Steel Assembly |  | 0 | +57.160 | +58.300 | 13/A-B | A165 | 160
Steel Assembly | RIGID_FRAME | 8.6 | +57.090 | +57.160 | 17-18/D-E | A207 | 70
Steel Assembly | RIGID_FRAME | 29.1 | +57.110 | +57.270 | 17/D-E | A51 | 476.118
Steel Assembly | RIGID_FRAME | 8.6 | +57.090 | +57.160 | 16-17/A-B | A212 | 70
Steel Assembly | RIGID_FRAME | 12.5 | +57.090 | +57.160 | 15-16/A-B | A211 | 70
Steel Assembly | RIGID_FRAME | 114.9 | +57.067 | +57.400 | 15-17/A-B | A106 | 260.993
Steel Assembly | RIGID_FRAME | 21.1 | +57.110 | +57.270 | 16-17/B-C | A73 | 150
Steel Assembly | RIGID_FRAME | 21.1 | +57.110 | +57.270 | 17-18/B-C | A52 | 150
Steel Assembly | RIGID_FRAME | 12.5 | +57.090 | +57.160 | 15-16/D-E | A211 | 70
Steel Assembly | RIGID_FRAME | 114.9 | +57.067 | +57.400 | 15-17/D-E | A105 | 260.993
Steel Assembly | RIGID_FRAME | 25 | +57.130 | +57.270 | 14-15/A-B | A98 | 532.086
Steel Assembly | RIGID_FRAME | 4.6 | +57.090 | +57.160 | 13-14/A-B | A210 | 70
Steel Assembly | RIGID_FRAME | 25 | +57.130 | +57.270 | 13-14/A-B | A100 | 532.086
Steel Assembly | RIGID_FRAME | 6.3 | +57.090 | +57.160 | 13-14/A-B | A216 | 70
4 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 14/A-B | A678 | 90
3 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 13-14/A-B | -38AN131 | 90
Steel Assembly | RIGID_FRAME | 25 | +57.130 | +57.270 | 13-14/A-B | A99 | 532.086
7 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 13-14/A-B | -38AN154 | 90
Steel Assembly | RIGID_FRAME | 4.6 | +57.090 | +57.160 | 13-14/A-B | A208 | 70
Steel Assembly | RIGID_FRAME | 23.3 | +57.130 | +57.270 | 13-14/A-B | A94 | 540.483
Steel Assembly | RIGID_FRAME | 6.1 | +57.090 | +57.160 | 13-14/A-B | A219 | 70
4 x Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 13-14/A-B | A680 | 90
Steel Assembly | RIGID_FRAME | 77.5 | +57.118 | +57.400 | 13-14/A-B | A389 | 152.4
Steel Assembly | RIGID_FRAME | 77.5 | +57.118 | +57.400 | 13-14/B-C | A385 | 152.4
Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 13-14/B-C | A681 | 90
4 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 14/B-C | -38AN154 | 90
Steel Assembly | RIGID_FRAME | 25.1 | +57.130 | +57.270 | 14/B-C | A651 | 73
4 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 14/B-C | A678 | 90
Steel Assembly | RIGID_FRAME | 18.3 | +57.130 | +57.270 | 14-15/B-C | A654 | 73
8 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 13-14/B-C | -38AN131 | 90
2 x Steel Assembly | RIGID_FRAME | 18.3 | +57.130 | +57.270 | 13-14/B-C | A653 | 73
Steel Assembly | RIGID_FRAME | 77.5 | +57.118 | +57.400 | 13-14/B-C | A387 | 152.4
4 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 13-14/B-C | -38AN154 | 90
Steel Assembly | RIGID_FRAME | 25.1 | +57.130 | +57.270 | 13-14/B-C | A651 | 73
Steel Assembly | RIGID_FRAME | 77.5 | +57.118 | +57.400 | 13-14/C-D | A387 | 152.4
4 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 14/C-D | -38AN154 | 90
Steel Assembly | RIGID_FRAME | 25.1 | +57.130 | +57.270 | 14/C-D | A651 | 73
4 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 14/C-D | -38AN131 | 90
Steel Assembly | RIGID_FRAME | 18.3 | +57.130 | +57.270 | 14-15/C-D | A654 | 73
4 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 13-14/C-D | -38AN131 | 90
2 x Steel Assembly | RIGID_FRAME | 18.3 | +57.130 | +57.270 | 13-14/C-D | A653 | 73
Steel Assembly | RIGID_FRAME | 77.5 | +57.118 | +57.400 | 13-14/C-D | A385 | 152.4
4 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 13-14/C-D | -38AN154 | 90
Steel Assembly | RIGID_FRAME | 25.1 | +57.130 | +57.270 | 13-14/C-D | A651 | 73
4 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 13-14/C-D | A678 | 90
Steel Assembly | RIGID_FRAME | 4.6 | +57.090 | +57.160 | 15/D-E | A210 | 70
Steel Assembly | RIGID_FRAME | 25 | +57.130 | +57.270 | 14-15/D-E | A97 | 532.086
Steel Assembly | RIGID_FRAME | 6.3 | +57.090 | +57.160 | 14-15/D-E | A216 | 70
Steel Assembly | RIGID_FRAME | 25 | +57.130 | +57.270 | 13-14/D-E | A96 | 532.086
4 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 14/D-E | A678 | 90
8 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 13-14/D-E | -38AN131 | 90
Steel Assembly | RIGID_FRAME | 25 | +57.130 | +57.270 | 13-14/D-E | A95 | 532.086
Steel Assembly | RIGID_FRAME | 4.6 | +57.090 | +57.160 | 13-14/D-E | A210 | 70
Steel Assembly | RIGID_FRAME | 6.3 | +57.090 | +57.160 | 13-14/D-E | A216 | 70
Steel Assembly | RIGID_FRAME | 23.3 | +57.130 | +57.270 | 13-14/D-E | A93 | 540.483
4 x Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 13-14/D-E | A680 | 90
Steel Assembly | RIGID_FRAME | 77.5 | +57.118 | +57.400 | 13-14/D-E | A383 | 152.4
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 14/A-B | -38AN154 | 90
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 13-14/D-E | -38AN154 | 90
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 14/D-E | -38AN154 | 90
Steel Assembly | RIGID_FRAME | 106.8 | +57.067 | +57.400 | 15-17/B-C | A178 | 166.7
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 15/A-B | -38AN131 | 90
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 15/B-C | -38AN131 | 90
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 15/C-D | -38AN131 | 90
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 15/D-E | -38AN131 | 90
Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 15/A-B | A681 | 90
Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 15/A-B | A680 | 90
Steel Assembly | RIGID_FRAME | 80.5 | +57.118 | +57.400 | 13-15/A-B | A390 | 152.4
Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 15/B-C | A681 | 90
3 x Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 15/B-C | A680 | 90
Steel Assembly | RIGID_FRAME | 80.5 | +57.118 | +57.400 | 13-15/B-C | A388 | 152.4
Steel Assembly | RIGID_FRAME | 80.5 | +57.118 | +57.400 | 13-15/B-C | A386 | 152.4
Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 15/C-D | A681 | 90
3 x Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 15/C-D | A680 | 90
Steel Assembly | RIGID_FRAME | 80.5 | +57.118 | +57.400 | 13-15/C-D | A388 | 152.4
Steel Assembly | RIGID_FRAME | 80.5 | +57.118 | +57.400 | 13-15/C-D | A386 | 152.4
Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 15/D-E | A681 | 90
Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 15/D-E | A680 | 90
Steel Assembly | RIGID_FRAME | 80.5 | +57.118 | +57.400 | 13-15/D-E | A384 | 152.4
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 13/D-E | -38AN131 | 90
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 13/C-D | -38AN131 | 90
Steel Assembly | RIGID_FRAME | 16.7 | +57.130 | +57.270 | 13-14/C-D | A652 | 73
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 13/B-C | -38AN131 | 90
Steel Assembly | RIGID_FRAME | 16.7 | +57.130 | +57.270 | 13-14/B-C | A652 | 73
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.165 | +57.235 | 13/A-B | -38AN131 | 90
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 13/A-B | A680 | 90
4 x Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 13/B-C | A680 | 90
4 x Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 13/C-D | A680 | 90
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.135 | +57.250 | 13/D-E | A680 | 90
Steel Assembly |  | 0 | +55.035 | +56.235 | 19/A-E | A650 | 400
Steel Assembly | RIGID_FRAME | 9.1 | +56.835 | +57.835 | 19-20/D-E | A550 | 641
Steel Assembly | RIGID_FRAME | 9.1 | +56.835 | +57.835 | 19-20/C-D | A549 | 641
Steel Assembly | RIGID_FRAME | 9.1 | +56.835 | +57.835 | 19-20/C-D | A550 | 641
Steel Assembly | RIGID_FRAME | 9.1 | +56.835 | +57.835 | 19-20/B-C | A549 | 641
Steel Assembly | RIGID_FRAME | 9.1 | +56.835 | +57.835 | 19-20/B-C | A550 | 641
Steel Assembly | RIGID_FRAME | 6.3 | +57.320 | +58.274 | 16/A-B | A553 | 337.001
Steel Assembly | RIGID_FRAME | 6.3 | +57.320 | +58.274 | 15/A-B | A552 | 337.001
Steel Assembly | RIGID_FRAME | 9.1 | +56.835 | +57.835 | 19-20/A-B | A549 | 641
Steel Assembly | RIGID_FRAME | 4.2 | +58.349 | +58.399 | 15/A-C | A684 | 50
Steel Assembly | RIGID_FRAME | 4.2 | +58.324 | +58.374 | 13-14/A-C | A683 | 50
Steel Assembly | RIGID_FRAME | 4.2 | +58.278 | +58.328 | 13-14/A-C | A683 | 50
Steel Assembly |  | 0 | +58.253 | +58.287 | 13/D-E | A564 | 34
Steel Assembly |  | 0 | +57.753 | +57.787 | 13/D-E | A564 | 34
Steel Assembly |  | 0 | +58.253 | +58.287 | 13/A-B | A564 | 34
Steel Assembly |  | 0 | +57.753 | +57.787 | 13/A-B | A564 | 34
Steel Assembly | RIGID_FRAME | 9.3 | +56.817 | +56.967 | 13/A-B | A771 | 200
2 x Bush |  | 0 | +58.341 | +58.381 | 18-19/A-B | A672 | 40.0001
2 x Bush |  | 0 | +58.341 | +58.381 | 18-19/A-B | A671 | 39.1489
2 x Pin |  | 0 | +58.351 | +58.371 | 18-19/A-B | A673 | 20
2 x Wheel |  | 0 | +58.324 | +58.399 | 18-19/A-B | A668 | 75
2 x Bush |  | 0 | +58.094 | +58.134 | 18-19/A-B | A672 | 40.0001
2 x Bush |  | 0 | +58.094 | +58.134 | 18-19/A-B | A671 | 39.1489
2 x Pin |  | 0 | +58.104 | +58.124 | 18-19/A-B | A673 | 20
2 x Wheel |  | 0 | +58.077 | +58.152 | 18-19/A-B | A668 | 75
2 x Bush |  | 0 | +58.341 | +58.381 | 17-18/A-B | A672 | 40.0001
2 x Bush |  | 0 | +58.341 | +58.381 | 17-18/A-B | A671 | 39.1489
2 x Pin |  | 0 | +58.351 | +58.371 | 17-18/A-B | A673 | 20
2 x Wheel |  | 0 | +58.324 | +58.399 | 17-18/A-B | A668 | 75
2 x Bush |  | 0 | +58.094 | +58.134 | 17-18/A-B | A672 | 40.0001
2 x Bush |  | 0 | +58.094 | +58.134 | 17-18/A-B | A671 | 39.1489
2 x Pin |  | 0 | +58.104 | +58.124 | 17-18/A-B | A673 | 20
2 x Wheel |  | 0 | +58.077 | +58.152 | 17-18/A-B | A668 | 75
Bush |  | 0 | +58.094 | +58.134 | 16-17/A-B | A672 | 40.0001
Bush |  | 0 | +58.094 | +58.134 | 16-17/A-B | A671 | 39.1489
Pin |  | 0 | +58.104 | +58.124 | 16-17/A-B | A673 | 20
Wheel |  | 0 | +58.077 | +58.152 | 16-17/A-B | A668 | 75
2 x Bush |  | 0 | +58.094 | +58.134 | 16-17/B-C | A672 | 40.0001
Bush |  | 0 | +58.094 | +58.134 | 16-17/B-C | A671 | 39.1489
2 x Pin |  | 0 | +58.104 | +58.124 | 16-17/B-C | A673 | 20
Wheel |  | 0 | +58.077 | +58.152 | 16-17/B-C | A668 | 75
4 x Bush |  | 0 | +58.094 | +58.134 | 17-18/B-C | A672 | 40.0001
2 x Bush |  | 0 | +58.094 | +58.134 | 17-18/B-C | A671 | 39.1489
4 x Pin |  | 0 | +58.104 | +58.124 | 17-18/B-C | A673 | 20
2 x Wheel |  | 0 | +58.077 | +58.152 | 17-18/B-C | A668 | 75
4 x Bush |  | 0 | +58.341 | +58.381 | 17-18/B-C | A672 | 40.0001
2 x Bush |  | 0 | +58.341 | +58.381 | 17-18/B-C | A671 | 39.1489
4 x Pin |  | 0 | +58.351 | +58.371 | 17-18/B-C | A673 | 20
2 x Wheel |  | 0 | +58.324 | +58.399 | 17-18/B-C | A668 | 75
4 x Bush |  | 0 | +58.094 | +58.134 | 18-19/B-C | A672 | 40.0001
2 x Bush |  | 0 | +58.094 | +58.134 | 18-19/B-C | A671 | 39.1489
4 x Pin |  | 0 | +58.104 | +58.124 | 18-19/B-C | A673 | 20
2 x Wheel |  | 0 | +58.077 | +58.152 | 18-19/B-C | A668 | 75
4 x Bush |  | 0 | +58.341 | +58.381 | 18-19/B-C | A672 | 40.0001
2 x Bush |  | 0 | +58.341 | +58.381 | 18-19/B-C | A671 | 39.1489
4 x Pin |  | 0 | +58.351 | +58.371 | 18-19/B-C | A673 | 20
2 x Wheel |  | 0 | +58.324 | +58.399 | 18-19/B-C | A668 | 75
2 x Bush |  | 0 | +58.094 | +58.134 | 16-17/C-D | A672 | 40.0001
Bush |  | 0 | +58.094 | +58.134 | 16-17/C-D | A671 | 39.1489
2 x Pin |  | 0 | +58.104 | +58.124 | 16-17/C-D | A673 | 20
Wheel |  | 0 | +58.077 | +58.152 | 16-17/C-D | A668 | 75
4 x Bush |  | 0 | +58.094 | +58.134 | 17-18/C-D | A672 | 40.0001
2 x Bush |  | 0 | +58.094 | +58.134 | 17-18/C-D | A671 | 39.1489
4 x Pin |  | 0 | +58.104 | +58.124 | 17-18/C-D | A673 | 20
2 x Wheel |  | 0 | +58.077 | +58.152 | 17-18/C-D | A668 | 75
4 x Bush |  | 0 | +58.341 | +58.381 | 17-18/C-D | A672 | 40.0001
2 x Bush |  | 0 | +58.341 | +58.381 | 17-18/C-D | A671 | 39.1489
4 x Pin |  | 0 | +58.351 | +58.371 | 17-18/C-D | A673 | 20
2 x Wheel |  | 0 | +58.324 | +58.399 | 17-18/C-D | A668 | 75
4 x Bush |  | 0 | +58.094 | +58.134 | 18-19/C-D | A672 | 40.0001
2 x Bush |  | 0 | +58.094 | +58.134 | 18-19/C-D | A671 | 39.1489
4 x Pin |  | 0 | +58.104 | +58.124 | 18-19/C-D | A673 | 20
2 x Wheel |  | 0 | +58.077 | +58.152 | 18-19/C-D | A668 | 75
4 x Bush |  | 0 | +58.341 | +58.381 | 18-19/C-D | A672 | 40.0001
2 x Bush |  | 0 | +58.341 | +58.381 | 18-19/C-D | A671 | 39.1489
4 x Pin |  | 0 | +58.351 | +58.371 | 18-19/C-D | A673 | 20
2 x Wheel |  | 0 | +58.324 | +58.399 | 18-19/C-D | A668 | 75
Bush |  | 0 | +58.094 | +58.134 | 16-17/B-C | A670 | 40.0001
2 x Washer |  | 0 | +58.094 | +58.134 | 16-17/B-C | A669 | 40
Wheel |  | 0 | +58.077 | +58.152 | 16-17/B-C | A667 | 75
2 x Bush |  | 0 | +58.094 | +58.134 | 17-18/B-C | A670 | 40.0001
4 x Washer |  | 0 | +58.094 | +58.134 | 17-18/B-C | A669 | 40
2 x Wheel |  | 0 | +58.077 | +58.152 | 17-18/B-C | A667 | 75
2 x Bush |  | 0 | +58.341 | +58.381 | 17-18/B-C | A670 | 40.0001
4 x Washer |  | 0 | +58.341 | +58.381 | 17-18/B-C | A669 | 40
2 x Wheel |  | 0 | +58.324 | +58.399 | 17-18/B-C | A666 | 75
2 x Bush |  | 0 | +58.094 | +58.134 | 18-19/B-C | A670 | 40.0001
4 x Washer |  | 0 | +58.094 | +58.134 | 18-19/B-C | A669 | 40
2 x Wheel |  | 0 | +58.077 | +58.152 | 18-19/B-C | A667 | 75
2 x Bush |  | 0 | +58.341 | +58.381 | 18-19/B-C | A670 | 40.0001
4 x Washer |  | 0 | +58.341 | +58.381 | 18-19/B-C | A669 | 40
2 x Wheel |  | 0 | +58.324 | +58.399 | 18-19/B-C | A666 | 75
Bush |  | 0 | +58.094 | +58.134 | 16-17/C-D | A670 | 40.0001
2 x Washer |  | 0 | +58.094 | +58.134 | 16-17/C-D | A669 | 40
Wheel |  | 0 | +58.077 | +58.152 | 16-17/C-D | A667 | 75
2 x Bush |  | 0 | +58.094 | +58.134 | 17-18/C-D | A670 | 40.0001
4 x Washer |  | 0 | +58.094 | +58.134 | 17-18/C-D | A669 | 40
2 x Wheel |  | 0 | +58.077 | +58.152 | 17-18/C-D | A667 | 75
2 x Bush |  | 0 | +58.341 | +58.381 | 17-18/C-D | A670 | 40.0001
4 x Washer |  | 0 | +58.341 | +58.381 | 17-18/C-D | A669 | 40
2 x Wheel |  | 0 | +58.324 | +58.399 | 17-18/C-D | A665 | 75
2 x Bush |  | 0 | +58.094 | +58.134 | 18-19/C-D | A670 | 40.0001
4 x Washer |  | 0 | +58.094 | +58.134 | 18-19/C-D | A669 | 40
2 x Wheel |  | 0 | +58.077 | +58.152 | 18-19/C-D | A667 | 75
2 x Bush |  | 0 | +58.341 | +58.381 | 18-19/C-D | A670 | 40.0001
4 x Washer |  | 0 | +58.341 | +58.381 | 18-19/C-D | A669 | 40
2 x Wheel |  | 0 | +58.324 | +58.399 | 18-19/C-D | A665 | 75
Bush |  | 0 | +58.094 | +58.134 | 16-17/D-E | A670 | 40.0001
Bush |  | 0 | +58.094 | +58.134 | 16-17/D-E | A672 | 40.0001
2 x Washer |  | 0 | +58.094 | +58.134 | 16-17/D-E | A669 | 40
Pin |  | 0 | +58.104 | +58.124 | 16-17/D-E | A673 | 20
Wheel |  | 0 | +58.077 | +58.152 | 16-17/D-E | A667 | 75
2 x Bush |  | 0 | +58.094 | +58.134 | 17-18/D-E | A670 | 40.0001
2 x Bush |  | 0 | +58.094 | +58.134 | 17-18/D-E | A672 | 40.0001
4 x Washer |  | 0 | +58.094 | +58.134 | 17-18/D-E | A669 | 40
2 x Pin |  | 0 | +58.104 | +58.124 | 17-18/D-E | A673 | 20
2 x Wheel |  | 0 | +58.077 | +58.152 | 17-18/D-E | A667 | 75
2 x Bush |  | 0 | +58.341 | +58.381 | 17-18/D-E | A670 | 40.0001
2 x Bush |  | 0 | +58.341 | +58.381 | 17-18/D-E | A672 | 40.0001
4 x Washer |  | 0 | +58.341 | +58.381 | 17-18/D-E | A669 | 40
2 x Pin |  | 0 | +58.351 | +58.371 | 17-18/D-E | A673 | 20
2 x Wheel |  | 0 | +58.324 | +58.399 | 17-18/D-E | A665 | 75
2 x Bush |  | 0 | +58.094 | +58.134 | 18-19/D-E | A670 | 40.0001
2 x Bush |  | 0 | +58.094 | +58.134 | 18-19/D-E | A672 | 40.0001
4 x Washer |  | 0 | +58.094 | +58.134 | 18-19/D-E | A669 | 40
2 x Pin |  | 0 | +58.104 | +58.124 | 18-19/D-E | A673 | 20
2 x Wheel |  | 0 | +58.077 | +58.152 | 18-19/D-E | A667 | 75
2 x Bush |  | 0 | +58.341 | +58.381 | 18-19/D-E | A670 | 40.0001
2 x Bush |  | 0 | +58.341 | +58.381 | 18-19/D-E | A672 | 40.0001
4 x Washer |  | 0 | +58.341 | +58.381 | 18-19/D-E | A669 | 40
2 x Pin |  | 0 | +58.351 | +58.371 | 18-19/D-E | A673 | 20
2 x Wheel |  | 0 | +58.324 | +58.399 | 18-19/D-E | A665 | 75
Bush |  | 0 | +58.341 | +58.381 | 19/A-B | A672 | 40.0001
Bush |  | 0 | +58.341 | +58.381 | 19/A-B | A671 | 39.1489
Pin |  | 0 | +58.351 | +58.371 | 19/A-B | A673 | 20
Wheel |  | 0 | +58.324 | +58.399 | 19/A-B | A668 | 75
Bush |  | 0 | +58.341 | +58.381 | 19/B-C | A670 | 40.0001
2 x Bush |  | 0 | +58.341 | +58.381 | 19/B-C | A672 | 40.0001
2 x Washer |  | 0 | +58.341 | +58.381 | 19/B-C | A669 | 40
2 x Pin |  | 0 | +58.351 | +58.371 | 19/B-C | A673 | 20
Wheel |  | 0 | +58.324 | +58.399 | 19/B-C | A666 | 75
Bush |  | 0 | +58.341 | +58.381 | 19/B-C | A671 | 39.1489
Wheel |  | 0 | +58.324 | +58.399 | 19/B-C | A668 | 75
Bush |  | 0 | +58.341 | +58.381 | 19/C-D | A670 | 40.0001
2 x Bush |  | 0 | +58.341 | +58.381 | 19/C-D | A672 | 40.0001
2 x Washer |  | 0 | +58.341 | +58.381 | 19/C-D | A669 | 40
2 x Pin |  | 0 | +58.351 | +58.371 | 19/C-D | A673 | 20
Wheel |  | 0 | +58.324 | +58.399 | 19/C-D | A665 | 75
Bush |  | 0 | +58.341 | +58.381 | 19/C-D | A671 | 39.1489
Wheel |  | 0 | +58.324 | +58.399 | 19/C-D | A668 | 75
Bush |  | 0 | +58.341 | +58.381 | 19/D-E | A670 | 40.0001
Bush |  | 0 | +58.341 | +58.381 | 19/D-E | A672 | 40.0001
2 x Washer |  | 0 | +58.341 | +58.381 | 19/D-E | A669 | 40
Pin |  | 0 | +58.351 | +58.371 | 19/D-E | A673 | 20
Wheel |  | 0 | +58.324 | +58.399 | 19/D-E | A665 | 75
Steel Assembly | RIGID_FRAME | 3547.9 | +57.460 | +58.114 | 15-16/C-E | A437 | 654
Steel Assembly |  | 0 | +56.729 | +57.553 | 19-20/B-D | A440 | 824
Mesh |  | 0 | +57.270 | +57.276 | 14-15/B-C | A769 | 6
Mesh |  | 0 | +57.270 | +57.276 | 13-14/B-C | A764 | 6
Mesh |  | 0 | +57.270 | +57.276 | 13-14/C-D | A763 | 6
Mesh |  | 0 | +57.270 | +57.276 | 13-14/B-C | A760 | 6
Mesh |  | 0 | +57.270 | +57.276 | 13-14/C-D | A760 | 6
Steel Assembly |  | 0 | +55.215 | +55.735 | 19-20/C-E | A658 | 520
Steel Assembly |  | 0 | +55.215 | +55.735 | 19-20/B-D | A658 | 520
Steel Assembly |  | 0 | +57.109 | +57.933 | 19/C-E | A440 | 824
Steel Assembly |  | 0 | +57.109 | +57.933 | 19/B-D | A440 | 824
Steel Assembly |  | 0 | +57.109 | +57.933 | 19/A-C | A440 | 824
Steel Assembly | RIGID_FRAME | 117.8 | +56.735 | +56.785 | 20-21/D-E | A825 | 50
2 x Steel Assembly | RIGID_FRAME | 117.8 | +56.735 | +56.785 | 20-21/C-D | A825 | 50
2 x Steel Assembly | RIGID_FRAME | 117.8 | +56.735 | +56.785 | 20-21/B-C | A825 | 50
Steel Assembly | RIGID_FRAME | 117.8 | +56.735 | +56.785 | 20-21/A-B | A825 | 50
Steel Assembly | RIGID_FRAME | 112.3 | +56.735 | +56.785 | 17-20/D-E | A824 | 50
2 x Steel Assembly | RIGID_FRAME | 112.3 | +56.735 | +56.785 | 17-20/C-D | A824 | 50
2 x Steel Assembly | RIGID_FRAME | 112.3 | +56.735 | +56.785 | 17-20/B-C | A824 | 50
Steel Assembly | RIGID_FRAME | 112.3 | +56.735 | +56.785 | 17-20/A-B | A824 | 50
Steel Assembly |  | 0 | +56.729 | +57.553 | 19-20/C-E | A440 | 824
Steel Assembly |  | 0 | +56.729 | +57.553 | 19-20/A-C | A440 | 824
Steel Assembly | RIGID_FRAME | 3547.9 | +57.460 | +58.114 | 15-16/B-D | A437 | 654
Steel Assembly | RIGID_FRAME | 3547.9 | +57.460 | +58.114 | 15-16/A-C | A437 | 654
Mesh |  | 0 | +57.270 | +57.276 | 13-15/D-E | A759 | 6
Mesh |  | 0 | +57.270 | +57.276 | 13-14/D-E | A768 | 6
Mesh |  | 0 | +57.270 | +57.276 | 16-18/C-D | A757 | 6
Mesh |  | 0 | +57.270 | +57.276 | 15-17/C-D | A762 | 6
Mesh |  | 0 | +57.270 | +57.276 | 16-18/D-E | A756 | 6
Mesh |  | 0 | +57.270 | +57.276 | 15-17/D-E | A767 | 6
Mesh |  | 0 | +57.270 | +57.276 | 16-18/B-C | A757 | 6
Mesh |  | 0 | +57.270 | +57.276 | 15-17/B-C | A762 | 6
Mesh |  | 0 | +57.270 | +57.276 | 13-14/B-C | A761 | 6
Mesh |  | 0 | +57.270 | +57.276 | 16-18/A-B | A755 | 6
Mesh |  | 0 | +57.270 | +57.276 | 15-17/A-B | A766 | 6
Mesh |  | 0 | +57.270 | +57.276 | 13-15/A-B | A758 | 6
Mesh |  | 0 | +57.270 | +57.276 | 13-14/A-B | A765 | 6
Steel Assembly |  | 0 | +58.253 | +58.287 | 13-18/D-E | A563 | 34
Steel Assembly |  | 0 | +57.753 | +57.787 | 13-18/D-E | A563 | 34
Steel Assembly |  | 0 | +58.253 | +58.287 | 13-18/A-B | A563 | 34
Steel Assembly |  | 0 | +57.753 | +57.787 | 13-18/A-B | A563 | 34
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.170 | +57.270 | 15/A-B | A807 | 8
6 x Steel Assembly | RIGID_FRAME | 1.3 | +57.170 | +57.270 | 13-14/A-B | A807 | 8
2 x Steel Assembly | RIGID_FRAME | 1.3 | +57.170 | +57.270 | 15/D-E | A807 | 8
6 x Steel Assembly | RIGID_FRAME | 1.3 | +57.170 | +57.270 | 13-14/D-E | A807 | 8
Steel Assembly | RIGID_FRAME | 6.1 | +56.429 | +56.598 | 11-12/D-E | A625 | 67.3641
Steel Assembly | RIGID_FRAME | 6.1 | +56.941 | +57.072 | 12-13/A-B | A623 | 67.7901
Steel Assembly | RIGID_FRAME | 16.3 | +56.941 | +57.071 | 12-13/B-C | A643 | 67.4762
Steel Assembly | RIGID_FRAME | 16.3 | +56.941 | +57.071 | 12-13/C-D | A643 | 67.4762
Steel Assembly | RIGID_FRAME | 6.1 | +56.941 | +57.072 | 12-13/D-E | A623 | 67.7901
Steel Assembly |  | 0 | +56.848 | +57.262 | 11-12/A-B | A599 | 34.0009
Steel Assembly | RIGID_FRAME | 6.1 | +56.716 | +56.862 | 12-13/D-E | A622 | 69.1966
Steel Assembly | RIGID_FRAME | 6.1 | +57.114 | +57.227 | 12-13/D-E | A621 | 66.6505
Steel Assembly | RIGID_FRAME | 6.1 | +57.033 | +57.156 | 12-13/D-E | A615 | 67.3061
Steel Assembly | RIGID_FRAME | 6.1 | +56.833 | +56.974 | 12-13/D-E | A618 | 68.3836
Steel Assembly | RIGID_FRAME | 6.1 | +57.180 | +57.276 | 12-13/D-E | A614 | 66.0207
Steel Assembly | RIGID_FRAME | 6.1 | +56.429 | +56.598 | 11-12/A-B | A617 | 67.2547
Steel Assembly | RIGID_FRAME | 6.1 | +56.716 | +56.862 | 12-13/A-B | A622 | 68.6045
Steel Assembly | RIGID_FRAME | 6.1 | +56.833 | +56.974 | 12-13/A-B | A616 | 68.4012
Steel Assembly | RIGID_FRAME | 6.1 | +57.115 | +57.227 | 12-13/A-B | A621 | 66.0876
Steel Assembly | RIGID_FRAME | 16.3 | +56.833 | +56.973 | 12-13/B-C | A639 | 68.0032
Steel Assembly | RIGID_FRAME | 16.3 | +56.429 | +56.598 | 11-12/B-C | A637 | 68.8704
Steel Assembly | RIGID_FRAME | 16.3 | +56.429 | +56.598 | 11-12/C-D | A637 | 68.8704
Steel Assembly | RIGID_FRAME | 16.3 | +56.833 | +56.973 | 12-13/C-D | A639 | 68.0031
Steel Assembly | RIGID_FRAME | 73.8 | +52.307 | +52.521 | 6-7/B-D | A791 | 1996.27
Steel Assembly | RIGID_FRAME | 17.3 | +50.436 | +51.236 | 1-2/C-D | A46 | 210
Steel Assembly | RIGID_FRAME | 17.3 | +50.436 | +51.236 | 1-2/D-E | A45 | 210
Steel Assembly | RIGID_FRAME | 30.5 | +50.462 | +50.672 | 1-2/C-E | A35 | 200
Steel Assembly | RIGID_FRAME | 30.3 | +51.541 | +51.672 | 1-2/C-E | A47 | 120
Steel Assembly | RIGID_FRAME | 17.3 | +50.436 | +51.236 | 1-2/A-B | A46 | 210
Steel Assembly | RIGID_FRAME | 17.3 | +50.436 | +51.236 | 1-2/B-C | A45 | 210
Steel Assembly | RIGID_FRAME | 30.5 | +50.462 | +50.672 | 1-2/A-C | A35 | 200
Steel Assembly | RIGID_FRAME | 30.3 | +51.541 | +51.672 | 1-2/A-C | A47 | 120
Steel Assembly | RIGID_FRAME | 30.3 | +51.541 | +51.672 | 1-2/B-D | A47 | 120
Steel Assembly | RIGID_FRAME | 17.3 | +50.436 | +51.236 | 1-2/B-C | A46 | 210
Steel Assembly | RIGID_FRAME | 30.5 | +50.462 | +50.672 | 1-2/B-D | A35 | 200
Steel Assembly | RIGID_FRAME | 17.3 | +50.436 | +51.236 | 1-2/C-D | A45 | 210
Steel Assembly | RIGID_FRAME | 30 | +52.073 | +52.153 | 1-2/D-E | A827 | 80.0016
2 x Steel Assembly | RIGID_FRAME | 30 | +52.073 | +52.153 | 1-2/C-D | A827 | 80.0016
2 x Steel Assembly | RIGID_FRAME | 30 | +52.073 | +52.153 | 1-2/B-C | A827 | 80.0016
Steel Assembly | RIGID_FRAME | 9.1 | +50.577 | +51.167 | 1/D-E | A750 | 62.0053
Steel Assembly | RIGID_FRAME | 9.1 | +50.577 | +51.167 | 1/C-D | A750 | 62.0053
Steel Assembly | RIGID_FRAME | 18.3 | +50.242 | +52.302 | 15/A | A152 | 160.001
Steel Assembly |  | 0 | +57.725 | +57.759 | 12-14/A-B | A154 | 34
Steel Assembly |  | 0 | +57.225 | +57.259 | 12-14/A-B | A153 | 34
Steel Assembly | RIGID_FRAME | 132.2 | +53.727 | +57.957 | 13-14/A-B | A555 | 900.002
Steel Assembly | RIGID_FRAME | 8.6 | +51.115 | +52.327 | 13-14/A-B | A469 | 600.025
Steel Assembly | RIGID_FRAME | 11.9 | +50.322 | +52.327 | 13-14/A-B | A490 | 610.001
Steel Assembly | RIGID_FRAME | 12.6 | +50.322 | +52.327 | 13-14/A-B | A484 | 750.001
Steel Assembly | RIGID_FRAME | 8.6 | +51.115 | +52.327 | 13-14/A-B | A470 | 599.99
Steel Assembly | RIGID_FRAME | 11.9 | +50.322 | +52.327 | 13-14/A-B | A488 | 599.99
Steel Assembly | RIGID_FRAME | 11.9 | +50.322 | +52.327 | 14/A-B | A488 | 599.99
Steel Assembly | RIGID_FRAME | 5.7 | +50.322 | +51.115 | 13-14/A-B | A472 | 599.976
Steel Assembly | RIGID_FRAME | 5.7 | +50.322 | +51.115 | 13-14/A-B | A471 | 600.025
Steel Assembly | RIGID_FRAME | 6.1 | +50.322 | +51.115 | 12-13/A-B | A467 | 750.001
Steel Assembly | RIGID_FRAME | 12.5 | +50.322 | +52.327 | 15/A-B | A486 | 750.115
2 x Steel Assembly | RIGID_FRAME | 12.6 | +50.322 | +52.327 | 15/A-B | A484 | 750.24
Steel Assembly | RIGID_FRAME | 12.6 | +50.322 | +52.327 | 15/A-B | A484 | 750.236
Steel Assembly | RIGID_FRAME | 12.6 | +50.322 | +52.327 | 12-13/A-B | A484 | 750.236
2 x Steel Assembly | RIGID_FRAME | 12.6 | +50.322 | +52.327 | 12-13/A-B | A484 | 750.24
Steel Assembly | RIGID_FRAME | 12.5 | +50.322 | +52.327 | 12-13/A-B | A486 | 750.115
Steel Assembly | RIGID_FRAME | 11.7 | +50.322 | +52.327 | 15/A-B | A489 | 599.976
Steel Assembly | RIGID_FRAME | 11.9 | +50.322 | +52.327 | 13-14/A-B | A488 | 600.025
Steel Assembly | RIGID_FRAME | 12.6 | +50.322 | +52.327 | 13/A-B | A484 | 750.001
Steel Assembly | RIGID_FRAME | 9.1 | +51.115 | +52.327 | 12-13/A-B | A468 | 750.001
Steel Assembly | RIGID_FRAME | 540.5 | +50.234 | +56.742 | 13/A-B | A157 | 1750
2 x Steel Assembly | RIGID_FRAME | 540.5 | +50.234 | +56.742 | 13-14/A-B | A157 | 1750
2 x Steel Assembly | RIGID_FRAME | 15.4 | +56.604 | +56.894 | 13-14/A-B | A159 | 170
2 x Steel Assembly | RIGID_FRAME | 15.4 | +56.604 | +56.894 | 13-14/A-B | A158 | 175
Steel Assembly | RIGID_FRAME | 15.4 | +56.604 | +56.894 | 12-13/A-B | A159 | 170
Steel Assembly | RIGID_FRAME | 15.4 | +56.604 | +56.894 | 12-13/A-B | A158 | 175
Steel Assembly | RIGID_FRAME | 361.1 | +50.242 | +56.742 | 12-13/A-B | A147 | 1750
2 x Steel Assembly | RIGID_FRAME | 361.1 | +50.242 | +56.742 | 13-14/A-B | A146 | 1750
Steel Assembly | RIGID_FRAME | 138.1 | +50.242 | +54.912 | 15/A-B | A554 | 898.938
Steel Assembly | RIGID_FRAME | 241.2 | +51.062 | +52.702 | 13/A-B | A311 | 1640
Steel Assembly | RIGID_FRAME | 246.9 | +50.387 | +52.227 | 12-13/A-B | A466 | 1840
2 x Steel Assembly | RIGID_FRAME | 158.3 | +50.242 | +56.732 | 12-13/A-B | A160 | 300
Steel Assembly | RIGID_FRAME | 274.5 | +51.062 | +52.702 | 13-14/A-B | A309 | 1640
2 x Steel Assembly | RIGID_FRAME | 246.9 | +50.387 | +52.227 | 13-14/A-B | A466 | 1840
4 x Steel Assembly | RIGID_FRAME | 158.3 | +50.242 | +56.732 | 13-14/A-B | A160 | 300
Steel Assembly | RIGID_FRAME | 285.2 | +51.062 | +52.702 | 13-14/A-B | A310 | 1640
Steel Assembly | RIGID_FRAME | 176.7 | +53.537 | +53.697 | 14/A-B | A374 | 2250
Steel Assembly | RIGID_FRAME | 54.6 | +52.702 | +53.192 | 12-13/A-B | A714 | 489.995
2 x Steel Assembly | RIGID_FRAME | 54.6 | +52.702 | +53.192 | 13-14/A-B | A714 | 489.995
7 x Steel Assembly |  | 0 | +56.632 | +57.772 | 13-14/A-B | A156 | 160
2 x Steel Assembly |  | 0 | +56.632 | +57.772 | 14/A-B | A156 | 160
4 x Steel Assembly |  | 0 | +56.632 | +57.772 | 12-13/A-B | A156 | 160
2 x Steel Assembly |  | 0 | +56.632 | +57.772 | 13/A-B | A156 | 160
Steel Assembly |  | 0 | +54.680 | +54.714 | 12-14/A | A155 | 34.003
Steel Assembly |  | 0 | +54.180 | +54.214 | 12-14/A | A155 | 34.0069
Steel Assembly |  | 0 | +53.587 | +54.727 | 12-13/A-B | A156 | 160
Steel Assembly |  | 0 | +53.587 | +54.727 | 14/A-B | A156 | 160
Steel Assembly |  | 0 | +53.587 | +54.727 | 14/A | A156 | 160
3 x Steel Assembly |  | 0 | +53.587 | +54.727 | 13-14/A | A156 | 160
Steel Assembly |  | 0 | +53.587 | +54.727 | 13/A | A156 | 160
Steel Assembly |  | 0 | +53.587 | +54.727 | 12-13/A | A156 | 160
Steel Assembly | RIGID_FRAME | 54.2 | +52.242 | +52.322 | 12-15/A-B | A291 | 164.999
Steel Assembly | RIGID_FRAME | 27.1 | +52.242 | +52.322 | 12-13/A-B | A289 | 165.024
Steel Assembly | RIGID_FRAME | 27.1 | +52.242 | +52.322 | 15/A-B | A289 | 80
Steel Assembly | RIGID_FRAME | 18.3 | +50.242 | +52.302 | 12-13/A | A151 | 200
Steel Assembly | RIGID_FRAME | 19.1 | +50.242 | +52.302 | 15/A-B | A149 | 260.001
2 x Steel Assembly | RIGID_FRAME | 18.3 | +50.242 | +52.302 | 13-14/A-B | A150 | 155.001
Steel Assembly | RIGID_FRAME | 19.9 | +50.242 | +52.302 | 12-13/A-B | A148 | 160.001
Steel Assembly | RIGID_FRAME | 52.7 | +50.622 | +50.702 | 12-15/A-B | A290 | 80
Steel Assembly | RIGID_FRAME | 26.4 | +50.622 | +50.702 | 12-13/A-B | A288 | 80
Steel Assembly | RIGID_FRAME | 26.4 | +50.622 | +50.702 | 15/A-B | A288 | 80
Steel Assembly | RIGID_FRAME | 40.5 | +51.176 | +51.616 | 12-13/A-B | A784 | 32
2 x Steel Assembly | RIGID_FRAME | 40.5 | +51.176 | +51.616 | 13-14/A-B | A784 | 32
Steel Assembly | RIGID_FRAME | 20.1 | +53.746 | +53.762 | 12-13/A-B | A753 | 16
2 x Steel Assembly | RIGID_FRAME | 8.7 | +53.762 | +54.082 | 12-13/A-B | A782 | 20
Steel Assembly | RIGID_FRAME | 5.5 | +54.376 | +55.012 | 13/A-B | A200 | 70
Steel Assembly | RIGID_FRAME | 4.6 | +52.976 | +53.527 | 13/A-B | A199 | 70
Steel Assembly | RIGID_FRAME | 7.2 | +51.389 | +52.191 | 13/A-B | A287 | 80
Steel Assembly | RIGID_FRAME | 11.1 | +55.112 | +56.345 | 13/A-B | A197 | 70
Steel Assembly | RIGID_FRAME | 5.3 | +55.112 | +55.738 | 13/A-B | A194 | 70
Steel Assembly | RIGID_FRAME | 5 | +55.766 | +56.345 | 13/A-B | A205 | 70
Steel Assembly | RIGID_FRAME | 2.9 | +55.578 | +55.926 | 13/A-B | DUMMY1149 | 10
Steel Assembly | RIGID_FRAME | 11.3 | +53.759 | +55.012 | 13/A-B | A204 | 70
Steel Assembly | RIGID_FRAME | 5 | +53.759 | +54.348 | 13/A-B | A203 | 70
Steel Assembly | RIGID_FRAME | 2.9 | +54.187 | +54.537 | 13/A-B | DUMMY1149 | 10
Steel Assembly | RIGID_FRAME | 10.8 | +52.317 | +53.530 | 13/A-B | A202 | 70
Steel Assembly | RIGID_FRAME | 5.3 | +52.317 | +52.948 | 13/A-B | A194 | 70
Steel Assembly | RIGID_FRAME | 2.9 | +52.787 | +53.137 | 13/A-B | DUMMY1149 | 10
Steel Assembly | RIGID_FRAME | 14.5 | +50.617 | +52.191 | 13/A-B | A286 | 80
Steel Assembly | RIGID_FRAME | 6.3 | +50.617 | +51.335 | 13/A-B | A285 | 80
Steel Assembly | RIGID_FRAME | 3.4 | +51.162 | +51.562 | 13/A-B | DUMMY1148 | 10
Steel Assembly | RIGID_FRAME | 9.6 | +55.027 | +55.097 | 13/A-B | A193 | 70
Steel Assembly | RIGID_FRAME | 9.6 | +52.227 | +52.297 | 13/A-B | A193 | 70
Steel Assembly | RIGID_FRAME | 7.8 | +50.462 | +50.532 | 13/A-B | A192 | 70
2 x Steel Assembly | RIGID_FRAME | 9.9 | +50.272 | +50.784 | 13/A-B | DUMMY1145 | 10
Steel Assembly | RIGID_FRAME | 5.5 | +54.376 | +55.012 | 12-13/A-B | A200 | 70
Steel Assembly | RIGID_FRAME | 4.6 | +52.976 | +53.527 | 12-13/A-B | A199 | 70
Steel Assembly | RIGID_FRAME | 30.5 | +56.742 | +56.894 | 12-13/A-B | A401 | 76.2
2 x Steel Assembly | RIGID_FRAME | 35 | +56.894 | +56.926 | 12-13/A-B | A783 | 32
Steel Assembly | RIGID_FRAME | 30.5 | +56.742 | +56.894 | 12-13/A-B | A400 | 76.2
Steel Assembly | RIGID_FRAME | 7.2 | +51.389 | +52.191 | 12-13/A-B | A287 | 80
Steel Assembly | RIGID_FRAME | 82.4 | +56.442 | +56.742 | 12-13/A-B | A382 | 200.001
Steel Assembly | RIGID_FRAME | 82.4 | +56.442 | +56.742 | 12-13/A-B | A381 | 200
2 x Steel Assembly | RIGID_FRAME | 5.3 | +56.184 | +56.442 | 13/A-B | DUMMY1161 | 10
Steel Assembly | RIGID_FRAME | 11.1 | +55.112 | +56.347 | 12-13/A-B | A198 | 70
2 x Steel Assembly | RIGID_FRAME | 5.3 | +56.186 | +56.442 | 12-13/A-B | DUMMY1162 | 10
Steel Assembly | RIGID_FRAME | 5.3 | +55.112 | +55.738 | 12-13/A-B | A194 | 70
Steel Assembly | RIGID_FRAME | 5 | +55.766 | +56.347 | 12-13/A-B | A201 | 70
Steel Assembly | RIGID_FRAME | 2.9 | +55.578 | +55.926 | 12-13/A-B | DUMMY1149 | 10
Steel Assembly | RIGID_FRAME | 11.1 | +53.771 | +55.012 | 12-13/A-B | A197 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +53.771 | +54.348 | 12-13/A-B | A196 | 70
Steel Assembly | RIGID_FRAME | 2.9 | +54.187 | +54.537 | 12-13/A-B | DUMMY1149 | 10
Steel Assembly | RIGID_FRAME | 10.8 | +52.317 | +53.527 | 12-13/A-B | A195 | 70
Steel Assembly | RIGID_FRAME | 5.3 | +52.317 | +52.948 | 12-13/A-B | A194 | 70
Steel Assembly | RIGID_FRAME | 2.9 | +52.787 | +53.137 | 12-13/A-B | DUMMY1149 | 10
Steel Assembly | RIGID_FRAME | 14.5 | +50.617 | +52.191 | 12-13/A-B | A286 | 80
Steel Assembly | RIGID_FRAME | 6.3 | +50.617 | +51.335 | 12-13/A-B | A285 | 80
Steel Assembly | RIGID_FRAME | 3.4 | +51.162 | +51.562 | 12-13/A-B | DUMMY1148 | 10
Steel Assembly | RIGID_FRAME | 9.6 | +55.027 | +55.097 | 12-13/A-B | A193 | 70
Steel Assembly | RIGID_FRAME | 9.6 | +52.227 | +52.297 | 12-13/A-B | A193 | 70
Steel Assembly | RIGID_FRAME | 7.8 | +50.462 | +50.532 | 12-13/A-B | A192 | 70
2 x Steel Assembly | RIGID_FRAME | 9.9 | +50.272 | +50.784 | 12-13/A-B | DUMMY1145 | 10
2 x Steel Assembly | RIGID_FRAME | 20.1 | +53.746 | +53.762 | 13-14/A-B | A753 | 16
4 x Steel Assembly | RIGID_FRAME | 8.7 | +53.762 | +54.082 | 13-14/A-B | A782 | 20
3 x Steel Assembly | RIGID_FRAME | 5.5 | +54.376 | +55.012 | 13-14/A-B | A200 | 70
3 x Steel Assembly | RIGID_FRAME | 4.6 | +52.976 | +53.527 | 13-14/A-B | A199 | 70
3 x Steel Assembly | RIGID_FRAME | 7.2 | +51.389 | +52.191 | 13-14/A-B | A287 | 80
Steel Assembly | RIGID_FRAME | 11.1 | +55.112 | +56.345 | 13-14/A-B | A197 | 70
3 x Steel Assembly | RIGID_FRAME | 5.3 | +55.112 | +55.738 | 13-14/A-B | A194 | 70
Steel Assembly | RIGID_FRAME | 5 | +55.766 | +56.345 | 13-14/A-B | A205 | 70
3 x Steel Assembly | RIGID_FRAME | 2.9 | +55.578 | +55.926 | 13-14/A-B | DUMMY1149 | 10
Steel Assembly | RIGID_FRAME | 11.3 | +53.759 | +55.012 | 13-14/A-B | A204 | 70
Steel Assembly | RIGID_FRAME | 5 | +53.759 | +54.348 | 13-14/A-B | A203 | 70
3 x Steel Assembly | RIGID_FRAME | 2.9 | +54.187 | +54.537 | 13-14/A-B | DUMMY1149 | 10
Steel Assembly | RIGID_FRAME | 10.8 | +52.317 | +53.530 | 13-14/A-B | A202 | 70
3 x Steel Assembly | RIGID_FRAME | 5.3 | +52.317 | +52.948 | 13-14/A-B | A194 | 70
3 x Steel Assembly | RIGID_FRAME | 2.9 | +52.787 | +53.137 | 13-14/A-B | DUMMY1149 | 10
3 x Steel Assembly | RIGID_FRAME | 14.5 | +50.617 | +52.191 | 13-14/A-B | A286 | 80
3 x Steel Assembly | RIGID_FRAME | 6.3 | +50.617 | +51.335 | 13-14/A-B | A285 | 80
3 x Steel Assembly | RIGID_FRAME | 3.4 | +51.162 | +51.562 | 13-14/A-B | DUMMY1148 | 10
3 x Steel Assembly | RIGID_FRAME | 9.6 | +55.027 | +55.097 | 13-14/A-B | A193 | 70
3 x Steel Assembly | RIGID_FRAME | 9.6 | +52.227 | +52.297 | 13-14/A-B | A193 | 70
3 x Steel Assembly | RIGID_FRAME | 7.8 | +50.462 | +50.532 | 13-14/A-B | A192 | 70
6 x Steel Assembly | RIGID_FRAME | 9.9 | +50.272 | +50.784 | 13-14/A-B | DUMMY1145 | 10
2 x Steel Assembly | RIGID_FRAME | 30.5 | +56.742 | +56.894 | 13-14/A-B | A401 | 76.2
4 x Steel Assembly | RIGID_FRAME | 35 | +56.894 | +56.926 | 13-14/A-B | A783 | 32
2 x Steel Assembly | RIGID_FRAME | 30.5 | +56.742 | +56.894 | 13-14/A-B | A400 | 76.2
2 x Steel Assembly | RIGID_FRAME | 82.4 | +56.442 | +56.742 | 13-14/A-B | A382 | 200.001
Steel Assembly | RIGID_FRAME | 82.4 | +56.442 | +56.742 | 13-14/A-B | A373 | 200
2 x Steel Assembly | RIGID_FRAME | 5.3 | +56.184 | +56.442 | 13-14/A-B | DUMMY1161 | 10
2 x Steel Assembly | RIGID_FRAME | 11.1 | +55.112 | +56.347 | 13-14/A-B | A198 | 70
Steel Assembly | RIGID_FRAME | 88.5 | +56.186 | +56.742 | 13-14/A-B | A145 | 110
2 x Steel Assembly | RIGID_FRAME | 5 | +55.766 | +56.347 | 13-14/A-B | A201 | 70
2 x Steel Assembly | RIGID_FRAME | 11.1 | +53.771 | +55.012 | 13-14/A-B | A197 | 70
2 x Steel Assembly | RIGID_FRAME | 4.8 | +53.771 | +54.348 | 13-14/A-B | A196 | 70
2 x Steel Assembly | RIGID_FRAME | 10.8 | +52.317 | +53.527 | 13-14/A-B | A195 | 70
Steel Assembly | RIGID_FRAME | 5.5 | +54.376 | +55.012 | 14/A-B | A200 | 70
Steel Assembly | RIGID_FRAME | 4.6 | +52.976 | +53.527 | 14/A-B | A199 | 70
Steel Assembly | RIGID_FRAME | 7.2 | +51.389 | +52.191 | 14/A-B | A287 | 80
Steel Assembly | RIGID_FRAME | 11.1 | +55.112 | +56.345 | 14/A-B | A197 | 70
Steel Assembly | RIGID_FRAME | 5.3 | +55.112 | +55.738 | 14/A-B | A194 | 70
Steel Assembly | RIGID_FRAME | 5 | +55.766 | +56.345 | 14/A-B | A205 | 70
Steel Assembly | RIGID_FRAME | 2.9 | +55.578 | +55.926 | 14/A-B | DUMMY1149 | 10
Steel Assembly | RIGID_FRAME | 11.3 | +53.759 | +55.012 | 14/A-B | A204 | 70
Steel Assembly | RIGID_FRAME | 5 | +53.759 | +54.348 | 14/A-B | A203 | 70
Steel Assembly | RIGID_FRAME | 2.9 | +54.187 | +54.537 | 14/A-B | DUMMY1149 | 10
Steel Assembly | RIGID_FRAME | 13.9 | +52.317 | +53.530 | 14/A-B | A144 | 420.309
Steel Assembly | RIGID_FRAME | 5.3 | +52.317 | +52.948 | 14/A-B | A194 | 70
Steel Assembly | RIGID_FRAME | 14.5 | +50.617 | +52.191 | 14/A-B | A286 | 80
Steel Assembly | RIGID_FRAME | 6.3 | +50.617 | +51.335 | 14/A-B | A285 | 80
Steel Assembly | RIGID_FRAME | 3.4 | +51.162 | +51.562 | 14/A-B | DUMMY1148 | 10
Steel Assembly | RIGID_FRAME | 9.6 | +55.027 | +55.097 | 14/A-B | A193 | 70
Steel Assembly | RIGID_FRAME | 9.6 | +52.227 | +52.297 | 14/A-B | A193 | 70
Steel Assembly | RIGID_FRAME | 7.8 | +50.462 | +50.532 | 14/A-B | A192 | 70
2 x Steel Assembly | RIGID_FRAME | 9.9 | +50.272 | +50.784 | 14/A-B | DUMMY1145 | 10
Steel Assembly | RIGID_FRAME | 82.4 | +56.442 | +56.742 | 13-14/A-B | A380 | 200
2 x Steel Assembly | RIGID_FRAME | 5.3 | +56.184 | +56.442 | 14/A-B | DUMMY1161 | 10
2 x Steel Assembly | RIGID_FRAME | 5.3 | +56.186 | +56.442 | 13-14/A-B | DUMMY1162 | 10
Steel Assembly | RIGID_FRAME | 390.6 | +52.297 | +56.478 | 13/A-B | A314 | 730
2 x Steel Assembly | RIGID_FRAME | 390.6 | +52.297 | +56.478 | 13-14/A-B | A312 | 730
Steel Assembly | RIGID_FRAME | 90.5 | +52.297 | +56.477 | 12-13/A-B | A313 | 329.001
2 x Steel Assembly | RIGID_FRAME | 90.5 | +52.297 | +56.477 | 13-14/A-B | A313 | 329.001
Steel Assembly |  | 0 | +54.180 | +54.214 | 14/A-B | A557 | 34.0407
Steel Assembly |  | 0 | +54.680 | +54.714 | 14/A-B | A557 | 34.0385
Steel Assembly | RIGID_FRAME | 12.5 | +50.322 | +52.327 | 12-13/A | A487 | 750.126
Steel Assembly | RIGID_FRAME | 12.5 | +50.322 | +52.327 | 15/A-B | A487 | 750.126
Steel Assembly | RIGID_FRAME | 12.5 | +50.322 | +52.327 | 12-13/A-B | A485 | 750.001
Steel Assembly | RIGID_FRAME | 138.8 | +56.442 | +56.742 | 13/A-B | A445 | 365
Steel Assembly | RIGID_FRAME | 138.8 | +56.442 | +56.742 | 13-14/A-B | A444 | 365
Steel Assembly | RIGID_FRAME | 83 | +56.442 | +56.742 | 14/A-B | A378 | 100.001
Steel Assembly | RIGID_FRAME | 83 | +56.442 | +56.742 | 12-13/A-B | A379 | 100
Steel Assembly | RIGID_FRAME | 50.4 | +53.537 | +53.697 | 12-13/A-B | A377 | 65
Steel Assembly | RIGID_FRAME | 43.9 | +53.537 | +53.697 | 13-14/A | A375 | 65
Steel Assembly | RIGID_FRAME | 43.9 | +53.537 | +53.697 | 12-14/A | A376 | 65
Steel Assembly | RIGID_FRAME | 278.6 | +50.882 | +53.942 | 12-13/A-B | A323 | 1420
2 x Steel Assembly | RIGID_FRAME | 3.4 | +53.762 | +53.942 | 12-13/A-B | A740 | 28.0004
2 x Steel Assembly | RIGID_FRAME | 3.4 | +53.762 | +53.942 | 12-13/A-B | A740 | 28
2 x Steel Assembly | RIGID_FRAME | 3.4 | +50.882 | +51.062 | 12-13/A-B | A740 | 28.0004
2 x Steel Assembly | RIGID_FRAME | 3.4 | +50.882 | +51.062 | 12-13/A-B | A740 | 28
Steel Assembly | RIGID_FRAME | 278.6 | +50.882 | +53.942 | 13-14/A-B | A323 | 1420
4 x Steel Assembly | RIGID_FRAME | 3.4 | +53.762 | +53.942 | 13-14/A-B | A740 | 28.0004
4 x Steel Assembly | RIGID_FRAME | 3.4 | +53.762 | +53.942 | 13-14/A-B | A740 | 28
4 x Steel Assembly | RIGID_FRAME | 3.4 | +50.882 | +51.062 | 13-14/A-B | A740 | 28.0004
4 x Steel Assembly | RIGID_FRAME | 3.4 | +50.882 | +51.062 | 13-14/A-B | A740 | 28
Steel Assembly | RIGID_FRAME | 282.7 | +50.882 | +53.942 | 13-14/A-B | A324 | 1420
Steel Assembly | RIGID_FRAME | 53.4 | +53.537 | +53.697 | 13/A-B | A458 | 335
Steel Assembly | RIGID_FRAME | 53.4 | +53.537 | +53.697 | 13-14/A-B | A458 | 335
DUMMY |  | 0 | +51.168 | +56.735 | 12-13/A-B | A708 | 26
2 x DUMMY |  | 0 | +51.168 | +56.735 | 13-14/A-B | A708 | 26
3 x Steel Assembly | RIGID_FRAME | 277 | +56.742 | +56.772 | 13-14/A-B | A787 | 30
Steel Assembly | RIGID_FRAME | 37.2 | +51.062 | +52.702 | 13/A-B | A789 | 3
Steel Assembly | RIGID_FRAME | 0.7 | +52.172 | +52.242 | 15/A-B | A267 | 70
Steel Assembly | RIGID_FRAME | 0.2 | +50.657 | +50.707 | 13/A-B | A715 | 50
Steel Assembly | RIGID_FRAME | 475.3 | +53.697 | +53.727 | 13-14/A-B | A786 | 30
Steel Assembly | RIGID_FRAME | 416.6 | +53.697 | +53.727 | 13-14/A-B | A785 | 30
Steel Assembly | RIGID_FRAME | 416.6 | +53.697 | +53.727 | 12-14/A-B | A785 | 30
2 x Steel Assembly | RIGID_FRAME | 383 | +56.742 | +56.772 | 13-14/A-B | A788 | 30
Steel Assembly | RIGID_FRAME | 277 | +56.742 | +56.772 | 12-13/A-B | A787 | 30
2 x Steel Assembly | RIGID_FRAME | 8 | +54.858 | +55.265 | 13/A-B | A738 | 10
2 x Steel Assembly | RIGID_FRAME | 9.1 | +52.024 | +52.471 | 13/A-B | A737 | 10
2 x Steel Assembly | RIGID_FRAME | 1.9 | +53.767 | +53.937 | 12-13/A-B | A805 | 8
2 x Steel Assembly | RIGID_FRAME | 12.8 | +53.373 | +53.924 | 13/A-B | A736 | 10
2 x Steel Assembly | RIGID_FRAME | 12.8 | +53.373 | +53.924 | 12-13/A-B | A736 | 10
2 x Steel Assembly | RIGID_FRAME | 8 | +54.858 | +55.265 | 12-13/A-B | A738 | 10
2 x Steel Assembly | RIGID_FRAME | 9.1 | +52.024 | +52.471 | 12-13/A-B | A737 | 10
6 x Steel Assembly | RIGID_FRAME | 8 | +54.858 | +55.265 | 13-14/A-B | A738 | 10
6 x Steel Assembly | RIGID_FRAME | 9.1 | +52.024 | +52.471 | 13-14/A-B | A737 | 10
2 x Steel Assembly | RIGID_FRAME | 1.9 | +53.767 | +53.937 | 13-14/A-B | A805 | 8
6 x Steel Assembly | RIGID_FRAME | 12.8 | +53.373 | +53.924 | 13-14/A-B | A736 | 10
2 x Steel Assembly | RIGID_FRAME | 8 | +54.858 | +55.265 | 14/A-B | A738 | 10
2 x Steel Assembly | RIGID_FRAME | 9.1 | +52.024 | +52.471 | 14/A-B | A737 | 10
2 x Steel Assembly | RIGID_FRAME | 12.8 | +53.373 | +53.924 | 14/A-B | A736 | 10
4 x Steel Assembly | RIGID_FRAME | 1.1 | +53.762 | +53.942 | 12-13/A-B | A804 | 8
2 x Steel Assembly | RIGID_FRAME | 5.7 | +56.590 | +56.742 | 12-13/A-B | A418 | 76.2
2 x Steel Assembly | RIGID_FRAME | 18.9 | +53.537 | +53.697 | 13-14/A-B | A460 | 65
Steel Assembly | RIGID_FRAME | 37.2 | +51.062 | +52.702 | 13-14/A-B | A789 | 3
8 x Steel Assembly | RIGID_FRAME | 1.1 | +53.762 | +53.942 | 13-14/A-B | A804 | 8
4 x Steel Assembly | RIGID_FRAME | 5.7 | +56.590 | +56.742 | 13-14/A-B | A418 | 76.2
Steel Assembly | RIGID_FRAME | 47.2 | +53.537 | +53.697 | 13-14/A-B | A459 | 65
Steel Assembly | RIGID_FRAME | 26.8 | +52.699 | +52.702 | 13-14/A-B | A803 | 3
Steel Assembly | RIGID_FRAME | 77.9 | +56.442 | +56.742 | 13-14/A-B | A443 | 100
Steel Assembly | RIGID_FRAME | 16.3 | +57.180 | +57.276 | 12-13/C-D | A636 | 66.0113
Steel Assembly | RIGID_FRAME | 16.3 | +57.180 | +57.276 | 12-13/B-C | A636 | 66.0113
Steel Assembly | RIGID_FRAME | 6.1 | +57.180 | +57.276 | 12-13/A-B | A614 | 66.0207
Steel Assembly | RIGID_FRAME | 9.1 | +50.577 | +51.167 | 1/A-B | A750 | 62.0053
Steel Assembly | RIGID_FRAME | 30 | +52.073 | +52.153 | 1-2/A-B | A827 | 80.0016
2 x Liner Plate |  | 0 | +52.872 | +53.301 | 6-7/C | A835 | 16
2 x Liner Plate |  | 0 | +52.843 | +53.278 | 6-7/C | A832 | 16
2 x Liner Plate |  | 0 | +52.814 | +53.249 | 6-7/C | A832 | 16
2 x Liner Plate |  | 0 | +52.748 | +53.184 | 6-7/C | A832 | 16
2 x Liner Plate |  | 0 | +52.719 | +53.155 | 6/C | A832 | 16
2 x Liner Plate |  | 0 | +52.690 | +53.126 | 6/C | A832 | 16
2 x Liner Plate |  | 0 | +52.654 | +53.096 | 5-6/C | A834 | 16
2 x Liner Plate |  | 0 | +52.625 | +53.060 | 5-6/C | A832 | 16
2 x Liner Plate |  | 0 | +52.596 | +53.031 | 5-6/C | A832 | 16
2 x Liner Plate |  | 0 | +52.567 | +53.002 | 5-6/C | A832 | 16
2 x Liner Plate |  | 0 | +52.530 | +52.972 | 5-6/C | A834 | 16
2 x Liner Plate |  | 0 | +52.501 | +52.936 | 5/C | A832 | 16
2 x Liner Plate |  | 0 | +52.472 | +52.907 | 5/C | A832 | 16
2 x Liner Plate |  | 0 | +52.443 | +52.878 | 4-5/C | A832 | 16
2 x Liner Plate |  | 0 | +52.409 | +52.848 | 4-5/C | A833 | 16
2 x Liner Plate |  | 0 | +52.380 | +52.815 | 4-5/C | A832 | 16
2 x Liner Plate |  | 0 | +52.351 | +52.786 | 4-5/C | A832 | 16
2 x Liner Plate |  | 0 | +52.322 | +52.757 | 4-5/C | A832 | 16
2 x Liner Plate |  | 0 | +52.293 | +52.728 | 4-5/C | A832 | 16
Steel Assembly | RIGID_FRAME | 5.2 | +50.652 | +50.702 | 1/C-E | A729 | 50
Steel Assembly | RIGID_FRAME | 9.9 | +50.652 | +50.702 | 1-2/D-E | A728 | 50
Steel Assembly | RIGID_FRAME | 9.9 | +50.652 | +50.702 | 1-2/C-D | A727 | 50
DUMMY_PULLY |  | 0 | +51.530 | +52.354 | 1-2/C-E | A439 | 824
DUMMY_PULLY |  | 0 | +50.545 | +51.199 | 1-2/C-E | A436 | 654
DUMMY_PULLY |  | 0 | +51.530 | +52.354 | 1-2/B-D | A439 | 824
DUMMY_PULLY |  | 0 | +50.545 | +51.199 | 1-2/B-D | A436 | 654
Steel Assembly | RIGID_FRAME | 18 | +50.815 | +50.977 | 6/D-E | A770 | 200
2 x Steel Assembly | RIGID_FRAME | 18 | +50.815 | +50.977 | 6/C-D | A770 | 200
2 x Steel Assembly | RIGID_FRAME | 18 | +50.815 | +50.977 | 6/B-C | A770 | 200
Steel Assembly | RIGID_FRAME | 18 | +52.396 | +52.558 | 8/D-E | A731 | 200
2 x Steel Assembly | RIGID_FRAME | 18 | +52.396 | +52.558 | 8/C-D | A731 | 200
2 x Steel Assembly | RIGID_FRAME | 18 | +52.396 | +52.558 | 8/B-C | A731 | 200
Steel Assembly | RIGID_FRAME | 18 | +52.396 | +52.558 | 8/A-B | A731 | 200
Steel Assembly | RIGID_FRAME | 161.3 | +50.259 | +53.149 | 9/C-E | A184 | 274.872
2 x Steel Assembly | RIGID_FRAME | 27.7 | +51.761 | +53.149 | 9/C-E | A434 | 100
Steel Assembly | RIGID_FRAME | 111.4 | +50.242 | +53.389 | 9/D-E | A17 | 324.454
Steel Assembly | RIGID_FRAME | 139.6 | +50.267 | +52.156 | 8/C-E | A183 | 260.441
2 x Steel Assembly | RIGID_FRAME | 15.9 | +51.273 | +52.156 | 8/C-D | A419 | 70
Steel Assembly | RIGID_FRAME | 81.7 | +50.242 | +52.396 | 8/D-E | A24 | 394.1
DUMMY_PULLY |  | 0 | +50.545 | +51.199 | 1-2/A-C | A436 | 654
Steel Assembly |  | 0 | +57.040 | +58.115 | 17-18/D-E | A162 | 60.4349
Steel Assembly |  | 0 | +57.040 | +58.115 | 17-18/A-B | A162 | 60.4349
Steel Assembly |  | 0 | +53.049 | +54.091 | 5-6/B-C | A177 | 160.28
Steel Assembly | RIGID_FRAME | 3.8 | +50.957 | +51.023 | 5/C-D | A645 | 66
Steel Assembly | RIGID_FRAME | 3.8 | +50.957 | +51.023 | 5/D-E | A645 | 66
Steel Assembly | RIGID_FRAME | 3.8 | +50.957 | +51.023 | 5/B-C | A645 | 66
Steel Assembly | RIGID_FRAME | 3.8 | +50.957 | +51.023 | 5/A-B | A645 | 66
Steel Assembly | RIGID_FRAME | 6.1 | +55.606 | +55.784 | 10-11/D-E | A610 | 66.0257
Steel Assembly | RIGID_FRAME | 16.3 | +55.605 | +55.784 | 10-11/C-D | A633 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +55.605 | +55.784 | 10-11/B-C | A633 | 66.0003
Steel Assembly | RIGID_FRAME | 6.1 | +55.606 | +55.784 | 10-11/A-B | A610 | 66.0257
2 x Rubber |  | 0 | +52.788 | +52.942 | 4-5/C | A778 | 10
Steel Assembly | RIGID_FRAME | 16.3 | +57.114 | +57.227 | 12-13/C-D | A641 | 67.1129
Steel Assembly | RIGID_FRAME | 16.3 | +57.034 | +57.156 | 12-13/C-D | A642 | 66.6699
Steel Assembly | RIGID_FRAME | 16.3 | +56.717 | +56.862 | 12-13/C-D | A638 | 76.5138
Steel Assembly | RIGID_FRAME | 16.3 | +57.114 | +57.227 | 12-13/B-C | A641 | 67.1129
Steel Assembly | RIGID_FRAME | 16.3 | +57.034 | +57.156 | 12-13/B-C | A642 | 66.6699
Steel Assembly | RIGID_FRAME | 16.3 | +56.717 | +56.862 | 12-13/B-C | A638 | 76.5138
Steel Assembly | RIGID_FRAME | 6.1 | +57.033 | +57.156 | 12-13/A-B | A615 | 67.3061
Steel Assembly | RIGID_FRAME | 18 | +55.374 | +55.536 | 11/D-E | A733 | 200
2 x Steel Assembly | RIGID_FRAME | 18 | +55.374 | +55.536 | 11/C-D | A733 | 200
2 x Steel Assembly | RIGID_FRAME | 18 | +55.374 | +55.536 | 11/B-C | A731 | 200
Steel Assembly | RIGID_FRAME | 18 | +55.374 | +55.536 | 11/A-B | A731 | 200
Steel Assembly | RIGID_FRAME | 18 | +54.381 | +54.543 | 10/D-E | A734 | 200
2 x Steel Assembly | RIGID_FRAME | 18 | +54.381 | +54.543 | 10/C-D | A733 | 200
2 x Steel Assembly | RIGID_FRAME | 18 | +54.381 | +54.543 | 10/B-C | A733 | 200
Steel Assembly | RIGID_FRAME | 18 | +53.389 | +53.551 | 9/D-E | A734 | 200
2 x Steel Assembly | RIGID_FRAME | 18 | +53.389 | +53.551 | 9/C-D | A731 | 200
2 x Steel Assembly | RIGID_FRAME | 18 | +53.389 | +53.551 | 9/B-C | A731 | 200
Steel Assembly | RIGID_FRAME | 18 | +51.403 | +51.565 | 7/D-E | A731 | 200
2 x Steel Assembly | RIGID_FRAME | 18 | +51.403 | +51.565 | 7/B-C | A733 | 200.001
Steel Assembly | RIGID_FRAME | 16.3 | +56.576 | +56.734 | 11-12/C-D | A640 | 66.9157
Steel Assembly | RIGID_FRAME | 16.3 | +56.269 | +56.445 | 11-12/C-D | A644 | 68.2292
Steel Assembly | RIGID_FRAME | 16.3 | +56.105 | +56.283 | 11-12/C-D | A635 | 66.0285
Steel Assembly | RIGID_FRAME | 16.3 | +55.940 | +56.118 | 11-12/C-D | A635 | 66.0285
Steel Assembly | RIGID_FRAME | 16.3 | +55.779 | +55.953 | 11-12/C-D | A634 | 66.0254
Steel Assembly | RIGID_FRAME | 16.3 | +56.576 | +56.734 | 11-12/B-C | A640 | 66.9157
Steel Assembly | RIGID_FRAME | 16.3 | +56.269 | +56.445 | 11-12/B-C | A644 | 68.2292
Steel Assembly | RIGID_FRAME | 16.3 | +56.105 | +56.283 | 11-12/B-C | A635 | 66.0285
Steel Assembly | RIGID_FRAME | 16.3 | +55.940 | +56.118 | 11-12/B-C | A635 | 66.0285
Steel Assembly | RIGID_FRAME | 16.3 | +55.779 | +55.953 | 11-12/B-C | A634 | 66.0254
Steel Assembly | RIGID_FRAME | 6.1 | +56.576 | +56.734 | 11-12/D-E | A620 | 66.9045
Steel Assembly | RIGID_FRAME | 6.1 | +56.269 | +56.445 | 11-12/D-E | A624 | 68.2676
Steel Assembly | RIGID_FRAME | 6.1 | +56.105 | +56.283 | 11-12/D-E | A613 | 65.956
Steel Assembly | RIGID_FRAME | 6.1 | +55.940 | +56.118 | 11-12/D-E | A613 | 66.0525
Steel Assembly | RIGID_FRAME | 6.1 | +55.779 | +55.953 | 11-12/D-E | A612 | 66.0726
Steel Assembly | RIGID_FRAME | 6.1 | +56.576 | +56.734 | 11-12/A-B | A619 | 66.8548
Steel Assembly | RIGID_FRAME | 6.1 | +56.269 | +56.445 | 11-12/A-B | A624 | 68.2676
Steel Assembly | RIGID_FRAME | 6.1 | +56.105 | +56.283 | 11-12/A-B | A613 | 66.0409
Steel Assembly | RIGID_FRAME | 6.1 | +55.940 | +56.118 | 11-12/A-B | A613 | 66.0525
Steel Assembly | RIGID_FRAME | 6.1 | +55.779 | +55.953 | 11-12/A-B | A612 | 66.1756
Steel Assembly |  | 0 | +55.783 | +56.809 | 10-11/A-B | A560 | 34
Steel Assembly |  | 0 | +55.285 | +56.311 | 10-11/A-B | A560 | 34
Steel Assembly |  | 0 | +54.791 | +55.817 | 9-10/A-B | A560 | 34
Steel Assembly |  | 0 | +54.293 | +55.319 | 9-10/A-B | A560 | 34
Steel Assembly |  | 0 | +53.799 | +54.825 | 8-9/A-B | A560 | 34
Steel Assembly |  | 0 | +53.300 | +54.327 | 8-9/A-B | A560 | 34
Steel Assembly | RIGID_FRAME | 16.3 | +55.443 | +55.620 | 10-11/C-D | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +55.278 | +55.455 | 10-11/C-D | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +55.116 | +55.291 | 10-11/C-D | A627 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +54.951 | +55.126 | 10-11/C-D | A627 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +54.787 | +54.961 | 10-11/C-D | A629 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +54.613 | +54.792 | 9-10/C-D | A632 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +54.451 | +54.628 | 9-10/C-D | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +54.286 | +54.463 | 9-10/C-D | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +54.121 | +54.298 | 9-10/C-D | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +53.956 | +54.133 | 9-10/C-D | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +53.795 | +53.969 | 9-10/C-D | A629 | 66.0002
Steel Assembly | RIGID_FRAME | 16.3 | +53.621 | +53.800 | 8-9/C-D | A632 | 66.0002
Steel Assembly | RIGID_FRAME | 16.3 | +53.458 | +53.636 | 8-9/C-D | A626 | 66.0002
Steel Assembly | RIGID_FRAME | 16.3 | +53.293 | +53.471 | 8-9/C-D | A626 | 66.0002
Steel Assembly | RIGID_FRAME | 16.3 | +53.129 | +53.306 | 8-9/C-D | A626 | 66.0002
Steel Assembly | RIGID_FRAME | 16.3 | +52.964 | +53.141 | 8-9/C-D | A626 | 66.0049
Steel Assembly | RIGID_FRAME | 16.3 | +52.803 | +52.976 | 8-9/C-D | A629 | 66
Steel Assembly | RIGID_FRAME | 16.3 | +52.629 | +52.808 | 7-8/C-D | A632 | 66
Steel Assembly | RIGID_FRAME | 16.3 | +51.022 | +51.231 | 5-6/C-D | A631 | 65.9999
Steel Assembly | RIGID_FRAME | 16.3 | +51.211 | +51.359 | 6-7/C-D | A630 | 66.0001
Steel Assembly | RIGID_FRAME | 16.3 | +52.466 | +52.643 | 7-8/C-D | A626 | 66
Steel Assembly | RIGID_FRAME | 16.3 | +52.301 | +52.478 | 7-8/C-D | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +52.136 | +52.314 | 7-8/C-D | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +51.347 | +51.524 | 6-7/C-D | A626 | 66
Steel Assembly | RIGID_FRAME | 16.3 | +51.972 | +52.149 | 7-8/C-D | A626 | 65.996
Steel Assembly | RIGID_FRAME | 16.3 | +51.810 | +51.984 | 7-8/C-D | A629 | 65.9935
Steel Assembly | RIGID_FRAME | 16.3 | +51.660 | +51.815 | 6-7/C-D | A628 | 65.9961
Steel Assembly | RIGID_FRAME | 16.3 | +51.512 | +51.689 | 6-7/C-D | A626 | 65.998
Steel Assembly | RIGID_FRAME | 16.3 | +55.443 | +55.620 | 10-11/B-C | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +55.278 | +55.455 | 10-11/B-C | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +55.116 | +55.291 | 10-11/B-C | A627 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +54.951 | +55.126 | 10-11/B-C | A627 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +54.787 | +54.961 | 10-11/B-C | A629 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +54.613 | +54.792 | 9-10/B-C | A632 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +54.451 | +54.628 | 9-10/B-C | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +54.286 | +54.463 | 9-10/B-C | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +54.121 | +54.298 | 9-10/B-C | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +53.956 | +54.133 | 9-10/B-C | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +53.795 | +53.969 | 9-10/B-C | A629 | 66.0002
Steel Assembly | RIGID_FRAME | 16.3 | +53.621 | +53.800 | 8-9/B-C | A632 | 66.0002
Steel Assembly | RIGID_FRAME | 16.3 | +53.458 | +53.636 | 8-9/B-C | A626 | 66.0002
Steel Assembly | RIGID_FRAME | 16.3 | +53.293 | +53.471 | 8-9/B-C | A626 | 66.0002
Steel Assembly | RIGID_FRAME | 16.3 | +53.129 | +53.306 | 8-9/B-C | A626 | 66.0002
Steel Assembly | RIGID_FRAME | 16.3 | +52.964 | +53.141 | 8-9/B-C | A626 | 66.0049
Steel Assembly | RIGID_FRAME | 16.3 | +52.803 | +52.976 | 8-9/B-C | A629 | 66
Steel Assembly | RIGID_FRAME | 16.3 | +52.629 | +52.808 | 7-8/B-C | A632 | 66
Steel Assembly | RIGID_FRAME | 16.3 | +51.022 | +51.231 | 5-6/B-C | A631 | 65.9999
Steel Assembly | RIGID_FRAME | 16.3 | +51.211 | +51.359 | 6-7/B-C | A630 | 66.0001
Steel Assembly | RIGID_FRAME | 16.3 | +52.466 | +52.643 | 7-8/B-C | A626 | 66
