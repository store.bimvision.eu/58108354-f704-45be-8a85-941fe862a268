Properties of the parts of a building model (IFC2X3), part 1 of 16

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], ExchangeRequirement[Structural, SurfaceGeometry]
File name: 17J.ifc
Time: 2017-01-18T18:03:01
Author: GEN-PC\GEN
Organization: Structural Designer
Written by: IFC Database Version:Work
Made in: Tekla structures 21.1, IFC Export Version: 4.0.0.0 Sep 11 2015

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C140*60 (24)
In: Undefined
Description: C140*60; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 30.8 m2; Net surface area: 0.3 m2; Height: 140 mm; Width: 60 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x DUMMY | +51.666 | +51.806 | 22 | 2 | 10.5 | 657 | m412 | 656.978 | 0.323972 | 0.00118003 | 9.26321
3 x DUMMY | +51.666 | +51.806 | 22 | 2 | 10.5 | 657 | m411 | 656.978 | 0.323972 | 0.00118003 | 9.26321
3 x Post | +57.335 | +57.874 | 12 | 3 | 8.5 | 539.1 | m407 | 539.08 | 0.265833 | 0.00101047 | 7.93221
3 x Post | +57.335 | +57.874 | 12 | 3 | 8.5 | 539.1 | m406 | 539.08 | 0.265833 | 0.00101047 | 7.93221
Column | +57.791 | +58.411 | 3 | 3 | 10 | 620 | A442 | 620.013 | 0.305743 | 0.00124644 | 9.78456
Column | +57.791 | +58.411 | 3 | 3 | 10 | 620 | A441 | 620.013 | 0.305743 | 0.00124644 | 9.78456
2 x Column | +57.791 | +58.411 | 3 | 3 | 10 | 620 | A442 | 620.015 | 0.305744 | 0.00124644 | 9.78458
2 x Column | +57.791 | +58.411 | 3 | 3 | 10 | 620 | A441 | 620.015 | 0.305744 | 0.00124644 | 9.78458
3 x Post | +50.436 | +51.226 | 9 | 3 | 12.6 | 790 | m405 | 790.003 | 0.389569 | 0.00158818 | 12.4672
3 x Post | +50.436 | +51.226 | 9 | 3 | 12.6 | 790 | m404 | 790.003 | 0.389569 | 0.00158818 | 12.4672

# IfcBeam: C152*76 (21)
In: Undefined
Description: C152*76; Material: STEEL/S355JR
Tekla Common - Class: 2
Tekla Quantity - Volume: 0 m3; Area per tons: 32.6 m2; Height: 152.4 mm; Width: 76.2 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x DUMMY | +51.088 | +51.240 | 22 | 58.4 | 0.2 | 1.9 | 3260 | m312 | 1.90471 | 0.00714813 | 56.1128
6 x DUMMY | +56.742 | +56.894 | 11 | 2.2 | 0 | 0.1 | 124 | m311 | 0.0724492 | 0.000271892 | 2.13435
6 x DUMMY | +56.590 | +56.742 | 11 | 5.7 | 0 | 0.2 | 316.4 | A418 | 0.184862 | 0.000693763 | 5.44604
3 x DUMMY | +56.742 | +56.894 | 11 | 30.4 | 0.1 | 0.9 | 1700 | A401 | 0.993254 | 0.00372755 | 29.2613
3 x DUMMY | +56.742 | +56.894 | 11 | 30.4 | 0.1 | 0.9 | 1700 | A400 | 0.993254 | 0.00372755 | 29.2613

# IfcBeam: C160*65 (18)
In: Undefined
Description: C160*65; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 29.3 m2; Height: 160 mm; Width: 65 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x Beam | +57.110 | +57.270 | 3 | 3 | 18.1 | 0.1 | 0.5 | 960.2 | m454 | 960.2 | 0.529325 | 0.00217863 | 17.1023
3 x Beam | +58.317 | +58.477 | 4 | 3 | 43.3 | 0.1 | 1.3 | 2290 | m451 | 2290.02 | 1.26241 | 0.00543429 | 42.6592
Beam | +57.110 | +57.270 | 3 | 3 | 20.1 | 0.1 | 0.6 | 1063.9 | m453 | 1063.85 | 0.586464 | 0.00240277 | 18.8617
Beam | +57.110 | +57.270 | 3 | 3 | 20.1 | 0.1 | 0.6 | 1063.9 | m452 | 1063.85 | 0.586464 | 0.00240277 | 18.8617
3 x DUMMY | +53.537 | +53.697 | 11 | 2 | 47.2 | 0.2 | 1.4 | 2500 | m440 | 2500 | 1.37816 | 0.00593257 | 46.5707
2 x DUMMY | +53.537 | +53.697 | 11 | 2 | 18.9 | 0.1 | 0.6 | 1000 | A460 | 1000 | 0.551266 | 0.00237303 | 18.6283
2 x DUMMY | +53.537 | +53.697 | 11 | 2 | 37.5 | 0.1 | 1.1 | 1985 | m447 | 1985 | 1.09426 | 0.00471046 | 36.9771
DUMMY | +53.537 | +53.697 | 11 | 2 | 47.2 | 0.2 | 1.4 | 2500 | m441 | 2500 | 1.37816 | 0.00593257 | 46.5707
DUMMY | +53.537 | +53.697 | 11 | 2 | 47.2 | 0.2 | 1.4 | 2500 | A459 | 2500 | 1.37816 | 0.00593257 | 46.5707

# IfcBeam: CFLC100*75*20*2.5 (3)
In: Undefined
Description: CFLC100*75*20*2.5; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +51.118; Top elevation: +51.218; Phase: 22; Class: 2
Tekla Quantity - Volume: 0 m3; Area per tons: 102.8 m2; Height: 100 mm; Width: 75 mm
Pset_BeamCommon - LoadBearing: yes
Name | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
DUMMY | 10.8 | 0.2 | 1.3 | 2046 | A707 | 1.12086 | 0.0014322 | 11.2428
DUMMY | 29.6 | 0.3 | 3.1 | 5546 | A706 | 3.03828 | 0.0038822 | 30.4753
DUMMY | 48.2 | 0.8 | 5.1 | 9046 | A705 | 4.95569 | 0.0063322 | 49.7078

# IfcBeam: CHS34*2.5 (153)
In: Undefined
Description: CHS34*2.5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 34 mm; Width: 34 mm
Pset_BeamCommon - LoadBearing: yes
Name | Material | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.894 | +52.030 | 7 | 44 | 0 | 0 | 294.3 | A558 | 294.298 | 0.0313043 | 0.0000694276 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.894 | +52.030 | 7 | 44 | 0 | 0 | 294.3 | A558 | 294.299 | 0.0313043 | 0.0000694276 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +51.894 | +52.030 | 7 | 44 | 0 | 0 | 294.1 | A558 | 294.085 | 0.0312818 | 0.0000693771 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +51.894 | +52.030 | 7 | 44 | 0 | 0 | 294.1 | A558 | 294.085 | 0.0312817 | 0.0000693771 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.521 | +51.579 | 7 | 45 | 0 | 0.1 | 486.8 | A575 | 486.815 | 0.0515439 | 0.000114588 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.500 | +51.555 | 7 | 41 | 0 | 0 | 435.8 | A579 | 435.818 | 0.0461896 | 0.000102651 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +52.024 | +52.083 | 7 | 45 | 0 | 0.1 | 488.8 | A580 | 488.822 | 0.0517868 | 0.000115173 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +52.005 | +52.059 | 7 | 41 | 0 | 0 | 431.6 | A581 | 431.587 | 0.0457394 | 0.000101639 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.521 | +51.579 | 7 | 45 | 0 | 0.1 | 486.8 | A576 | 486.815 | 0.0515439 | 0.000114588 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.500 | +51.555 | 7 | 41 | 0 | 0 | 435.8 | A579 | 435.818 | 0.0461896 | 0.00010265 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +52.024 | +52.083 | 7 | 45 | 0 | 0.1 | 488.8 | A578 | 488.822 | 0.0517868 | 0.000115173 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +52.005 | +52.059 | 7 | 41 | 0 | 0 | 431.6 | A577 | 431.587 | 0.0457394 | 0.000101639 | 0
8 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.996 | +52.039 | 7 | 40 | 0 | 0 | 121.4 | A568 | 121.436 | 0.0130784 | 0.0000286892 | 0
8 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.490 | +51.534 | 7 | 40 | 0 | 0 | 129.7 | A567 | 129.735 | 0.0139548 | 0.0000306499 | 0
4 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.387 | +51.524 | 7 | 44 | 0 | 0 | 294.3 | A558 | 294.298 | 0.0313043 | 0.0000694276 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.387 | +51.524 | 7 | 44 | 0 | 0 | 294.3 | A558 | 294.299 | 0.0313043 | 0.0000694276 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +51.387 | +51.524 | 7 | 44 | 0 | 0 | 294.1 | A558 | 294.085 | 0.0312818 | 0.0000693771 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +51.387 | +51.524 | 7 | 44 | 0 | 0 | 294.1 | A558 | 294.085 | 0.0312817 | 0.0000693771 | 0
6 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.697 | +52.245 | 7 | 42 | 0 | 0.1 | 1014.2 | A587 | 1014.15 | 0.107174 | 0.000238972 | 0
4 x HANDRAIL | MISCELLANEOUS/COMPONENT | +52.050 | +52.233 | 7 | 40 | 0 | 0.2 | 1795.9 | A571 | 1795.9 | 0.189899 | 0.000424282 | 0
4 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.546 | +51.731 | 7 | 40 | 0 | 0.2 | 1835.5 | A572 | 1835.49 | 0.194079 | 0.000433633 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +52.005 | +52.233 | 7 | 40 | 0 | 0.2 | 2336.8 | A573 | 2336.78 | 0.247015 | 0.000552064 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.501 | +51.731 | 7 | 40 | 0 | 0.3 | 2383.1 | A574 | 2383.09 | 0.251905 | 0.000563005 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.753 | +57.787 | 1 | 40 | 0 | 0 | 154 | A589 | 153.967 | 0.0165137 | 0.0000363748 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +58.253 | +58.287 | 1 | 40 | 0 | 0 | 154 | A589 | 153.967 | 0.0165137 | 0.0000363748 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.753 | +57.787 | 1 | 40 | 0 | 0 | 159.2 | m613 | 159.217 | 0.0170681 | 0.0000376151 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +58.253 | +58.287 | 1 | 40 | 0 | 0 | 159.2 | m613 | 159.217 | 0.0170681 | 0.0000376151 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.753 | +57.787 | 7 | 41 | 0 | 0 | 391.3 | A582 | 391.259 | 0.0414844 | 0.0000921241 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +57.428 | +58.098 | 7 | 40 | 0 | 0.1 | 1077.6 | A592 | 1077.6 | 0.113843 | 0.000253851 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +58.253 | +58.287 | 7 | 41 | 0 | 0 | 391.3 | A582 | 391.277 | 0.0414863 | 0.0000921285 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.571 | +57.787 | 7 | 40 | 0 | 0 | 378.6 | A591 | 378.621 | 0.0401932 | 0.0000892934 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.753 | +57.787 | 7 | 41 | 0 | 0 | 386 | A583 | 386.027 | 0.0409319 | 0.0000908881 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +58.072 | +58.287 | 7 | 40 | 0 | 0 | 381.3 | A590 | 381.347 | 0.040481 | 0.0000899375 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +58.253 | +58.287 | 7 | 41 | 0 | 0 | 386 | A583 | 386.027 | 0.0409319 | 0.0000908881 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +57.753 | +57.787 | 7 | 41 | 0 | 0.1 | 563.1 | A584 | 563.08 | 0.0596284 | 0.000132717 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +58.253 | +58.287 | 7 | 41 | 0 | 0.1 | 563.1 | A584 | 563.08 | 0.0596284 | 0.000132717 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.748 | +57.787 | 7 | 41 | 0 | 0.1 | 525.5 | A585 | 525.549 | 0.0556653 | 0.00012385 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +58.253 | +58.291 | 7 | 41 | 0 | 0.1 | 525.5 | A585 | 525.549 | 0.0556653 | 0.00012385 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.748 | +57.787 | 7 | 41 | 0 | 0.1 | 525.5 | A586 | 525.549 | 0.0556653 | 0.00012385 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +58.253 | +58.291 | 7 | 41 | 0 | 0.1 | 525.5 | A586 | 525.549 | 0.0556653 | 0.00012385 | 0
3 x HANDRAIL | MISCELLANEOUS/COMPONENT | +53.382 | +53.930 | 6 | 42 | 0 | 0.1 | 1014.1 | m612 | 1014.1 | 0.107169 | 0.00023896 | 0
3 x HANDRAIL | MISCELLANEOUS/COMPONENT | +53.382 | +53.930 | 6 | 42 | 0 | 0.1 | 1014.2 | m618 | 1014.19 | 0.107147 | 0.00023887 | 0
3 x HANDRAIL | MISCELLANEOUS/COMPONENT | +53.398 | +53.479 | 6 | 40 | 0 | 0.1 | 570.3 | m586 | 570.279 | 0.0604754 | 0.000134728 | 0
4 x HANDRAIL | MISCELLANEOUS/COMPONENT | +50.919 | +51.583 | 7 | 43 | 0 | 0.1 | 1066.9 | A593 | 1066.88 | 0.112712 | 0.000251321 | 0
4 x HANDRAIL | STEEL/S355JR | +50.919 | +51.583 | 7 | 43 | 2 | 0.1 | 1066.9 | A594 | 1066.87 | 0.112711 | 0.00025132 | 1.97286 | Tekla Quantity - Area per tons: 57.1 m2
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.228 | +57.796 | 7 | 40 | 0 | 1.3 | 11811.6 | A595 | 11811.6 | 1.24754 | 0.00279049 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.728 | +58.295 | 7 | 40 | 0 | 1.3 | 11844.2 | A598 | 11844.2 | 1.25098 | 0.0027982 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.346 | +57.761 | 7 | 40 | 0 | 0.5 | 5125.2 | A602 | 5125.24 | 0.541471 | 0.00121084 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +56.776 | +57.380 | 7 | 40 | 0 | 0.6 | 6914.1 | A566 | 6914.08 | 0.73037 | 0.00163345 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +56.277 | +56.882 | 7 | 40 | 0 | 0.6 | 6913.8 | A566 | 6913.75 | 0.730335 | 0.00163337 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +56.848 | +57.262 | 7 | 40 | 0 | 0.5 | 5116.8 | A601 | 5116.75 | 0.540575 | 0.00120883 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +55.783 | +56.809 | 7 | 40 | 0 | 1.3 | 12041.2 | A560 | 12041.2 | 1.27179 | 0.00284474 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +55.285 | +56.311 | 7 | 40 | 0 | 1.3 | 12041 | A560 | 12041 | 1.27177 | 0.00284469 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +54.791 | +55.817 | 7 | 40 | 0 | 1.3 | 12041.1 | A560 | 12041.1 | 1.27178 | 0.00284471 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +54.293 | +55.319 | 7 | 40 | 0 | 1.3 | 12041.1 | A560 | 12041.1 | 1.27177 | 0.00284471 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +53.799 | +54.825 | 7 | 40 | 0 | 1.3 | 12041.3 | A560 | 12041.3 | 1.2718 | 0.00284477 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +53.300 | +54.327 | 7 | 40 | 0 | 1.3 | 12041.3 | A560 | 12041.3 | 1.2718 | 0.00284477 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +52.005 | +52.256 | 7 | 40 | 0 | 0.3 | 2630.1 | A562 | 2630.09 | 0.277987 | 0.000621358 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.501 | +51.755 | 7 | 40 | 0 | 0.3 | 2676.4 | A561 | 2676.39 | 0.282877 | 0.000632296 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +52.806 | +53.833 | 7 | 40 | 0 | 1.3 | 12041.6 | A560 | 12041.6 | 1.27183 | 0.00284483 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +52.308 | +53.334 | 7 | 40 | 0 | 1.3 | 12041.3 | A560 | 12041.3 | 1.27179 | 0.00284476 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +52.219 | +52.840 | 7 | 40 | 0 | 0.9 | 7124.7 | A559 | 7124.69 | 0.752609 | 0.00168321 | 0
2 x HANDRAIL | MISCELLANEOUS/COMPONENT | +51.721 | +52.342 | 7 | 40 | 0 | 0.9 | 7124.7 | A559 | 7124.69 | 0.752609 | 0.00168321 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.228 | +57.796 | 7 | 40 | 0 | 1.3 | 11811.9 | A596 | 11811.9 | 1.24757 | 0.00279057 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.728 | +58.295 | 7 | 40 | 0 | 1.3 | 11844.6 | A597 | 11844.6 | 1.25102 | 0.00279829 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.346 | +57.761 | 7 | 40 | 0 | 0.5 | 5125.2 | A600 | 5125.25 | 0.541472 | 0.00121084 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +58.253 | +58.287 | 7 | 40 | 0 | 0 | 222.5 | A564 | 222.45 | 0.0237453 | 0.0000525539 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.753 | +57.787 | 7 | 40 | 0 | 0 | 222.5 | A564 | 222.45 | 0.0237453 | 0.0000525539 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +58.253 | +58.287 | 7 | 40 | 0 | 0 | 222.5 | A564 | 222.45 | 0.0237453 | 0.0000525538 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.753 | +57.787 | 7 | 40 | 0 | 0 | 222.5 | A564 | 222.45 | 0.0237453 | 0.0000525538 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +58.253 | +58.287 | 7 | 40 | 0 | 1.3 | 11170 | A563 | 11170 | 1.17979 | 0.00263891 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.753 | +57.787 | 7 | 40 | 0 | 1.3 | 11170 | A563 | 11170 | 1.17979 | 0.00263891 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +58.253 | +58.287 | 7 | 40 | 0 | 1.3 | 11170.3 | A563 | 11170.3 | 1.17982 | 0.00263898 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +57.753 | +57.787 | 7 | 40 | 0 | 1.3 | 11170.3 | A563 | 11170.3 | 1.17982 | 0.00263898 | 0
HANDRAIL | MISCELLANEOUS/COMPONENT | +56.848 | +57.262 | 7 | 40 | 0 | 0.5 | 5116.8 | A599 | 5116.76 | 0.540575 | 0.00120883 | 0
DUMMY | MISCELLANEOUS/COMPONENT | +54.680 | +54.714 | 11 | 2 | 0 | 0.1 | 545 | m569 | 545 | 0.057806 | 0.000128756 | 0
DUMMY | MISCELLANEOUS/COMPONENT | +57.725 | +57.759 | 11 | 2 | 0 | 0.6 | 5579.1 | m570 | 5579.11 | 0.589399 | 0.00131806 | 0
DUMMY | MISCELLANEOUS/COMPONENT | +57.225 | +57.259 | 11 | 2 | 0 | 0.6 | 5579.1 | m570 | 5579.11 | 0.589399 | 0.00131806 | 0
DUMMY | MISCELLANEOUS/COMPONENT | +54.180 | +54.214 | 11 | 2 | 0 | 0.1 | 545 | m569 | 545 | 0.057806 | 0.000128756 | 0
DUMMY | MISCELLANEOUS/COMPONENT | +54.680 | +54.714 | 11 | 2 | 0 | 0.6 | 6049.5 | m568 | 6049.5 | 0.639071 | 0.00142919 | 0
DUMMY | MISCELLANEOUS/COMPONENT | +54.180 | +54.214 | 11 | 2 | 0 | 0.6 | 6049.5 | m568 | 6049.5 | 0.639072 | 0.0014292 | 0

# IfcBeam: CHS43*3 (68)
In: Undefined
Description: CHS43*3; Material: MISCELLANEOUS/COMPONENT
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Bottom elevation | Top elevation | Phase | Class | Net surface area (m2) | Height (mm) | Width (mm) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
3 x HANDRAIL | +50.914 | +52.076 | 7 | 48 | 0.2 | 60 | 60 | 1161.7 | m424 | 1161.69 | 0.16195 | 0.000807012
HANDRAIL | +50.914 | +52.076 | 7 | 48 | 0.2 | 60 | 60 | 1161.7 | m424 | 1161.69 | 0.16195 | 0.000807011
3 x HANDRAIL | +53.064 | +54.091 | 6 | 48 | 0.1 | 63.5 | 67.2 | 1027.5 | m427 | 1027.55 | 0.14344 | 0.00075711
HANDRAIL | +57.160 | +58.300 | 7 | 46 | 0.2 | 60 | 60 | 1140 | m428 | 1140 | 0.159054 | 0.000799198
HANDRAIL | +57.165 | +58.300 | 7 | 46 | 0.2 | 60 | 60 | 1135.1 | m429 | 1135.1 | 0.1584 | 0.000797436
8 x HANDRAIL | +57.160 | +58.300 | 7 | 46 | 0.2 | 60 | 60 | 1140 | m428 | 1140 | 0.159055 | 0.0007992
HANDRAIL | +57.160 | +58.300 | 7 | 46 | 0.2 | 60 | 60 | 1140 | m428 | 1140 | 0.159054 | 0.000799197
HANDRAIL | +57.165 | +58.300 | 7 | 46 | 0.2 | 60 | 60 | 1135.1 | m429 | 1135.1 | 0.1584 | 0.000797435
8 x HANDRAIL | +57.160 | +58.300 | 7 | 46 | 0.2 | 60 | 60 | 1140 | m428 | 1140 | 0.159055 | 0.000799199
5 x DUMMY | +56.632 | +57.772 | 11 | 2 | 0.2 | 60 | 60 | 1140 | m420 | 1139.94 | 0.159047 | 0.000799178
8 x DUMMY | +56.632 | +57.772 | 11 | 2 | 0.2 | 60 | 60 | 1140 | m420 | 1140 | 0.159055 | 0.0007992
2 x DUMMY | +56.632 | +57.772 | 11 | 2 | 0.2 | 60 | 60 | 1140 | m420 | 1140 | 0.159055 | 0.000799199
DUMMY | +53.587 | +54.727 | 11 | 2 | 0.2 | 60 | 60 | 1140 | m420 | 1140 | 0.159055 | 0.000799199
DUMMY | +53.587 | +54.727 | 11 | 2 | 0.2 | 60 | 60 | 1140 | m420 | 1140 | 0.159055 | 0.0007992
5 x DUMMY | +53.587 | +54.727 | 11 | 2 | 0.2 | 60 | 60 | 1140 | m420 | 1139.94 | 0.159047 | 0.000799178
DUMMY | +53.587 | +54.727 | 11 | 2 | 0.2 | 60 | 60 | 1140 | m420 | 1139.94 | 0.159047 | 0.000799179
8 x HANDRAIL | +51.027 | +52.055 | 7 | 48 | 0.1 | 60 | 60 | 1027.7 | m423 | 1027.68 | 0.144054 | 0.00075877
8 x HANDRAIL | +50.579 | +51.600 | 7 | 47 | 0.1 | 60 | 60 | 1020.8 | m422 | 1020.85 | 0.140803 | 0.000749848
HANDRAIL | +57.080 | +58.115 | 7 | 47 | 0.1 | 60 | 60 | 1035.3 | m421 | 1035.26 | 0.142667 | 0.000754865
HANDRAIL | +57.080 | +58.115 | 7 | 47 | 0.1 | 60 | 60 | 1035.3 | m421 | 1035.26 | 0.142666 | 0.000754865

# IfcBeam: D20 (60)
In: Undefined
Description: D20; Material: Undefined/BRIGHT BAR
Tekla Common - Phase: 4; Class: 6
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 20 mm; Width: 20 mm; Length: 85 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A673
BaseQuantities - Length: 85 mm; OuterSurfaceArea: 0.00582857 m2; NetVolume: 0.0000238418 m3; NetWeight: 0 kg
Name | Bottom elevation | Top elevation
30 x Pin | +58.351 | +58.371
30 x Pin | +58.104 | +58.124

# IfcBeam: D35 (60)
In: Undefined
Description: D35; Material: Undefined/Vesconite
Tekla Common - Phase: 4; Class: 99
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 35 mm; Width: 35 mm; Length: 30 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A674
BaseQuantities - Length: 30 mm; OuterSurfaceArea: 0.00509862 m2; NetVolume: 0.0000275625 m3; NetWeight: 0 kg
Name | Bottom elevation | Top elevation
30 x Roller | +58.269 | +58.304
30 x Roller | +58.022 | +58.057

# IfcBeam: D75 (60)
In: Undefined
Description: D75; Material: Undefined/EN8
Tekla Common - Phase: 4; Class: 7
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 75 mm; Width: 75 mm; Length: 45 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 45 mm; OuterSurfaceArea: 0.0215259 m2; NetVolume: 0.000111828 m3; NetWeight: 0 kg
Name | Bottom elevation | Top elevation | Reference
15 x Wheel | +58.324 | +58.399 | A668
15 x Wheel | +58.077 | +58.152 | A668
15 x Wheel | +58.077 | +58.152 | A667
5 x Wheel | +58.324 | +58.399 | A666
10 x Wheel | +58.324 | +58.399 | A665

# IfcBeam: FL10*65 (3)
In: Undefined
Description: FL10*65; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +51.152; Top elevation: +53.986; Phase: 6; Class: 14
Tekla Quantity - Weight: 14.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.5 m2; Net surface area: 0.3 m2; Height: 65 mm; Width: 10 mm; Length: 2875.4 mm
Pset_BeamCommon - LoadBearing: yes; Reference: p255
BaseQuantities - Length: 2875.37 mm; OuterSurfaceArea: 0.433847 m2; NetVolume: 0.00187437 m3; NetWeight: 14.7138 kg

# IfcBeam: FL8*65 (3)
In: Undefined
Description: FL8*65; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +51.144; Top elevation: +51.264; Phase: 6; Class: 14
Tekla Quantity - Weight: 0.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 37.2 m2; Net surface area: 0 m2; Height: 65 mm; Width: 8 mm; Length: 172.7 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A780
BaseQuantities - Length: 172.682 mm; OuterSurfaceArea: 0.0275205 m2; NetVolume: 0.000094314 m3; NetWeight: 0.740365 kg

# IfcBeam: FL8*70 (3)
In: Undefined
Description: FL8*70; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +51.096; Top elevation: +51.221; Phase: 6; Class: 14
Tekla Quantity - Weight: 0.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 36.9 m2; Net surface area: 0 m2; Height: 70 mm; Width: 8 mm; Length: 175.2 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A781
BaseQuantities - Length: 175.327 mm; OuterSurfaceArea: 0.0296205 m2; NetVolume: 0.000102309 m3; NetWeight: 0.803128 kg

# IfcBeam: IPE100 (9)
In: Undefined
Description: IPE100; Material: STEEL/S355JR
Tekla Common - Phase: 9; Class: 3
Tekla Quantity - Weight: 10.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 49.4 m2; Net surface area: 0.5 m2; Height: 100 mm; Width: 55 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x Beam | +51.710 | +51.814 | 1275 | m963 | 1275 | 0.509724 | 0.00126258 | 9.91122
3 x Beam | +51.958 | +52.062 | 1255 | m964 | 1254.99 | 0.501724 | 0.00124277 | 9.75574
3 x Beam | +51.462 | +51.566 | 1275 | m963 | 1274.99 | 0.50972 | 0.00126258 | 9.91122

# IfcBeam: IPE140 (24)
In: Undefined
Description: IPE140; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +57.130; Top elevation: +57.270; Phase: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 42.7 m2; Height: 140 mm; Width: 73 mm
Pset_BeamCommon - LoadBearing: yes
Name | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Beam | 3 | 18.3 | 0.9 | 1420.2 | m674 | 1420.2 | 0.781937 | 0.00219433 | 17.2255
2 x Beam | 3 | 18.3 | 0.9 | 1420.6 | m675 | 1420.6 | 0.782157 | 0.00218934 | 17.1863
4 x Beam | 3 | 20.1 | 0.9 | 1557.7 | m671 | 1557.7 | 0.857642 | 0.00235964 | 18.5232
2 x Beam | 3 | 16.7 | 0.6 | 1292.8 | m672 | 1292.75 | 0.711765 | 0.00199316 | 15.6463
2 x Beam | 3 | 18.3 | 0.9 | 1420.2 | A654 | 1420.2 | 0.781937 | 0.00219433 | 17.2255
4 x Beam | 3 | 18.3 | 0.9 | 1420.6 | A653 | 1420.6 | 0.782157 | 0.00219216 | 17.2085
4 x Beam | 11 | 25.1 | 1.1 | 1947.9 | A651 | 1947.9 | 1.07248 | 0.00303312 | 23.81
2 x Beam | 3 | 16.7 | 0.6 | 1292.7 | A652 | 1292.75 | 0.711765 | 0.00199316 | 15.6463
2 x Beam | 3 | 18.3 | 0.9 | 1420.6 | m673 | 1420.6 | 0.782157 | 0.00219216 | 17.2085

# IfcBeam: L100*100*10 (24)
In: Undefined
Description: L100*100*10; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26 m2; Net surface area: 0.6 m2; Height: 100 mm; Width: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x Nip Angle | +56.790 | +56.899 | 12 | 3 | 23.8 | 1586 | m920 | 0.618064 | 0.0030134 | 23.6552
DUMMY | +52.102 | +52.215 | 22 | 2 | 23.4 | 1560 | m922 | 0.607931 | 0.002964 | 23.2674
3 x DUMMY | +51.514 | +51.614 | 22 | 2 | 23.4 | 1560 | m922 | 0.607931 | 0.002964 | 23.2674
DUMMY | +52.191 | +52.325 | 22 | 2 | 23.4 | 1560 | m922 | 0.607931 | 0.002964 | 23.2674
2 x DUMMY | +51.505 | +51.605 | 22 | 2 | 27.5 | 1834 | m921 | 0.714708 | 0.0034846 | 27.3541
DUMMY | +52.205 | +52.344 | 22 | 2 | 23.4 | 1560 | m922 | 0.607931 | 0.002964 | 23.2674
DUMMY | +51.506 | +51.606 | 22 | 2 | 27.5 | 1834 | m921 | 0.714708 | 0.0034846 | 27.3541
3 x Nip Angle | +57.356 | +57.477 | 12 | 3 | 27.5 | 1830 | m918 | 0.713149 | 0.003477 | 27.2945
3 x Nip Angle | +57.796 | +57.934 | 3 | 3 | 22.8 | 1518 | m919 | 0.591563 | 0.0028842 | 22.641
3 x Nip Angle | +50.563 | +50.671 | 9 | 3 | 27.5 | 1830 | m918 | 0.713149 | 0.003477 | 27.2944
3 x Nip Angle | +51.551 | +51.657 | 9 | 3 | 27.3 | 1820 | m917 | 0.709252 | 0.003458 | 27.1453

# IfcBeam: L125*75*8 (64)
In: Undefined
Description: L125*75*8; Material: STEEL/S355JR
Tekla Common - Phase: 2; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 32 m2; Height: 125 mm; Width: 75 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Walkway_Angle | +55.771 | +56.845 | 146.6 | 4.8 | 12015.2 | A371 | 12015.2 | 4.69263 | 0.0184548 | 144.87
Walkway_Angle | +55.771 | +56.845 | 146.6 | 4.8 | 12015.2 | A370 | 12015.2 | 4.69263 | 0.0184548 | 144.87
2 x Walkway_Angle | +55.771 | +56.845 | 146.6 | 4.8 | 12015.2 | A369 | 12015.2 | 4.69263 | 0.0184548 | 144.87
2 x Walkway_Angle | +55.771 | +56.845 | 146.6 | 4.8 | 12015.2 | A368 | 12015.2 | 4.69263 | 0.0184548 | 144.87
Walkway_Angle | +55.771 | +56.845 | 146.6 | 4.8 | 12015.2 | A367 | 12015.2 | 4.69263 | 0.0184548 | 144.87
Walkway_Angle | +55.771 | +56.845 | 146.6 | 4.8 | 12015.2 | A366 | 12015.2 | 4.69263 | 0.0184548 | 144.87
Walkway_Angle | +54.779 | +55.895 | 146.7 | 4.8 | 12026.7 | A365 | 12026.7 | 4.69711 | 0.018473 | 145.013
Walkway_Angle | +56.721 | +57.353 | 127.9 | 4.2 | 10483.7 | m227 | 10483.7 | 4.09449 | 0.0161018 | 126.399
Walkway_Angle | +56.721 | +57.353 | 127.9 | 4.2 | 10483.7 | m225 | 10483.7 | 4.09449 | 0.0161018 | 126.399
Walkway_Angle | +56.721 | +57.353 | 127.9 | 4.2 | 10483.7 | m224 | 10483.7 | 4.09449 | 0.0161018 | 126.399
Walkway_Angle | +56.721 | +57.353 | 127.9 | 4.2 | 10483.7 | m226 | 10483.7 | 4.09449 | 0.0161018 | 126.399
2 x Walkway_Angle | +56.721 | +57.353 | 127.9 | 4.2 | 10483.7 | m222 | 10483.7 | 4.09449 | 0.0161018 | 126.399
2 x Walkway_Angle | +56.721 | +57.353 | 127.9 | 4.2 | 10483.7 | m223 | 10483.7 | 4.09449 | 0.0161018 | 126.399
2 x Walkway_Angle | +51.014 | +51.339 | 29.7 | 0.9 | 2431.9 | m218 | 2431.94 | 0.949814 | 0.0037308 | 29.2868
Walkway_Angle | +51.014 | +51.339 | 29.7 | 0.9 | 2431.9 | m217 | 2431.94 | 0.949814 | 0.0037308 | 29.2868
Walkway_Angle | +51.014 | +51.339 | 29.7 | 0.9 | 2431.9 | m216 | 2431.94 | 0.949814 | 0.00373077 | 29.2866
2 x Walkway_Angle | +51.014 | +51.339 | 29.7 | 0.9 | 2431.9 | m219 | 2431.94 | 0.949814 | 0.00373077 | 29.2865
Walkway_Angle | +51.014 | +51.339 | 29.7 | 0.9 | 2431.9 | m215 | 2431.95 | 0.949814 | 0.00373077 | 29.2865
Walkway_Angle | +51.014 | +51.339 | 29.7 | 0.9 | 2431.9 | m214 | 2431.94 | 0.949814 | 0.0037308 | 29.2868
2 x Walkway_Angle | +51.215 | +51.926 | 86.8 | 2.8 | 7114.7 | A356 | 7114.71 | 2.7787 | 0.0109282 | 85.7863
Walkway_Angle | +51.215 | +51.926 | 86.8 | 2.8 | 7114.7 | A349 | 7114.69 | 2.7787 | 0.0109282 | 85.7861
Walkway_Angle | +51.215 | +51.926 | 86.8 | 2.8 | 7114.7 | A347 | 7114.71 | 2.7787 | 0.0109282 | 85.7863
2 x Walkway_Angle | +51.802 | +52.918 | 146.7 | 4.8 | 12031 | A342 | 12031 | 4.6988 | 0.0184796 | 145.065
Walkway_Angle | +51.802 | +52.918 | 146.7 | 4.8 | 12031 | A364 | 12031 | 4.6988 | 0.0184796 | 145.065
Walkway_Angle | +51.802 | +52.918 | 146.7 | 4.8 | 12031 | A337 | 12031 | 4.6988 | 0.0184796 | 145.065
Walkway_Angle | +51.802 | +52.918 | 146.7 | 4.8 | 12031 | A363 | 12031 | 4.6988 | 0.0184796 | 145.065
Walkway_Angle | +51.802 | +52.918 | 146.7 | 4.8 | 12031 | A336 | 12031 | 4.6988 | 0.0184796 | 145.065
2 x Walkway_Angle | +51.802 | +52.918 | 146.7 | 4.8 | 12031 | A343 | 12031 | 4.6988 | 0.0184796 | 145.065
2 x Walkway_Angle | +54.779 | +55.895 | 146.7 | 4.8 | 12026.7 | A344 | 12026.7 | 4.69711 | 0.018473 | 145.013
Walkway_Angle | +54.779 | +55.895 | 146.7 | 4.8 | 12026.7 | A339 | 12026.7 | 4.69711 | 0.018473 | 145.013
Walkway_Angle | +54.779 | +55.895 | 146.7 | 4.8 | 12026.7 | A362 | 12026.7 | 4.69711 | 0.018473 | 145.013
Walkway_Angle | +54.779 | +55.895 | 146.7 | 4.8 | 12026.7 | A338 | 12026.7 | 4.69711 | 0.018473 | 145.013
2 x Walkway_Angle | +54.779 | +55.895 | 146.7 | 4.8 | 12026.7 | A345 | 12026.7 | 4.69711 | 0.018473 | 145.013
2 x Walkway_Angle | +53.787 | +54.903 | 146.7 | 4.8 | 12031 | A342 | 12031 | 4.6988 | 0.0184796 | 145.065
Walkway_Angle | +53.787 | +54.903 | 146.7 | 4.8 | 12031 | A361 | 12031 | 4.6988 | 0.0184796 | 145.065
Walkway_Angle | +53.787 | +54.903 | 146.7 | 4.8 | 12031 | A337 | 12031 | 4.6988 | 0.0184796 | 145.065
Walkway_Angle | +53.787 | +54.903 | 146.7 | 4.8 | 12031 | A360 | 12031 | 4.6988 | 0.0184796 | 145.065
Walkway_Angle | +53.787 | +54.903 | 146.7 | 4.8 | 12031 | A336 | 12031 | 4.6988 | 0.0184796 | 145.065
2 x Walkway_Angle | +53.787 | +54.903 | 146.7 | 4.8 | 12031 | A343 | 12031 | 4.6988 | 0.0184796 | 145.065
2 x Walkway_Angle | +52.795 | +53.911 | 146.7 | 4.8 | 12031 | A340 | 12031 | 4.6988 | 0.0184796 | 145.065
Walkway_Angle | +52.795 | +53.911 | 146.7 | 4.8 | 12031 | A359 | 12031 | 4.6988 | 0.0184796 | 145.065
Walkway_Angle | +52.795 | +53.911 | 146.7 | 4.8 | 12031 | A335 | 12031 | 4.6988 | 0.0184796 | 145.065
Walkway_Angle | +52.795 | +53.911 | 146.7 | 4.8 | 12031 | A358 | 12031 | 4.6988 | 0.0184796 | 145.065
Walkway_Angle | +52.795 | +53.911 | 146.7 | 4.8 | 12031 | A334 | 12031 | 4.6988 | 0.0184796 | 145.065
2 x Walkway_Angle | +52.795 | +53.911 | 146.7 | 4.8 | 12031 | A341 | 12031 | 4.6988 | 0.0184796 | 145.065
2 x Walkway_Angle | +51.215 | +51.926 | 86.8 | 2.8 | 7114.7 | A357 | 7114.71 | 2.7787 | 0.0109282 | 85.7863
Walkway_Angle | +51.215 | +51.926 | 86.8 | 2.8 | 7114.7 | A348 | 7114.69 | 2.7787 | 0.0109282 | 85.7861
Walkway_Angle | +51.215 | +51.926 | 86.8 | 2.8 | 7114.7 | A346 | 7114.69 | 2.7787 | 0.0109282 | 85.7861

# IfcBeam: L150*90*10 (104)
In: Undefined
Description: L150*90*10; Material: STEEL/S355JR
Tekla Common - Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 25.8 m2; Net surface area: 0 m2; Height: 150 mm; Width: 90 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Cleat | +50.932 | +50.992 | 1 | 1.1 | 60 | A677 | 0.0281819 | 0.000138 | 1.0833
14 x Cleat | +50.932 | +50.992 | 1 | 1.1 | 60 | -38AL171 | 0.0281819 | 0.000138 | 1.0833
16 x Cleat | +57.165 | +57.235 | 3 | 1.2 | 70 | A678 | 0.0328789 | 0.000161 | 1.26385
43 x Cleat | +57.165 | +57.235 | 3 | 1.2 | 70 | -38AN131 | 0.0328789 | 0.000161 | 1.26385
29 x Cleat | +57.165 | +57.235 | 3 | 1.2 | 70 | -38AN154 | 0.0328789 | 0.000161 | 1.26385

# IfcBeam: L30*30*5 (30)
In: Undefined
Description: L30*30*5; Material: STEEL/S355JR
Tekla Common - Phase: 6; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 53.1 m2; Height: 30 mm; Width: 30 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x Angle | +52.721 | +52.885 | 3.2 | 0.2 | 1474 | A687 | 0.170554 | 0.00040535 | 3.182
6 x Angle | +52.322 | +52.514 | 3.9 | 0.2 | 1800 | A689 | 0.208274 | 0.000494999 | 3.88575
6 x Angle | +52.845 | +52.967 | 2.1 | 0.1 | 966 | A688 | 0.111774 | 0.00026565 | 2.08535
6 x Angle | +52.598 | +52.761 | 3.2 | 0.2 | 1474 | A687 | 0.170554 | 0.00040535 | 3.182
6 x Angle | +52.474 | +52.638 | 3.2 | 0.2 | 1474 | A687 | 0.170554 | 0.00040535 | 3.182

# IfcBeam: L40*40*3 (282)
In: Undefined
Description: L40*40*3; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 83.7 m2; Height: 40 mm; Width: 40 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
42 x Guard | +50.345 | +52.591 | 9 | 3 | 4.2 | 0 | 0.3 | 2246 | m540 | 2246 | 0.347792 | 0.000510612 | 4.0083
52 x DUMMY | +50.345 | +52.591 | 22 | 2 | 4.2 | 0 | 0.3 | 2246 | m518 | 2246 | 0.347792 | 0.000510612 | 4.0083
6 x DUMMY | +51.327 | +51.367 | 22 | 2 | 1.4 | 0 | 0.1 | 829 | m520 | 829 | 0.12837 | 0.000183285 | 1.43879
3 x DUMMY | +51.327 | +51.367 | 22 | 2 | 1.4 | 0 | 0.1 | 758 | m521 | 758 | 0.117376 | 0.000166884 | 1.31004
61 x DUMMY | +50.345 | +52.239 | 22 | 2 | 3.5 | 0 | 0.3 | 1894 | m519 | 1894 | 0.293285 | 0.0004293 | 3.37
3 x DUMMY | +50.345 | +51.114 | 22 | 2 | 1.4 | 0 | 0.1 | 769 | m512 | 769 | 0.119079 | 0.000170966 | 1.34208
3 x DUMMY | +51.114 | +52.239 | 22 | 2 | 2.1 | 0 | 0.2 | 1125 | m513 | 1125 | 0.174206 | 0.000253201 | 1.98763
12 x DUMMY | +50.345 | +52.591 | 25 | 2 | 4.2 | 0 | 0.3 | 2246 | m518 | 2246 | 0.347792 | 0.000510612 | 4.0083
4 x Guard | +50.345 | +52.591 | 25 | 2 | 4.2 | 0 | 0.3 | 2246 | m540 | 2246 | 0.347792 | 0.000510612 | 4.0083
18 x Guard | +57.323 | +58.317 | 9 | 3 | 1.7 | 0 | 0.2 | 994 | m541 | 994 | 0.153921 | 0.0002214 | 1.73799
11 x Guard | +57.323 | +58.271 | 9 | 3 | 1.7 | 0 | 0.1 | 948 | m542 | 948 | 0.146797 | 0.000210774 | 1.65458
6 x Guard | +58.280 | +58.320 | 9 | 3 | 3.5 | 0.1 | 0.3 | 1821 | m480 | 1821 | 0.281981 | 0.000420651 | 3.30211
Guard | +57.323 | +58.271 | 3 | 3 | 1.7 | 0 | 0.1 | 948 | m542 | 948 | 0.146797 | 0.000210774 | 1.65458
3 x Guard | +56.838 | +57.831 | 12 | 3 | 1.7 | 0 | 0.2 | 992.7 | m541 | 992.722 | 0.153723 | 0.000221105 | 1.73567
21 x Guard | +56.838 | +57.832 | 12 | 3 | 1.7 | 0 | 0.2 | 994 | m541 | 994 | 0.153921 | 0.0002214 | 1.73799
3 x Guard | +58.071 | +58.111 | 5 | 3 | 3 | 0.1 | 0.2 | 1544 | m478 | 1544 | 0.239088 | 0.000356664 | 2.79981
6 x Guard | +56.911 | +56.951 | 5 | 3 | 1.7 | 0 | 0.2 | 939 | m479 | 939 | 0.145404 | 0.000216909 | 1.70274
3 x Guard | +57.770 | +57.810 | 5 | 3 | 3 | 0.1 | 0.2 | 1544 | m478 | 1544 | 0.239088 | 0.000356664 | 2.79982
3 x DUMMY | +51.115 | +52.319 | 11 | 2 | 2.2 | 0 | 0.2 | 1204 | m507 | 1204 | 0.186439 | 0.00027145 | 2.13089
3 x DUMMY | +50.325 | +51.115 | 11 | 2 | 1.4 | 0 | 0.1 | 790 | m506 | 790 | 0.122331 | 0.000175816 | 1.38016
18 x DUMMY | +50.325 | +52.319 | 11 | 2 | 3.7 | 0 | 0.3 | 1994 | m517 | 1994 | 0.30877 | 0.0004524 | 3.55134

# IfcBeam: L50*50*3 (18)
In: Undefined
Description: L50*50*3; Material: STEEL/S355JR
Tekla Common - Phase: 9; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 82.9 m2; Height: 50 mm; Width: 50 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x Rail Angle | +52.152 | +52.202 | 5.1 | 0.3 | 2160 | m966 | 2160 | 0.419021 | 0.000628561 | 4.9342
3 x Rail Angle | +52.152 | +52.202 | 10 | 0.9 | 4256 | m967 | 4255.95 | 0.825617 | 0.00123848 | 9.72208
3 x Rail Angle | +52.152 | +52.202 | 10 | 0.9 | 4256 | m968 | 4256 | 0.825626 | 0.0012385 | 9.72219
3 x Angle | +50.652 | +50.702 | 5.1 | 0.3 | 2160 | A729 | 2160 | 0.419021 | 0.000628561 | 4.9342
3 x Angle | +50.652 | +50.702 | 10 | 0.9 | 4256 | A728 | 4255.95 | 0.825617 | 0.00123848 | 9.72208
3 x Angle | +50.652 | +50.702 | 10 | 0.9 | 4256 | A727 | 4256 | 0.825626 | 0.0012385 | 9.72219

# IfcBeam: L50*50*4 (9)
In: Undefined
Description: L50*50*4; Material: STEEL/S355JR
Tekla Common - Phase: 3; Class: 3
Tekla Quantity - Weight: 4.2 kg; Volume: 0 m3; Area per tons: 63.4 m2; Net surface area: 0.3 m2; Height: 50 mm; Width: 50 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Gross footprint area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x Angle | +58.349 | +58.399 | 0.1 | 1358 | A684 | 0.26344 | 0.000521472 | 4.09356
3 x Angle | +58.324 | +58.374 | 0 | 1338 | A683 | 0.25956 | 0.000513792 | 4.03327
3 x Angle | +58.278 | +58.328 | 0 | 1338 | A683 | 0.25956 | 0.000513792 | 4.03327

# IfcBeam: L50*50*5, DUMMY
In: Undefined
Description: L50*50*5; Material: STEEL/S355JR
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 51.5 m2; Net surface area: 0 m2; Height: 50 mm; Width: 50 mm; Length: 50 mm
Tekla Common - Bottom elevation: +50.657; Top elevation: +50.707; Phase: 11; Class: 2
Pset_BeamCommon - LoadBearing: yes; Reference: A715
BaseQuantities - Length: 50 mm; OuterSurfaceArea: 0.00969956 m2; NetVolume: 0.00002375 m3; NetWeight: 0.186438 kg

# IfcBeam: L50*50*6 (12)
In: Undefined
Description: L50*50*6; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +50.957; Top elevation: +51.327; Phase: 22; Class: 2
Tekla Quantity - Weight: 1.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 43.4 m2; Net surface area: 0.1 m2; Height: 50 mm; Width: 50 mm; Length: 370 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 370 mm; OuterSurfaceArea: 0.0717767 m2; NetVolume: 0.00020868 m3; NetWeight: 1.63814 kg
Name | Reference
6 x DUMMY | A712
6 x DUMMY | A713

# IfcBeam: L60*60*6 (168)
In: Undefined
Description: L60*60*6; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 43 m2; Height: 60 mm; Width: 60 mm
Tekla Common - Class: 99
Pset_BeamCommon - LoadBearing: yes
Name | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Bottom elevation | Top elevation | Phase | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Frame | 3 | 0.1 | 560 | +56.941 | +57.004 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 8 | 0.3 | 1502 | +56.941 | +57.004 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 3 | 0.1 | 560 | +56.716 | +56.780 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
Frame | 3 | 0.1 | 560 | +57.114 | +57.176 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +57.033 | +57.096 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +56.833 | +56.896 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +57.180 | +57.241 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 8 | 0.3 | 1502 | +57.180 | +57.241 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
4 x Frame | 3.8 | 0.2 | 705 | +50.957 | +51.017 | 2 | m645 | 705 | 0.164359 | 0.00048222 | 3.78543
2 x Frame | 8 | 0.3 | 1502 | +57.114 | +57.176 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +57.034 | +57.097 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +56.833 | +56.896 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +56.717 | +56.780 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
Frame | 3 | 0.1 | 560 | +57.115 | +57.177 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 8 | 0.3 | 1502 | +56.576 | +56.640 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +56.429 | +56.493 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +56.269 | +56.334 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +56.105 | +56.170 | 7008 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +55.940 | +56.005 | 7008 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +55.780 | +55.845 | 7008 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 3 | 0.1 | 560 | +56.576 | +56.640 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +56.429 | +56.493 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +56.269 | +56.334 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +56.105 | +56.170 | 7008 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +55.940 | +56.005 | 7008 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +55.780 | +55.845 | 7008 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 8 | 0.3 | 1502 | +51.026 | +51.091 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +55.605 | +55.670 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +55.443 | +55.508 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +55.278 | +55.343 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +55.116 | +55.181 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +54.951 | +55.016 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +54.788 | +54.853 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +54.613 | +54.678 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +54.451 | +54.515 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +54.286 | +54.350 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +54.121 | +54.186 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +53.956 | +54.021 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +53.796 | +53.860 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +53.621 | +53.686 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +53.458 | +53.523 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +53.293 | +53.358 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +53.129 | +53.193 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +52.964 | +53.029 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +52.803 | +52.868 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +52.629 | +52.693 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +52.466 | +52.531 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +52.301 | +52.366 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +52.136 | +52.201 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +51.972 | +52.036 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +51.811 | +51.876 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +51.660 | +51.725 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +51.512 | +51.576 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +51.347 | +51.411 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 8 | 0.3 | 1502 | +51.211 | +51.276 | 2 | m644 | 1502 | 0.350165 | 0.00102737 | 8.06484
2 x Frame | 3 | 0.1 | 560 | +51.026 | +51.091 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +55.606 | +55.670 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +55.443 | +55.508 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +55.278 | +55.343 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +55.116 | +55.181 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +54.951 | +55.016 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +54.788 | +54.853 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +54.613 | +54.678 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +54.451 | +54.515 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +54.286 | +54.351 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +54.121 | +54.186 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +53.956 | +54.021 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +53.796 | +53.861 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +53.621 | +53.686 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +53.458 | +53.523 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +53.294 | +53.358 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +53.129 | +53.193 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +52.964 | +53.029 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +52.803 | +52.868 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +52.629 | +52.693 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +52.466 | +52.531 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +52.301 | +52.366 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +52.136 | +52.201 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +51.972 | +52.036 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +51.811 | +51.876 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +51.660 | +51.725 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +51.512 | +51.576 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +51.347 | +51.411 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687
2 x Frame | 3 | 0.1 | 560 | +51.197 | +51.262 | 2 | m643 | 560.001 | 0.130554 | 0.00038304 | 3.00687

# IfcBeam: L65*50*6 (24)
In: Undefined
Description: L65*50*6; Material: STEEL/S355JR
Tekla Common - Phase: 6; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 43.6 m2; Height: 65 mm; Width: 50 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x HB | +51.915 | +52.055 | 9.1 | 0.3 | 1770.3 | A723 | 1770.32 | 0.398057 | 0.00115779 | 9.08864
3 x HB | +52.006 | +52.150 | 9.2 | 0.3 | 1777.1 | A722 | 1777.1 | 0.39958 | 0.00116222 | 9.1234
3 x HB | +51.667 | +51.836 | 10.5 | 0.5 | 2031.8 | A721 | 2031.84 | 0.456858 | 0.00132882 | 10.4313
3 x HB | +51.787 | +51.959 | 10.5 | 0.5 | 2032.5 | A721 | 2032.52 | 0.457012 | 0.00132927 | 10.4347
3 x HB | +51.419 | +51.588 | 10.5 | 0.5 | 2032 | A721 | 2032.03 | 0.4569 | 0.00132895 | 10.4322
3 x HB | +51.539 | +51.711 | 10.5 | 0.5 | 2032 | A721 | 2031.98 | 0.45689 | 0.00132891 | 10.432
3 x HB | +51.145 | +51.327 | 11.1 | 0.5 | 2155.3 | A720 | 2155.29 | 0.484617 | 0.00140956 | 11.0651
3 x HB | +51.278 | +51.463 | 11.1 | 0.5 | 2149.1 | A719 | 2149.13 | 0.483231 | 0.00140553 | 11.0334

# IfcBeam: L70*70*6 (222)
In: Undefined
Description: L70*70*6; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 42.7 m2; Height: 70 mm; Width: 70 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x DUMMY | +52.102 | +52.172 | 22 | 2 | 24.3 | 0 | 1.1 | 3804.2 | A263 | 3804.2 | 1.03579 | 0.00305858 | 24.0098
2 x DUMMY | +50.652 | +50.722 | 22 | 2 | 24.3 | 0 | 1.1 | 3804.2 | A263 | 3804.2 | 1.03579 | 0.00305858 | 24.0098
2 x DUMMY | +52.102 | +52.172 | 22 | 2 | 24.3 | 0 | 1.1 | 3804.2 | A263 | 3804.19 | 1.03578 | 0.00305857 | 24.0098
2 x DUMMY | +50.652 | +50.722 | 22 | 2 | 24.3 | 0 | 1.1 | 3804.2 | A263 | 3804.19 | 1.03578 | 0.00305857 | 24.0098
2 x DUMMY | +51.257 | +51.327 | 22 | 2 | 4.8 | 0 | 0.2 | 748 | A268 | 748.001 | 0.203661 | 0.000601393 | 4.72093
3 x DUMMY | +51.257 | +51.327 | 22 | 2 | 5.3 | 0 | 0.2 | 832 | m118 | 831.999 | 0.226532 | 0.00064128 | 5.03405
DUMMY | +51.257 | +51.327 | 22 | 2 | 5.3 | 0 | 0.2 | 832 | m117 | 832 | 0.226532 | 0.000641281 | 5.03406
DUMMY | +51.257 | +51.327 | 22 | 2 | 5.3 | 0 | 0.2 | 832 | m119 | 832 | 0.226532 | 0.000668928 | 5.25109
DUMMY | +51.257 | +51.327 | 22 | 2 | 4.8 | 0 | 0.2 | 748 | A268 | 747.996 | 0.20366 | 0.000601389 | 4.7209
DUMMY | +51.257 | +51.327 | 22 | 2 | 5.3 | 0 | 0.2 | 832 | m117 | 832 | 0.226532 | 0.000641328 | 5.03442
DUMMY | +52.102 | +52.172 | 22 | 2 | 15.4 | 0 | 0.6 | 2410 | m120 | 2410.01 | 0.656182 | 0.00188004 | 14.7583
DUMMY | +50.652 | +50.722 | 22 | 2 | 15.4 | 0 | 0.6 | 2410 | A271 | 2410.01 | 0.656182 | 0.00188004 | 14.7583
DUMMY | +52.102 | +52.172 | 22 | 2 | 32.3 | 0 | 1.4 | 5069 | m121 | 5069 | 1.38016 | 0.00407548 | 31.9925
DUMMY | +50.652 | +50.722 | 22 | 2 | 32.3 | 0 | 1.4 | 5069 | A273 | 5069 | 1.38016 | 0.00407548 | 31.9925
2 x DUMMY | +52.102 | +52.172 | 22 | 2 | 32.3 | 0 | 1.4 | 5069 | m122 | 5068.99 | 1.38016 | 0.00407547 | 31.9924
2 x DUMMY | +50.652 | +50.722 | 22 | 2 | 32.3 | 0 | 1.4 | 5069 | A275 | 5068.99 | 1.38016 | 0.00407547 | 31.9924
DUMMY | +52.102 | +52.172 | 22 | 2 | 14.9 | 0 | 0.6 | 2335 | m116 | 2335.01 | 0.635762 | 0.00184854 | 14.5111
DUMMY | +50.652 | +50.722 | 22 | 2 | 14.9 | 0 | 0.6 | 2335 | A269 | 2335.01 | 0.635762 | 0.00184854 | 14.5111
DUMMY | +52.102 | +52.172 | 22 | 2 | 32.3 | 0 | 1.4 | 5070 | m121 | 5070 | 1.38043 | 0.00407628 | 31.9988
DUMMY | +50.652 | +50.722 | 22 | 2 | 32.3 | 0 | 1.4 | 5070 | A273 | 5070 | 1.38043 | 0.00407628 | 31.9988
Angle | +52.102 | +52.172 | 25 | 2 | 15.4 | 0 | 0.6 | 2410 | m126 | 2410.01 | 0.656182 | 0.00188004 | 14.7583
Angle | +50.652 | +50.722 | 25 | 2 | 15.4 | 0 | 0.6 | 2410 | A282 | 2410.01 | 0.656182 | 0.00188004 | 14.7583
DUMMY | +52.102 | +52.172 | 25 | 2 | 32.7 | 0 | 1.4 | 5119 | m123 | 5119 | 1.39377 | 0.00411568 | 32.3081
DUMMY | +50.652 | +50.722 | 25 | 2 | 32.7 | 0 | 1.4 | 5119 | A277 | 5119 | 1.39377 | 0.00411568 | 32.3081
DUMMY | +52.102 | +52.172 | 25 | 2 | 32.7 | 0 | 1.4 | 5119 | m124 | 5118.99 | 1.39377 | 0.00411567 | 32.308
DUMMY | +50.652 | +50.722 | 22 | 2 | 32.7 | 0 | 1.4 | 5119 | A279 | 5118.99 | 1.39377 | 0.00411567 | 32.308
2 x HB | +54.831 | +54.907 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +54.663 | +54.739 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +54.581 | +54.656 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +54.457 | +54.533 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +54.333 | +54.409 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +54.086 | +54.162 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +53.963 | +54.038 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +53.839 | +53.915 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +53.671 | +53.746 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +53.588 | +53.664 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +53.465 | +53.540 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +53.341 | +53.417 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +53.094 | +53.169 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +52.970 | +53.046 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +52.847 | +52.922 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +52.678 | +52.754 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +52.596 | +52.672 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +52.472 | +52.548 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +52.349 | +52.424 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +52.102 | +52.177 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +51.978 | +52.054 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +51.854 | +51.930 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +51.683 | +51.758 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +51.559 | +51.635 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +51.312 | +51.387 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +50.979 | +51.055 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +51.103 | +51.179 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +57.181 | +57.253 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +57.158 | +57.229 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | m92 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +57.108 | +57.180 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +57.050 | +57.123 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +56.912 | +56.986 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +56.832 | +56.906 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +56.744 | +56.818 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +56.681 | +56.755 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +56.613 | +56.688 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +56.546 | +56.620 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +56.434 | +56.509 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +56.316 | +56.391 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
HB | +56.070 | +56.146 | 7008 | 3 | 4.8 | 0 | 0.2 | 750 | A225 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +55.946 | +56.022 | 7008 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +55.823 | +55.898 | 7008 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +55.740 | +55.816 | 7008 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +55.655 | +55.731 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +55.573 | +55.648 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +55.449 | +55.525 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +55.325 | +55.401 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +55.078 | +55.154 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +54.955 | +55.030 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +54.749 | +54.824 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +53.757 | +53.832 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
HB | +52.764 | +52.840 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +51.772 | +51.848 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
2 x HB | +51.188 | +51.264 | 2 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
HB | +56.070 | +56.146 | 7008 | 3 | 4.8 | 0 | 0.2 | 750 | A224 | 749.999 | 0.204205 | 0.000602999 | 4.73354
HB | +52.764 | +52.840 | 2 | 3 | 4.8 | 0 | 0.2 | 752.5 | A224 | 752.5 | 0.204886 | 0.00060501 | 4.74933
3 x Angle | +57.450 | +57.520 | 9 | 99 | 0.9 | 0 | 0 | 154.1 | A230 | 154.095 | 0.0419562 | 0.000123893 | 0.972557
Frame | +58.150 | +58.220 | 9 | 99 | 11 | 0 | 0.5 | 1725 | m86 | 1725 | 0.469674 | 0.0013869 | 10.8872
Angle | +57.450 | +57.520 | 9 | 99 | 0.9 | 0 | 0 | 154.1 | A226 | 154.095 | 0.0419562 | 0.000123893 | 0.972557
6 x Frame | +57.520 | +57.590 | 9 | 3 | 11 | 0 | 0.5 | 1725 | m86 | 1725 | 0.469674 | 0.0013869 | 10.8872
5 x Frame | +58.150 | +58.220 | 9 | 3 | 11 | 0 | 0.5 | 1725 | m86 | 1725 | 0.469674 | 0.0013869 | 10.8872
3 x Angle | +57.720 | +57.790 | 12 | 3 | 15.4 | 0 | 0.6 | 2405 | m81 | 2405 | 0.65482 | 0.00193362 | 15.1789
3 x Angle | +57.720 | +57.790 | 12 | 3 | 15.4 | 0 | 0.6 | 2405 | m80 | 2405 | 0.65482 | 0.00193362 | 15.1789
3 x Angle | +57.145 | +57.215 | 12 | 3 | 15.4 | 0 | 0.6 | 2405 | A222 | 2405 | 0.65482 | 0.00193362 | 15.1789
3 x Angle | +57.145 | +57.215 | 12 | 3 | 15.4 | 0 | 0.6 | 2405 | A220 | 2405 | 0.65482 | 0.00193362 | 15.1789
HB | +57.090 | +57.160 | 3 | 5 | 6.2 | 0.1 | 0.3 | 974.1 | A219 | 974.106 | 0.265224 | 0.000783181 | 6.14797
2 x HB | +57.090 | +57.160 | 3 | 5 | 4.7 | 0.1 | 0.2 | 725.9 | A217 | 725.914 | 0.197648 | 0.000583635 | 4.58153
3 x HB | +57.090 | +57.160 | 3 | 5 | 6.4 | 0.1 | 0.3 | 1010.5 | A216 | 1010.48 | 0.275127 | 0.000812423 | 6.37752
HB | +57.090 | +57.160 | 3 | 5 | 4.7 | 0.1 | 0.2 | 723.2 | A218 | 723.207 | 0.196911 | 0.000581458 | 4.56445
HB | +57.090 | +57.160 | 3 | 5 | 4.4 | 0 | 0.2 | 700.7 | A215 | 700.67 | 0.190774 | 0.000563339 | 4.42221
HB | +57.090 | +57.160 | 3 | 5 | 8.5 | 0.1 | 0.3 | 1340.3 | A207 | 1340.3 | 0.364928 | 0.001063 | 8.34459
HB | +57.090 | +57.160 | 3 | 5 | 8.3 | 0.1 | 0.3 | 1309.8 | A214 | 1309.82 | 0.356629 | 0.00105309 | 8.26677
4 x HB | +57.090 | +57.160 | 3 | 5 | 12.5 | 0.1 | 0.5 | 1958 | A211 | 1957.97 | 0.533104 | 0.0015742 | 12.3575
3 x HB | +57.090 | +57.160 | 3 | 5 | 4.7 | 0.1 | 0.2 | 742.2 | A210 | 742.159 | 0.202071 | 0.000596696 | 4.68406
3 x HB | +57.090 | +57.160 | 3 | 5 | 6.4 | 0.1 | 0.3 | 994.2 | A209 | 994.232 | 0.270704 | 0.000799362 | 6.27499
HB | +57.090 | +57.160 | 3 | 5 | 6.2 | 0.1 | 0.3 | 958.5 | A213 | 958.496 | 0.260974 | 0.000770631 | 6.04945
