Properties of the parts of a building model (IFC2X3), part 4 of 16

# IfcDiscreteAccessory: Beam (329)
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x Beam | UB406*178*54 | +57.320 | +57.722 | 5 | 99 | 98.7 | 0.3 | 27.5 | 2.8 | 402.6 | 177.6 | 1823.9 | m728 | 2.70464 | 0.00689172 | 0.0123401 | 0.0125698
6 x Beam | PC200*75 | +57.107 | +57.307 | 12 | 3 | 14.7 | 0 | 27.8 | 0.3 | 200 | 75 | 600 | m463 | 0.405129 | 0.00309554 | 0.0018234 | 0.00185732
6 x Beam | PC200*75 | +57.107 | +57.307 | 12 | 3 | 17.9 | 0.1 | 27.8 | 0.5 | 200 | 75 | 736 | m464 | 0.496958 | 0.00309554 | 0.0022367 | 0.00227832
9 x Beam | PC200*75 | +56.747 | +57.307 | 12 | 3 | 13.6 | 0 | 27.8 | 0.3 | 200 | 75 | 560 | m462 | 0.37812 | 0.00309554 | 0.00170184 | 0.0017335
15 x Beam | SHS75*75*4.0 | +58.253 | +58.328 | 4 | 3 | 15.4 | 0.1 | 32 | 0.5 | 75 | 75 | 1728.5 | m699 | 0.494804 | 0.00114395 | 0.00196355 | 0.00197729
15 x Beam | SHS75*75*4.0 | +58.253 | +58.328 | 4 | 3 | 15.4 | 0.1 | 32 | 0.5 | 75 | 75 | 1728.5 | m699 | 0.49482 | 0.00114395 | 0.00196362 | 0.00197736
3 x Beam | PC100*50 | +58.426 | +58.527 | 5 | 3 | 18.4 | 0 | 37.9 | 0.6 | 100 | 50 | 1823.9 | m167 | 0.69817 | 0.00128662 | 0.00229082 | 0.00234667
12 x Beam | L40*40*3 | +57.271 | +57.311 | 5 | 99 | 0.1 | 0 | 83.7 | 0 | 40 | 40 | 40 | m495 | 0.00619398 | 0.000235669 | 0.00000924 | 0.00000942675
12 x Beam | L40*40*3 | +57.571 | +57.611 | 5 | 99 | 0.1 | 0 | 83.7 | 0 | 40 | 40 | 40 | m495 | 0.00619398 | 0.000235669 | 0.00000924 | 0.00000942675
6 x Beam | L40*40*3 | +57.847 | +57.903 | 5 | 99 | 0.1 | 0 | 83.7 | 0 | 40 | 40 | 40 | m495 | 0.00619398 | 0.000235669 | 0.00000924 | 0.00000942675
6 x Beam | L40*40*3 | +57.818 | +57.875 | 5 | 99 | 0.1 | 0 | 83.7 | 0 | 40 | 40 | 40 | m495 | 0.00619398 | 0.000235669 | 0.00000924 | 0.00000942675
6 x Beam | L40*40*3 | +58.006 | +58.063 | 5 | 99 | 0.1 | 0 | 83.7 | 0 | 40 | 40 | 40 | m495 | 0.00619398 | 0.000235669 | 0.00000924 | 0.00000942675
6 x Beam | L40*40*3 | +57.978 | +58.034 | 5 | 99 | 0.1 | 0 | 83.7 | 0 | 40 | 40 | 40 | m495 | 0.00619398 | 0.000235669 | 0.00000924 | 0.00000942675
12 x Beam | L40*40*3 | +58.071 | +58.111 | 5 | 99 | 0.1 | 0 | 83.7 | 0 | 40 | 40 | 40 | m495 | 0.00619398 | 0.000235669 | 0.00000924 | 0.00000942675
12 x Beam | L40*40*3 | +58.031 | +58.071 | 5 | 99 | 0.1 | 0 | 83.7 | 0 | 40 | 40 | 40 | m495 | 0.00619398 | 0.000235669 | 0.00000924 | 0.00000942675
3 x Beam | L40*40*3 | +58.071 | +58.111 | 5 | 3 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 695.5 | m494 | 0.107694 | 0.000235669 | 0.00015549 | 0.000163902
3 x Beam | L40*40*3 | +57.051 | +57.091 | 5 | 3 | 3 | 0 | 83.7 | 0.2 | 40 | 40 | 1544 | m489 | 0.239088 | 0.000235669 | 0.000356664 | 0.000363873
6 x Beam | L40*40*3 | +57.054 | +57.807 | 5 | 3 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 753 | m481 | 0.116597 | 0.000235669 | 0.000165722 | 0.000177451
3 x Beam | L40*40*3 | +57.696 | +58.071 | 5 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 375 | m487 | 0.0580638 | 0.000235669 | 0.0000814848 | 0.0000883685
3 x Beam | L40*40*3 | +57.696 | +57.736 | 5 | 3 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 575.1 | m484 | 0.089054 | 0.000235669 | 0.000123608 | 0.000135533
3 x Beam | L40*40*3 | +57.306 | +57.736 | 5 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 430 | m485 | 0.0665836 | 0.000235669 | 0.0000859856 | 0.000101335
3 x Beam | L40*40*3 | +57.306 | +57.346 | 5 | 3 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 575.1 | m486 | 0.0890597 | 0.000235669 | 0.000123611 | 0.000135542
3 x Beam | L40*40*3 | +56.914 | +57.346 | 5 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 432 | m493 | 0.0668999 | 0.000235669 | 0.000093121 | 0.000101816
3 x Beam | L40*40*3 | +57.793 | +58.071 | 5 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 370.5 | m483 | 0.0573761 | 0.000235669 | 0.000083463 | 0.0000873219
3 x Beam | L40*40*3 | +58.031 | +58.071 | 5 | 3 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 682 | m488 | 0.105607 | 0.000235669 | 0.000153918 | 0.000160726
3 x Beam | L40*40*3 | +57.696 | +58.071 | 5 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 375 | m487 | 0.0580638 | 0.000235669 | 0.0000814848 | 0.0000883684
3 x Beam | L40*40*3 | +57.696 | +57.736 | 5 | 3 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 575.1 | m486 | 0.089054 | 0.000235669 | 0.000123608 | 0.000135533
3 x Beam | L40*40*3 | +57.306 | +57.736 | 5 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 430 | m485 | 0.0665838 | 0.000235669 | 0.0000859858 | 0.000101335
3 x Beam | L40*40*3 | +57.306 | +57.346 | 5 | 3 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 575.1 | m484 | 0.0890597 | 0.000235669 | 0.000123611 | 0.000135542
3 x Beam | L40*40*3 | +56.914 | +57.346 | 5 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 432 | m492 | 0.0668998 | 0.000235669 | 0.0000931253 | 0.000101816
3 x Beam | L40*40*3 | +57.793 | +58.071 | 5 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 370.5 | m483 | 0.0573765 | 0.000235669 | 0.0000834634 | 0.0000873224
3 x Beam | L40*40*3 | +58.031 | +58.071 | 5 | 3 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 682 | m482 | 0.105607 | 0.000235669 | 0.000153917 | 0.000160725
3 x Beam | PC100*50 | +58.296 | +58.397 | 5 | 99 | 18.4 | 0 | 37.9 | 0.6 | 100 | 50 | 1823.9 | m167 | 0.69817 | 0.00128662 | 0.00229082 | 0.00234667
3 x Beam | UC203*203*46 | +59.511 | +59.714 | 5 | 3 | 85 | 0.3 | 25.8 | 2.2 | 203.2 | 203.2 | 1844 | m712 | 2.18887 | 0.00587261 | 0.0103221 | 0.0108285
3 x Beam | UC203*203*46 | +57.052 | +57.255 | 5 | 3 | 85 | 0.3 | 25.8 | 2.2 | 203.2 | 203.2 | 1844 | m711 | 2.18887 | 0.00587261 | 0.010682 | 0.0108285
3 x Beam | UC203*203*46 | +56.799 | +57.002 | 5 | 99 | 85 | 0.3 | 25.8 | 2.2 | 203.2 | 203.2 | 1844 | m711 | 2.18887 | 0.00587261 | 0.010682 | 0.0108285
3 x Beam | L40*40*3 | +56.914 | +57.810 | 5 | 3 | 1.7 | 0 | 83.7 | 0.1 | 40 | 40 | 896 | m491 | 0.138745 | 0.000235669 | 0.000201803 | 0.000211159
3 x Beam | L40*40*3 | +56.914 | +57.810 | 5 | 3 | 1.7 | 0 | 83.7 | 0.1 | 40 | 40 | 896 | m490 | 0.138745 | 0.000235669 | 0.000201803 | 0.000211159
2 x Beam | UC152*152*23 | +57.152 | +57.262 | 3 | 99 | 2.4 | 0 | 38.7 | 0.1 | 69.6 | 152.4 | 110 | m279 | 0.0978068 | 0.00292994 | 0.000153356 | 0.000322293
Beam | UC152*152*23 | +57.147 | +57.257 | 3 | 99 | 2.4 | 0 | 38.7 | 0.1 | 96.7 | 152.4 | 110 | m278 | 0.0978068 | 0.00292994 | 0.000171572 | 0.000322293
Beam | UC152*152*23 | +57.147 | +57.257 | 3 | 99 | 2.4 | 0 | 38.7 | 0.1 | 96.7 | 152.4 | 110 | m278 | 0.0978071 | 0.00292994 | 0.000171573 | 0.000322294
Beam | UC152*152*23 | +57.147 | +57.257 | 3 | 99 | 2.4 | 0 | 38.7 | 0.1 | 96.7 | 152.4 | 110 | m278 | 0.097807 | 0.00292994 | 0.000171573 | 0.000322294
Beam | UC152*152*23 | +57.147 | +57.257 | 3 | 99 | 2.4 | 0 | 38.7 | 0.1 | 96.7 | 152.4 | 110 | m278 | 0.0978081 | 0.00292994 | 0.000171573 | 0.000322297
14 x Beam | UC152*152*23 | +57.147 | +57.257 | 3 | 99 | 2.4 | 0 | 38.7 | 0.1 | 96.7 | 152.4 | 110 | m278 | 0.0978068 | 0.00292994 | 0.000171573 | 0.000322293
Beam | PC180*70 | +56.625 | +56.805 | 1 | 3 | 254.4 | 0.8 | 29.3 | 7.6 | 180 | 70 | 12057 | m189 | 7.43487 | 0.0026879 | 0.0317509 | 0.032408
2 x Beam | C140*60 | +52.404 | +52.544 | 9 | 3 | 29.5 | 0.1 | 30.8 | 0.9 | 140 | 60 | 1841.4 | m401 | 0.908038 | 0.00203822 | 0.00354212 | 0.00375317
3 x Beam | UC254*254*73 | +52.290 | +52.544 | 9 | 3 | 134.6 | 0.5 | 20.3 | 2.8 | 254.2 | 254 | 1841.4 | m389 | 2.73521 | 0.0093121 | 0.0165863 | 0.0171473
3 x Beam | UC254*254*73 | +52.290 | +52.544 | 9 | 3 | 134.6 | 0.5 | 20.3 | 2.8 | 254.2 | 254 | 1841.4 | m388 | 2.73521 | 0.0093121 | 0.0165863 | 0.0171473
3 x Beam | UC254*254*73 | +52.290 | +52.544 | 9 | 3 | 240.9 | 0.8 | 20.3 | 5 | 254.2 | 254 | 3295.8 | m387 | 4.89557 | 0.0093121 | 0.0301746 | 0.0306908
6 x Beam | UC254*254*73 | +51.236 | +51.490 | 9 | 3 | 240.9 | 0.8 | 20.3 | 5 | 254.2 | 254 | 3295.8 | m386 | 4.89557 | 0.0093121 | 0.0301746 | 0.0306908
Beam | C140*60 | +52.404 | +52.544 | 9 | 3 | 29.5 | 0.1 | 30.8 | 0.9 | 140 | 60 | 1841.4 | m401 | 0.908038 | 0.00203822 | 0.00354228 | 0.00375317

# IfcDiscreteAccessory: Bracket (10)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Phase: 12
Tekla Quantity - Volume: 0 m3; Net surface area: 0.3 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x Bracket | PL16*230 | +55.175 | +55.775 | 99 | 17.3 | 0 | 17.5 | 230 | 16 | 600 | p678 | 0.30256 | 0.00368 | 0.002208
6 x Bracket | FL12*180 | +56.898 | +56.910 | 3 | 13.8 | 0.1 | 23 | 180 | 12 | 820 | p131 | 0.3192 | 0.00216 | 0.0017712

# IfcDiscreteAccessory: Channel (14)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x Channel | C152*76 | +52.239 | +53.370 | 6 | 20.1 | 32.6 | 0.6 | 152.4 | 76.2 | 1122.2 | m303 | 0.655665 | 0.00228026 | 0.00234198 | 0.0025589
2 x Channel | C152*76 | +52.156 | +53.287 | 6 | 20.1 | 32.6 | 0.6 | 152.4 | 76.2 | 1122.2 | m303 | 0.655665 | 0.00228026 | 0.00234198 | 0.0025589
2 x Channel | C152*76 | +52.033 | +53.164 | 6 | 20.1 | 32.6 | 0.6 | 152.4 | 76.2 | 1122.2 | m304 | 0.655665 | 0.00228026 | 0.00234198 | 0.0025589
2 x Channel | C152*76 | +51.662 | +52.793 | 6 | 20.1 | 32.6 | 0.6 | 152.4 | 76.2 | 1122.2 | m304 | 0.655665 | 0.00228026 | 0.00234198 | 0.0025589
2 x Channel | C152*76 | +51.909 | +53.040 | 6 | 20.1 | 32.6 | 0.6 | 152.4 | 76.2 | 1122.2 | m304 | 0.655665 | 0.00228026 | 0.00234198 | 0.0025589
2 x Channel | PC230*90 | +51.173 | +51.403 | 1 | 7.3 | 24.8 | 0.2 | 230 | 90 | 230 | m17 | 0.182781 | 0.00410191 | 0.00092805 | 0.00094344
2 x Channel | PC230*90 | +50.585 | +50.815 | 1 | 7.3 | 24.8 | 0.2 | 230 | 90 | 230 | m17 | 0.182781 | 0.00410191 | 0.00092805 | 0.00094344

# IfcDiscreteAccessory: Clamping Plate (12)
In: Undefined
Description: FL5*50; Material: STEEL/S355JR
Tekla Common - Phase: 6; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 50 mm; Width: 5 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00025 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
3 x Clamping Plate | +52.960 | +52.969 | 2 | 56.3 | 0.1 | 968 | A821 | 0.10698 | 0.000242
6 x Clamping Plate | +52.798 | +52.947 | 3.5 | 56.2 | 0.2 | 1746 | A817 | 0.19256 | 0.0004365
Clamping Plate | +52.788 | +52.797 | 2 | 56.3 | 0.1 | 968 | A822 | 0.10698 | 0.000242
2 x Clamping Plate | +52.788 | +52.797 | 2 | 56.3 | 0.1 | 968 | A821 | 0.10698 | 0.000242

# IfcDiscreteAccessory: Clamping Strip (6)
In: Undefined
Description: FL5*50; Material: STEEL/S355JR
Tekla Common - Phase: 6; Class: 99
Tekla Quantity - Weight: 2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 56.3 m2; Net surface area: 0.1 m2; Height: 50 mm; Width: 5 mm; Length: 948 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A819
BaseQuantities - NetArea: 0.10478 m2; GrossArea: 0.10478 m2; CrossSectionArea: 0.00025 m2; NetVolume: 0.000237 m3; GrossVolume: 0.000237 m3
Name | Bottom elevation | Top elevation
3 x Clamping Strip | +52.409 | +52.459
3 x Clamping Strip | +53.324 | +53.374

# IfcDiscreteAccessory: Cleat (240)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Weight (kg) | Area per tons (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x Cleat | L60*60*5 | +52.157 | +52.207 | 9 | 0.7 | 51 | 50 | 50 | 130.3 | m737 | 0.0303773 | 0.000582166 | 0.0000603187 | 0.0000758564
3 x Cleat | L60*60*5 | +52.157 | +52.207 | 9 | 0.7 | 51 | 50 | 50 | 130.3 | m736 | 0.0303757 | 0.000582166 | 0.0000603128 | 0.0000758525
3 x Cleat | L50*50*5 | +52.157 | +52.207 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m933 | 0.00969956 | 0.000480255 | 0.0000235 | 0.0000240127
15 x Cleat | L50*50*5 | +52.157 | +52.207 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m932 | 0.00969956 | 0.000480255 | 0.0000234998 | 0.0000240127
3 x Cleat | L60*60*5 | +50.657 | +50.707 | 9 | 0.7 | 51 | 50 | 50 | 130.3 | m737 | 0.0303773 | 0.000582166 | 0.0000603187 | 0.0000758564
3 x Cleat | L60*60*5 | +50.657 | +50.707 | 9 | 0.7 | 51 | 50 | 50 | 130.3 | m736 | 0.0303757 | 0.000582166 | 0.0000603128 | 0.0000758525
3 x Cleat | L50*50*5 | +50.657 | +50.707 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m933 | 0.00969956 | 0.000480255 | 0.0000235 | 0.0000240127
15 x Cleat | L50*50*5 | +50.657 | +50.707 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m932 | 0.00969956 | 0.000480255 | 0.0000234998 | 0.0000240127
66 x Cleat | L40*40*6 | +52.152 | +52.192 | 9 | 0.1 | 44 | 40 | 40 | 40 | m560 | 0.00619398 | 0.000448408 | 0.00001776 | 0.0000179363
3 x Cleat | L60*60*5 | +52.152 | +52.207 | 9 | 0.3 | 51 | 55 | 50.1 | 97 | m735 | 0.022614 | 0.000582166 | 0.0000309146 | 0.0000564705
3 x Cleat | L60*60*5 | +52.157 | +52.207 | 9 | 0.3 | 51 | 50 | 50 | 55 | m738 | 0.0128226 | 0.000582166 | 0.000025869 | 0.0000320198
3 x Cleat | L60*60*5 | +52.157 | +52.207 | 9 | 0.3 | 51 | 50 | 50.1 | 60.1 | m739 | 0.0140021 | 0.000582166 | 0.0000283088 | 0.0000349652
3 x Cleat | L60*60*5 | +52.152 | +52.207 | 9 | 0.3 | 51 | 55 | 50 | 97 | m734 | 0.022614 | 0.000582166 | 0.0000300304 | 0.0000564704
6 x Cleat | L50*50*5 | +52.157 | +52.207 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m933 | 0.00969991 | 0.000480255 | 0.0000235001 | 0.0000240136
6 x Cleat | L50*50*5 | +52.157 | +52.207 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m933 | 0.00969956 | 0.000480255 | 0.0000234969 | 0.0000240127
3 x Cleat | L50*50*5 | +52.157 | +52.207 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m932 | 0.00970052 | 0.000480255 | 0.0000235023 | 0.0000240151
9 x Cleat | L50*50*5 | +52.157 | +52.207 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m933 | 0.00970036 | 0.000480255 | 0.0000235002 | 0.0000240147
3 x Cleat | L50*50*5 | +52.157 | +52.207 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m932 | 0.00969956 | 0.000480255 | 0.0000235 | 0.0000240127
9 x Cleat | L50*50*5 | +52.157 | +52.207 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m933 | 0.00969956 | 0.000480255 | 0.0000234967 | 0.0000240127
3 x Cleat | L50*50*5 | +52.157 | +52.207 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m932 | 0.00970022 | 0.000480255 | 0.0000235022 | 0.0000240144
9 x Cleat | L50*50*5 | +52.157 | +52.207 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m932 | 0.00970007 | 0.000480255 | 0.0000235021 | 0.000024014
3 x Cleat | L60*60*5 | +50.652 | +50.707 | 9 | 0.3 | 51 | 55 | 50.1 | 97 | m735 | 0.022614 | 0.000582166 | 0.0000309146 | 0.0000564705
3 x Cleat | L60*60*5 | +50.657 | +50.707 | 9 | 0.3 | 51 | 50 | 50 | 55 | m738 | 0.0128226 | 0.000582166 | 0.000025869 | 0.0000320198
3 x Cleat | L60*60*5 | +50.657 | +50.707 | 9 | 0.3 | 51 | 50 | 50.1 | 60.1 | m739 | 0.0140021 | 0.000582166 | 0.0000283088 | 0.0000349652
3 x Cleat | L60*60*5 | +50.652 | +50.707 | 9 | 0.3 | 51 | 55 | 50 | 97 | m734 | 0.022614 | 0.000582166 | 0.0000300304 | 0.0000564704
6 x Cleat | L50*50*5 | +50.657 | +50.707 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m933 | 0.00969991 | 0.000480255 | 0.0000235001 | 0.0000240136
6 x Cleat | L50*50*5 | +50.657 | +50.707 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m933 | 0.00969956 | 0.000480255 | 0.0000234969 | 0.0000240127
3 x Cleat | L50*50*5 | +50.657 | +50.707 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m932 | 0.00970052 | 0.000480255 | 0.0000235023 | 0.0000240151
9 x Cleat | L50*50*5 | +50.657 | +50.707 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m933 | 0.00970036 | 0.000480255 | 0.0000235002 | 0.0000240147
3 x Cleat | L50*50*5 | +50.657 | +50.707 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m932 | 0.00969956 | 0.000480255 | 0.0000235 | 0.0000240127
9 x Cleat | L50*50*5 | +50.657 | +50.707 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m933 | 0.00969956 | 0.000480255 | 0.0000234967 | 0.0000240127
3 x Cleat | L50*50*5 | +50.657 | +50.707 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m932 | 0.00970022 | 0.000480255 | 0.0000235022 | 0.0000240144
9 x Cleat | L50*50*5 | +50.657 | +50.707 | 9 | 0.2 | 51.5 | 50 | 50 | 50 | m932 | 0.00970007 | 0.000480255 | 0.0000235021 | 0.000024014
6 x Cleat | L70*70*6 | +52.084 | +52.230 | 6 | 0.9 | 42.7 | 70 | 70 | 140 | m91 | 0.0381184 | 0.000812739 | 0.00011256 | 0.000113783

# IfcDiscreteAccessory: Column (29)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x Column | UB305*165*41 | +56.799 | +58.399 | 5 | 64.5 | 30.8 | 1.9 | 303.8 | 165.1 | 1600.2 | m686 | 1.98508 | 0.00513376 | 0.0078301 | 0.00821503
3 x Column | UB305*165*41 | +56.992 | +59.704 | 5 | 109.3 | 30.8 | 3.4 | 303.8 | 165.1 | 2712 | m685 | 3.36429 | 0.00513376 | 0.0138225 | 0.0139228
6 x Column | UC152*152*23 | +56.745 | +57.270 | 3 | 12.1 | 38.7 | 0.5 | 152.4 | 152.4 | 525 | m277 | 0.466805 | 0.00292994 | 0.00153264 | 0.00153822
12 x Column | UC254*254*73 | +50.262 | +52.544 | 9 | 166.8 | 20.3 | 3.4 | 254.2 | 254 | 2282 | m385 | 3.38967 | 0.0093121 | 0.0208928 | 0.0212502
Column | C152*76 | +52.239 | +53.370 | 6 | 20.1 | 32.6 | 0.6 | 152.4 | 76.2 | 1122.2 | m286 | 0.655665 | 0.00228026 | 0.00234198 | 0.0025589
Column | C152*76 | +52.156 | +53.287 | 6 | 20.1 | 32.6 | 0.6 | 152.4 | 76.2 | 1122.2 | m286 | 0.655665 | 0.00228026 | 0.00234198 | 0.0025589
Column | C152*76 | +52.033 | +53.164 | 6 | 20.1 | 32.6 | 0.6 | 152.4 | 76.2 | 1122.2 | m285 | 0.655665 | 0.00228026 | 0.00234198 | 0.0025589
Column | C152*76 | +51.662 | +52.793 | 6 | 20.1 | 32.6 | 0.6 | 152.4 | 76.2 | 1122.2 | m285 | 0.655665 | 0.00228026 | 0.00234198 | 0.0025589
Column | C152*76 | +51.909 | +53.040 | 6 | 20.1 | 32.6 | 0.6 | 152.4 | 76.2 | 1122.2 | m285 | 0.655665 | 0.00228026 | 0.00234198 | 0.0025589

# IfcDiscreteAccessory: DUMMY (4163)
In: Undefined
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Material | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x DUMMY | PLT8*200 | STEEL/S355JR | +50.937 | +51.137 | 6 | 8 | 2.6 | 0 | 34.4 | 0.1 | 200 | 8 | 210 | A808 | 0.0905605 | 0.0905605 | 0.0016 | 0.000336002 | 0.000336002
3 x DUMMY | PLT20*310 | STEEL/S355JR | +50.242 | +50.262 | 22 | 2 | 30.9 | 0.2 | 14 | 0.3 | 310 | 20 | 635 | DUMMY9999 | 0.4315 | 0.4315 | 0.0062 | 0.003937 | 0.003937
6 x DUMMY | FL25*300 | STEEL/S355JR | +51.006 | +51.217 | 22 | 2 | 8.3 | 0 | 12.8 | 0.1 | 211.4 | 25 | 211.3 | p680 | 0.106927 | 0.0446421 | 0.000625 | 0.00106043 | 0.00106043
6 x DUMMY | FL12*150 | STEEL/S355JR | +50.262 | +50.412 | 22 | 2 | 1.2 | 0 | 25.8 | 0 | 90.7 | 12 | 90.7 | p152 | 0.0299333 | 0.00822649 | 0.000144 | 0.000147921 | 0.000147921
3 x DUMMY | FL25*300 | STEEL/S355JR | +50.981 | +51.006 | 22 | 2 | 16.5 | 0.1 | 12 | 0.2 | 280 | 25 | 280 | p681 | 0.197 | 0.197 | 0.0075 | 0.0021 | 0.0021
3 x DUMMY | PLT12*280 | STEEL/S355JR | +50.969 | +50.981 | 22 | 2 | 12 | 0.1 | 22.7 | 0.3 | 280 | 12 | 453.6 | A744 | 0.271622 | 0.271622 | 0.00336 | 0.0015241 | 0.0015241
8 x DUMMY | FL8*150 | STEEL/S355JR | +52.002 | +52.102 | 22 | 2 | 3.5 | 0 | 34.2 | 0.1 | 150 | 8 | 359.7 | p312 | 0.118593 | 0.118593 | 0.0012 | 0.00044124 | 0.00044124
8 x DUMMY | FL8*150 | STEEL/S355JR | +52.002 | +52.102 | 22 | 2 | 3.5 | 0 | 34.2 | 0.1 | 150 | 8 | 359.7 | p316 | 0.118593 | 0.118593 | 0.0012 | 0.00044124 | 0.00044124
4 x DUMMY | FL8*150 | STEEL/S355JR | +52.002 | +52.102 | 22 | 2 | 3.5 | 0 | 34.2 | 0.1 | 150 | 8 | 359.7 | p313 | 0.118593 | 0.118593 | 0.0012 | 0.00044124 | 0.00044124
5 x DUMMY | PLT12*122.7 | STEEL/S355JR | +52.178 | +52.190 | 22 | 2 | 2.4 | 0 | 24.5 | 0.1 | 122.7 | 12 | 225.8 | p108 | 0.0615536 | 0.0277057 | 0.000144 | 0.000321668 | 0.000321668
6 x DUMMY | PL12*121 | STEEL/S355JR | +51.570 | +51.582 | 22 | 2 | 1.4 | 0 | 25.1 | 0 | 121 | 12 | 141 | p161 | 0.0380084 | 0.0170499 | 0.000144 | 0.000193009 | 0.000193009
6 x DUMMY | PL12*121 | STEEL/S355JR | +51.570 | +51.582 | 22 | 2 | 1.4 | 0 | 25.1 | 0 | 121 | 12 | 141 | p160 | 0.0379562 | 0.0170493 | 0.000144 | 0.000192697 | 0.000192697
6 x DUMMY | PL12*121 | STEEL/S355JR | +50.922 | +50.934 | 22 | 2 | 1.4 | 0 | 25.1 | 0 | 121 | 12 | 141 | p160 | 0.0379571 | 0.01705 | 0.000144 | 0.000192701 | 0.000192701
6 x DUMMY | PL12*121 | STEEL/S355JR | +50.922 | +50.934 | 22 | 2 | 1.4 | 0 | 25.1 | 0 | 121 | 12 | 141 | p160 | 0.0379566 | 0.0170494 | 0.000144 | 0.000192699 | 0.000192699
6 x DUMMY | PL12*121 | STEEL/S355JR | +51.246 | +51.258 | 22 | 2 | 1.4 | 0 | 25.1 | 0 | 121 | 12 | 141 | p160 | 0.0379571 | 0.01705 | 0.000144 | 0.000192701 | 0.000192701
6 x DUMMY | PL12*121 | STEEL/S355JR | +51.246 | +51.258 | 22 | 2 | 1.4 | 0 | 25.1 | 0 | 121 | 12 | 141 | p160 | 0.0379566 | 0.0170494 | 0.000144 | 0.000192699 | 0.000192699
6 x DUMMY | PL12*140.9 | STEEL/S355JR | +50.877 | +51.627 | 22 | 2 | 10 | 0 | 23.5 | 0.2 | 140.9 | 12 | 750 | p164 | 0.232732 | 0.232732 | 0.0016908 | 0.0012681 | 0.0012681
6 x DUMMY | PL12*250 | STEEL/S355JR | +50.877 | +51.627 | 22 | 2 | 17.7 | 0 | 22.6 | 0.3 | 250 | 12 | 750 | p166 | 0.399 | 0.399 | 0.003 | 0.00225 | 0.00225
6 x DUMMY | PL60*50 | STEEL/S355JR | +50.877 | +50.927 | 22 | 2 | 4.2 | 0 | 10.8 | 0 | 50 | 60 | 180 | p686 | 0.0456 | 0.0456 | 0.0108 | 0.00054 | 0.00054
6 x DUMMY | PL60*50 | STEEL/S355JR | +51.577 | +51.627 | 22 | 2 | 4.2 | 0 | 10.8 | 0 | 50 | 60 | 180 | p686 | 0.0456 | 0.0456 | 0.0108 | 0.00054 | 0.00054
6 x DUMMY | PL20*230 | STEEL/S355JR | +50.887 | +51.617 | 22 | 2 | 26.4 | 0 | 14.2 | 0.3 | 230 | 20 | 730 | p669 | 0.3742 | 0.3742 | 0.0046 | 0.003358 | 0.003358
84 x DUMMY | L40*40*6 | STEEL/S355JR | +52.102 | +52.142 | 22 | 2 | 0.1 | 0 | 44 | 0 | 40 | 40 | 40 | m561 | 0.00619398 | 0.00619398 | 0.000448408 | 0.00001776 | 0.0000179363
91 x DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 22 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m935 | 0.00969956 | 0.00969956 | 0.000480255 | 0.00002375 | 0.0000240127
91 x DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 22 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m935 | 0.00969956 | 0.00969956 | 0.000480255 | 0.00002375 | 0.0000240127
34 x DUMMY | FL5*40 | STEEL/S355JR | +51.448 | +51.488 | 22 | 2 | 1.1 | 0 | 57.7 | 0.1 | 40 | 5 | 670 | p570 | 0.0607 | 0.0607 | 0.0002 | 0.000134 | 0.000134
52 x DUMMY | D12 | STEEL/S355JR | +51.231 | +51.393 | 22 | 2 | 0.2 | 0 | 47 | 0 | 12 | 12 | 291.4 | m929 | 0.0108771 | 0.0108771 | 0.000101823 | 0.0000295288 | 0.0000295288
52 x DUMMY | D12 | STEEL/S355JR | +50.631 | +50.793 | 22 | 2 | 0.2 | 0 | 47 | 0 | 12 | 12 | 291.4 | m929 | 0.0108771 | 0.0108771 | 0.000101823 | 0.0000295288 | 0.0000295288
34 x DUMMY | PL3*694 | Undefined/VEM 6320H | +50.370 | +52.566 | 22 | 2 | 0 | 0 |  | 3.1 | 694 | 3 | 2196 | p368 | 3.06539 | 1.52402 | 0.000009 | 0.00457207 | 0.00457207
58 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 744 | m522 | 0.115208 | 0.115208 | 0.000235669 | 0.000171864 | 0.000175338
34 x DUMMY | L40*40*3 | STEEL/S355JR | +52.554 | +52.594 | 22 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 744 | m522 | 0.115208 | 0.115208 | 0.000235669 | 0.000171864 | 0.000175338
2 x DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m936 | 0.019787 | 0.019787 | 0.000480255 | 0.0000484497 | 0.0000489857
2 x DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m936 | 0.019787 | 0.019787 | 0.000480255 | 0.0000484497 | 0.0000489857
2 x DUMMY | FL5*40 | STEEL/S355JR | +51.448 | +51.488 | 22 | 2 | 1.1 | 0 | 57.7 | 0.1 | 40 | 5 | 670 | p570 | 0.0607009 | 0.0607009 | 0.0002 | 0.000134002 | 0.000134002
2 x DUMMY | PL3*694 | Undefined/VEM 6320H | +50.370 | +52.566 | 22 | 2 | 0 | 0 |  | 3.1 | 694 | 3 | 2196 | p368 | 3.06543 | 1.52405 | 0.000009 | 0.00457214 | 0.00457214
2 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 744 | m522 | 0.11521 | 0.11521 | 0.000235669 | 0.000171866 | 0.00017534
2 x DUMMY | L40*40*3 | STEEL/S355JR | +52.554 | +52.594 | 22 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 744 | m522 | 0.11521 | 0.11521 | 0.000235669 | 0.000171866 | 0.00017534
52 x DUMMY | L40*40*3 | STEEL/S355JR | +50.345 | +52.591 | 22 | 2 | 4.2 | 0 | 83.7 | 0.3 | 40 | 40 | 2246 | m518 | 0.347792 | 0.347792 | 0.000235669 | 0.000510612 | 0.000529312
3 x DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102.1 | m936 | 0.019799 | 0.019799 | 0.000480255 | 0.0000484791 | 0.0000490154
3 x DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102.1 | m936 | 0.019799 | 0.019799 | 0.000480255 | 0.0000484791 | 0.0000490154
8 x DUMMY | FL8*150 | STEEL/S355JR | +50.552 | +50.652 | 22 | 2 | 3.5 | 0 | 34.2 | 0.1 | 150 | 8 | 359.7 | p316 | 0.118593 | 0.118593 | 0.0012 | 0.00044124 | 0.00044124
DUMMY | L40*40*6 | STEEL/S355JR | +52.102 | +52.142 | 22 | 2 | 0.1 | 0 | 44 | 0 | 40 | 40 | 40 | m562 | 0.00619398 | 0.00619398 | 0.000448408 | 0.00001776 | 0.0000179363
72 x DUMMY | PLT12*122.7 | STEEL/S355JR | +52.192 | +52.418 | 22 | 2 | 2.6 | 0 | 24.5 | 0.1 | 122.7 | 12 | 225.8 | DUMMY319 | 0.0631144 | 0.0277057 | 0.000144 | 0.000329768 | 0.000329768
40 x DUMMY | PLT12*122.7 | STEEL/S355JR | +50.496 | +50.508 | 22 | 2 | 2.6 | 0 | 24.5 | 0.1 | 122.7 | 12 | 225.8 | DUMMY319 | 0.0631144 | 0.0277057 | 0.000144 | 0.000329768 | 0.000329768
32 x DUMMY | PLT12*122.7 | STEEL/S355JR | +50.738 | +50.750 | 22 | 2 | 2.6 | 0 | 24.5 | 0.1 | 122.7 | 12 | 225.8 | DUMMY319 | 0.0631144 | 0.0277057 | 0.000144 | 0.000329768 | 0.000329768
15 x DUMMY | PLT12*122.7 | STEEL/S355JR | +52.420 | +52.432 | 22 | 2 | 2.4 | 0 | 24.5 | 0.1 | 122.7 | 12 | 225.8 | DUMMY318 | 0.0615536 | 0.0277057 | 0.000144 | 0.000321668 | 0.000321668
15 x DUMMY | PLT12*122.7 | STEEL/S355JR | +52.178 | +52.190 | 22 | 2 | 2.4 | 0 | 24.5 | 0.1 | 122.7 | 12 | 225.8 | DUMMY318 | 0.0615536 | 0.0277057 | 0.000144 | 0.000321668 | 0.000321668
20 x DUMMY | PLT20*270 | STEEL/S355JR | +50.242 | +50.262 | 22 | 2 | 11.4 | 0.1 | 14.6 | 0.2 | 270 | 20 | 270 | DUMMY348 | 0.1674 | 0.1674 | 0.0054 | 0.001458 | 0.001458
5 x DUMMY | PLT12*122.7 | STEEL/S355JR | +52.420 | +52.432 | 22 | 2 | 2.4 | 0 | 24.5 | 0.1 | 122.7 | 12 | 225.8 | p108 | 0.0615536 | 0.0277057 | 0.000144 | 0.000321668 | 0.000321668
8 x DUMMY | PLT12*122.7 | STEEL/S355JR | +50.737 | +50.749 | 22 | 2 | 2.6 | 0 | 24.5 | 0.1 | 122.7 | 12 | 225.8 | DUMMY319 | 0.0631144 | 0.0277057 | 0.000144 | 0.000329768 | 0.000329768
24 x DUMMY | PLT10*160 | STEEL/S355JR | +50.319 | +50.479 | 22 | 2 | 2 | 0 | 28.7 | 0.1 | 160 | 10 | 160 | DUMMY110 | 0.0576 | 0.0576 | 0.0016 | 0.000256 | 0.000256
24 x DUMMY | FL12*150 | STEEL/S355JR | +50.242 | +50.254 | 22 | 2 | 3.1 | 0 | 24.1 | 0.1 | 150 | 12 | 220 | DUMMY122 | 0.07488 | 0.07488 | 0.0018 | 0.000396 | 0.000396
12 x DUMMY | PLT10*95 | STEEL/S355JR | +50.242 | +50.252 | 22 | 2 | 1.6 | 0 | 29.3 | 0 | 95 | 10 | 220 | DUMMY107 | 0.0481 | 0.0481 | 0.00095 | 0.000209 | 0.000209
2 x DUMMY | PLT8*120 | STEEL/S355JR | +52.001 | +52.275 | 22 | 2 | 2 | 0 | 35 | 0.1 | 120 | 8 | 260 | DUMMY326 | 0.06848 | 0.06848 | 0.00208 | 0.0002496 | 0.0002496
6 x DUMMY | PLT8*170 | STEEL/S355JR | +51.469 | +51.715 | 22 | 2 | 2.3 | 0 | 34.5 | 0.1 | 170 | 8 | 220 | DUMMY325 | 0.08104 | 0.08104 | 0.00176 | 0.0002992 | 0.0002992
2 x DUMMY | PLT8*120 | STEEL/S355JR | +52.138 | +52.334 | 22 | 2 | 1.4 | 0 | 35.2 | 0.1 | 120 | 8 | 200 | DUMMY324 | 0.05312 | 0.05312 | 0.0016 | 0.000192 | 0.000192
6 x DUMMY | PLT10*160 | STEEL/S355JR | +51.656 | +51.816 | 22 | 2 | 2.4 | 0 | 28.5 | 0.1 | 160 | 10 | 190 | DUMMY292 | 0.0678 | 0.0678 | 0.0019 | 0.000304 | 0.000304
4 x DUMMY | PLT8*120 | STEEL/S355JR | +51.405 | +51.605 | 22 | 2 | 1.4 | 0 | 35.2 | 0.1 | 120 | 8 | 200 | DUMMY324 | 0.05312 | 0.05312 | 0.0016 | 0.000192 | 0.000192
2 x DUMMY | PLT8*120 | STEEL/S355JR | +52.138 | +52.352 | 22 | 2 | 1.4 | 0 | 35.2 | 0.1 | 120 | 8 | 200 | DUMMY324 | 0.05312 | 0.05312 | 0.0016 | 0.000192 | 0.000192
2 x DUMMY | PLT8*120 | STEEL/S355JR | +51.406 | +51.606 | 22 | 2 | 1.4 | 0 | 35.2 | 0.1 | 120 | 8 | 200 | DUMMY324 | 0.05312 | 0.05312 | 0.0016 | 0.000192 | 0.000192
4 x DUMMY | FL10*100 | STEEL/S355JR | +50.242 | +50.252 | 22 | 2 | 1.6 | 0 | 29.3 | 0 | 100 | 10 | 200 | DUMMY291 | 0.046 | 0.046 | 0.001 | 0.0002 | 0.0002
2 x DUMMY | FL10*100 | STEEL/S355JR | +50.242 | +50.252 | 25 | 2 | 1.6 | 0 | 29.3 | 0 | 100 | 10 | 200 | DUMMY291 | 0.046 | 0.046 | 0.001 | 0.0002 | 0.0002
32 x DUMMY | PLT10*85 | STEEL/S355JR | +50.420 | +50.590 | 22 | 2 | 1.1 | 0 | 29.9 | 0 | 85 | 10 | 170 | DUMMY108 | 0.034 | 0.034 | 0.00085 | 0.0001445 | 0.0001445
30 x DUMMY | PLT10*85 | STEEL/S355JR | +52.047 | +52.217 | 22 | 2 | 1.1 | 0 | 29.9 | 0 | 85 | 10 | 170 | DUMMY108 | 0.034 | 0.034 | 0.00085 | 0.0001445 | 0.0001445
6 x DUMMY | PLT10*172 | STEEL/S355JR | +50.480 | +50.652 | 22 | 2 | 2.3 | 0 | 28.5 | 0.1 | 172 | 10 | 172 | DUMMY109 | 0.066048 | 0.066048 | 0.00172 | 0.00029584 | 0.00029584
DUMMY | PLT10*85 | STEEL/S355JR | +52.047 | +52.217 | 22 | 2 | 1.1 | 0 | 29.9 | 0 | 85 | 10 | 170 | DUMMY288 | 0.034 | 0.034 | 0.00085 | 0.0001445 | 0.0001445
47 x DUMMY | PLT12*63.8 | STEEL/S355JR | +50.830 | +51.017 | 22 | 2 | 0.9 | 0 | 26.6 | 0 | 63.8 | 12 | 187.6 | p107 | 0.0277496 | 0.0119689 | 0.000144 | 0.000132827 | 0.000132827
3 x DUMMY | L50*50*6 | STEEL/S355JR | +50.957 | +51.007 | 22 | 2 | 0.3 | 0 | 43.4 | 0 | 50 | 50 | 95 | m914 | 0.0184294 | 0.0184294 | 0.000569427 | 0.0000535807 | 0.0000540962
3 x DUMMY | L50*50*6 | STEEL/S355JR | +50.957 | +51.007 | 22 | 2 | 0.3 | 0 | 43.4 | 0 | 50 | 50 | 95 | m915 | 0.0184293 | 0.0184293 | 0.000569427 | 0.0000535803 | 0.0000540958
3 x DUMMY | L50*50*6 | STEEL/S355JR | +50.957 | +51.007 | 22 | 2 | 0.3 | 0 | 43.4 | 0 | 50 | 50 | 95 | m915 | 0.0184293 | 0.0184293 | 0.000569427 | 0.0000535804 | 0.0000540959
3 x DUMMY | L50*50*6 | STEEL/S355JR | +50.957 | +51.007 | 22 | 2 | 0.3 | 0 | 43.4 | 0 | 50 | 50 | 95 | m914 | 0.0184292 | 0.0184292 | 0.000569427 | 0.0000535802 | 0.0000540958
34 x DUMMY | L40*40*6 | STEEL/S355JR | +52.032 | +52.072 | 22 | 2 | 0.1 | 0 | 44 | 0 | 40 | 40 | 40 | m561 | 0.00619398 | 0.00619398 | 0.000448408 | 0.00001776 | 0.0000179363
2 x DUMMY | FL6*40 | STEEL/S355JR | +52.032 | +52.072 | 22 | 2 | 0.2 | 0 | 51 | 0 | 40 | 6 | 115 | p652 | 0.0110601 | 0.00460003 | 0.000036 | 0.0000276002 | 0.0000276002
15 x DUMMY | FL6*40 | STEEL/S355JR | +52.032 | +52.072 | 22 | 2 | 0.2 | 0 | 51 | 0 | 40 | 6 | 115 | p652 | 0.01106 | 0.0046 | 0.000036 | 0.0000276 | 0.0000276
64 x DUMMY | L40*40*6 | STEEL/S355JR | +52.132 | +52.172 | 22 | 2 | 0.1 | 0 | 44 | 0 | 40 | 40 | 40 | m561 | 0.00619398 | 0.00619398 | 0.000448408 | 0.00001776 | 0.0000179363
32 x DUMMY | FL6*40 | STEEL/S355JR | +52.132 | +52.172 | 22 | 2 | 0.3 | 0 | 50.4 | 0 | 40 | 6 | 155.5 | p650 | 0.014786 | 0.00622 | 0.000036 | 0.00003732 | 0.00003732
26 x DUMMY | FL6*40 | STEEL/S355JR | +52.102 | +52.142 | 22 | 2 | 0.2 | 0 | 51.8 | 0 | 40 | 6 | 85 | p651 | 0.0082999 | 0.00339996 | 0.000036 | 0.0000203998 | 0.0000203998
20 x DUMMY | L40*40*6 | STEEL/S355JR | +52.102 | +52.142 | 25 | 2 | 0.1 | 0 | 44 | 0 | 40 | 40 | 40 | m561 | 0.00619398 | 0.00619398 | 0.000448408 | 0.00001776 | 0.0000179363
10 x DUMMY | FL6*40 | STEEL/S355JR | +52.102 | +52.142 | 25 | 2 | 0.2 | 0 | 51.8 | 0 | 40 | 6 | 85 | p651 | 0.0082999 | 0.00339996 | 0.000036 | 0.0000203998 | 0.0000203998
3 x DUMMY | C140*60 | STEEL/S355JR | +51.396 | +51.806 | 22 | 2 | 6.6 | 0 | 30.8 | 0.2 | 140 | 60 | 410 | m409 | 0.202181 | 0.202181 | 0.00203822 | 0.000683517 | 0.000835668
3 x DUMMY | C140*60 | STEEL/S355JR | +51.396 | +51.806 | 22 | 2 | 6.6 | 0 | 30.8 | 0.2 | 140 | 60 | 410 | m408 | 0.202181 | 0.202181 | 0.00203822 | 0.000683517 | 0.000835668
6 x DUMMY | PL10*225 | STEEL/S355JR | +51.470 | +51.720 | 22 | 2 | 4.4 | 0 | 27.6 | 0.1 | 225 | 10 | 250 | p256 | 0.121998 | 0.121998 | 0.00225 | 0.000562491 | 0.000562491
2 x DUMMY | PL10*155 | STEEL/S355JR | +51.992 | +52.292 | 22 | 2 | 3.7 | 0 | 28 | 0.1 | 155 | 10 | 300 | p257 | 0.102099 | 0.102099 | 0.00155 | 0.000464994 | 0.000464994
2 x DUMMY | PL10*175 | STEEL/S355JR | +52.127 | +52.452 | 22 | 2 | 4.4 | 0 | 27.8 | 0.1 | 175 | 10 | 325 | p258 | 0.123749 | 0.123749 | 0.00175 | 0.000568743 | 0.000568743
2 x DUMMY | PL10*175 | STEEL/S355JR | +52.118 | +52.443 | 22 | 2 | 4.4 | 0 | 27.8 | 0.1 | 175 | 10 | 325 | p259 | 0.123749 | 0.123749 | 0.00175 | 0.000568743 | 0.000568743
6 x DUMMY | L60*60*6 | STEEL/S355JR | +50.342 | +50.402 | 22 | 2 | 0.3 | 0 | 43 | 0 | 60 | 60 | 55 | m650 | 0.0128223 | 0.0128223 | 0.000690446 | 0.00003762 | 0.0000379745
6 x DUMMY | L60*60*6 | STEEL/S355JR | +50.342 | +50.402 | 22 | 2 | 1.4 | 0 | 43 | 0.1 | 60 | 60 | 252.6 | m651 | 0.058901 | 0.058901 | 0.000690446 | 0.000172813 | 0.000174441
6 x DUMMY | L60*60*6 | STEEL/S355JR | +50.342 | +50.402 | 22 | 2 | 0.3 | 0 | 43 | 0 | 60 | 60 | 55 | m652 | 0.0128223 | 0.0128223 | 0.000690446 | 0.00003762 | 0.0000379745
6 x DUMMY | L60*60*6 | STEEL/S355JR | +50.342 | +50.402 | 22 | 2 | 1.4 | 0 | 43 | 0.1 | 60 | 60 | 252.6 | m653 | 0.058901 | 0.058901 | 0.000690446 | 0.000172813 | 0.000174441
3 x DUMMY | L70*70*6 | STEEL/S355JR | +51.187 | +51.257 | 22 | 2 | 1.2 | 0 | 42.7 | 0.1 | 70 | 70 | 195 | m111 | 0.0530935 | 0.0530935 | 0.000812739 | 0.00015678 | 0.000158484
3 x DUMMY | L70*70*6 | STEEL/S355JR | +51.187 | +51.257 | 22 | 2 | 1.2 | 0 | 42.7 | 0.1 | 70 | 70 | 195 | m112 | 0.0530935 | 0.0530935 | 0.000812739 | 0.00015678 | 0.000158484
6 x DUMMY | L50*50*6 | STEEL/S355JR | +51.207 | +51.257 | 22 | 2 | 0.5 | 0 | 43.4 | 0 | 50 | 50 | 115 | m912 | 0.022309 | 0.022309 | 0.000569427 | 0.0000648601 | 0.0000654842
6 x DUMMY | L50*50*6 | STEEL/S355JR | +51.207 | +51.257 | 22 | 2 | 0.5 | 0 | 43.4 | 0 | 50 | 50 | 115 | m913 | 0.022309 | 0.022309 | 0.000569427 | 0.0000648601 | 0.0000654842
3 x DUMMY | L50*50*5 | STEEL/S355JR | +51.282 | +51.332 | 22 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 60 | m937 | 0.0116399 | 0.0116399 | 0.000480255 | 0.0000254503 | 0.0000288163
DUMMY | L50*50*5 | STEEL/S355JR | +51.282 | +51.332 | 22 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 60 | m938 | 0.0116397 | 0.0116397 | 0.000480255 | 0.0000254488 | 0.0000288158
9 x DUMMY | L50*50*5 | STEEL/S355JR | +51.282 | +51.332 | 22 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m935 | 0.00969955 | 0.00969955 | 0.000480255 | 0.00002375 | 0.0000240127
2 x DUMMY | L50*50*5 | STEEL/S355JR | +51.282 | +51.332 | 22 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m935 | 0.00969947 | 0.00969947 | 0.000480255 | 0.0000237498 | 0.0000240125
9 x DUMMY | D12 | STEEL/S355JR | +51.341 | +51.353 | 22 | 2 | 0.2 | 0 | 47 | 0 | 12 | 12 | 291.4 | m929 | 0.0108771 | 0.0108771 | 0.000101823 | 0.0000295288 | 0.0000295288
9 x DUMMY | D12 | STEEL/S355JR | +51.071 | +51.083 | 22 | 2 | 0.2 | 0 | 47 | 0 | 12 | 12 | 291.4 | m929 | 0.0108771 | 0.0108771 | 0.000101823 | 0.0000295288 | 0.0000295288
4 x DUMMY | PL3*254 | Undefined/VEM 6320H | +51.085 | +51.339 | 22 | 2 | 0 | 0 |  | 0.3 | 254 | 3 | 779 | p378 | 0.40193 | 0.197866 | 0.000009 | 0.000593598 | 0.000593598
18 x DUMMY | L40*40*3 | STEEL/S355JR | +51.060 | +51.364 | 22 | 2 | 0.7 | 0 | 83.7 | 0 | 40 | 40 | 304 | m533 | 0.0470743 | 0.0470743 | 0.000235669 | 0.000070224 | 0.0000716433
3 x DUMMY | PL3*254 | Undefined/VEM 6320H | +51.085 | +51.339 | 22 | 2 | 0 | 0 |  | 0.3 | 254 | 3 | 708 | p377 | 0.365436 | 0.179832 | 0.000009 | 0.000539496 | 0.000539496
6 x DUMMY | L40*40*3 | STEEL/S355JR | +51.057 | +51.097 | 22 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 829 | m520 | 0.12837 | 0.12837 | 0.000235669 | 0.000183285 | 0.000195369
3 x DUMMY | L40*40*3 | STEEL/S355JR | +51.057 | +51.097 | 22 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 758 | m521 | 0.117376 | 0.117376 | 0.000235669 | 0.000166884 | 0.000178637
DUMMY | L50*50*5 | STEEL/S355JR | +51.282 | +51.332 | 22 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 60 | m938 | 0.0116396 | 0.0116396 | 0.000480255 | 0.0000254501 | 0.0000288157
2 x DUMMY | PL3*254 | Undefined/VEM 6320H | +51.085 | +51.339 | 22 | 2 | 0 | 0 |  | 0.3 | 254 | 3 | 779 | p380 | 0.401015 | 0.197866 | 0.000009 | 0.000591834 | 0.000593598
DUMMY | L50*50*5 | STEEL/S355JR | +51.282 | +51.332 | 22 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 60 | m938 | 0.0116396 | 0.0116396 | 0.000480255 | 0.00002545 | 0.0000288156
DUMMY | L50*50*5 | STEEL/S355JR | +51.282 | +51.332 | 22 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m935 | 0.00969972 | 0.00969972 | 0.000480255 | 0.0000237504 | 0.0000240131
3 x DUMMY | FL5*40 | STEEL/S355JR | +51.272 | +51.312 | 22 | 2 | 0.7 | 0 | 57.9 | 0 | 40 | 5 | 379 | p584 | 0.03451 | 0.03451 | 0.0002 | 0.0000758 | 0.0000758
3 x DUMMY | PL3*403 | Undefined/VEM 6320H | +50.370 | +52.214 | 22 | 2 | 0 | 0 |  | 1.4 | 403 | 3 | 1844 | p379 | 1.49976 | 0.74314 | 0.000009 | 0.00222942 | 0.00222942
70 x DUMMY | D12 | STEEL/S355JR | +50.761 | +50.923 | 22 | 2 | 0.2 | 0 | 47 | 0 | 12 | 12 | 291.4 | m929 | 0.0108771 | 0.0108771 | 0.000101823 | 0.0000295288 | 0.0000295288
70 x DUMMY | D12 | STEEL/S355JR | +51.361 | +51.523 | 22 | 2 | 0.2 | 0 | 47 | 0 | 12 | 12 | 291.4 | m929 | 0.0108771 | 0.0108771 | 0.000101823 | 0.0000295288 | 0.0000295288
26 x DUMMY | L50*50*5 | STEEL/S355JR | +50.457 | +50.507 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 100 | m946 | 0.0193993 | 0.0193993 | 0.000480255 | 0.0000457503 | 0.0000480258
26 x DUMMY | L50*50*5 | STEEL/S355JR | +52.087 | +52.137 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 100 | m946 | 0.0193993 | 0.0193993 | 0.000480255 | 0.0000457503 | 0.0000480258
26 x DUMMY | L50*50*5 | STEEL/S355JR | +50.457 | +50.507 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 100 | m945 | 0.0193993 | 0.0193993 | 0.000480255 | 0.0000457504 | 0.0000480258
26 x DUMMY | L50*50*5 | STEEL/S355JR | +52.087 | +52.137 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 100 | m945 | 0.0193993 | 0.0193993 | 0.000480255 | 0.0000457504 | 0.0000480258
6 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 453 | m529 | 0.0701469 | 0.0701469 | 0.000235669 | 0.000104643 | 0.000106758
6 x DUMMY | L40*40*3 | STEEL/S355JR | +52.202 | +52.242 | 22 | 2 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 453 | m529 | 0.0701469 | 0.0701469 | 0.000235669 | 0.000104643 | 0.000106758
61 x DUMMY | L40*40*3 | STEEL/S355JR | +50.345 | +52.239 | 22 | 2 | 3.5 | 0 | 83.7 | 0.3 | 40 | 40 | 1894 | m519 | 0.293285 | 0.293285 | 0.000235669 | 0.0004293 | 0.000446357
3 x DUMMY | PL3*403 | Undefined/VEM 6320H | +50.370 | +51.086 | 22 | 2 | 0 | 0 |  | 0.6 | 403 | 3 | 716 | p375 | 0.58381 | 0.288548 | 0.000009 | 0.000865644 | 0.000865644
3 x DUMMY | L40*40*3 | STEEL/S355JR | +51.074 | +51.114 | 22 | 2 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 459 | m516 | 0.071076 | 0.071076 | 0.000235669 | 0.000100896 | 0.000108172
3 x DUMMY | L40*40*3 | STEEL/S355JR | +50.345 | +51.114 | 22 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 769 | m510 | 0.119079 | 0.119079 | 0.000235669 | 0.000170965 | 0.000181229
3 x DUMMY | PL3*403 | Undefined/VEM 6320H | +51.142 | +52.214 | 22 | 2 | 0 | 0 |  | 0.9 | 403 | 3 | 1072 | p381 | 0.842282 | 0.432016 | 0.000009 | 0.00124925 | 0.00129605
3 x DUMMY | L40*40*3 | STEEL/S355JR | +51.114 | +51.154 | 22 | 2 | 0.3 | 0 | 83.7 | 0 | 40 | 40 | 180 | m505 | 0.0278729 | 0.0278729 | 0.000235669 | 0.000036447 | 0.0000424204
3 x DUMMY | L40*40*3 | STEEL/S355JR | +51.114 | +52.239 | 22 | 2 | 2.1 | 0 | 83.7 | 0.2 | 40 | 40 | 1125 | m511 | 0.174206 | 0.174206 | 0.000235669 | 0.000253202 | 0.000265127
3 x DUMMY | L40*40*3 | STEEL/S355JR | +51.114 | +51.254 | 22 | 2 | 0.3 | 0 | 83.7 | 0 | 40 | 40 | 140 | m526 | 0.0216789 | 0.0216789 | 0.000235669 | 0.0000231 | 0.0000329936
3 x DUMMY | L40*40*3 | STEEL/S355JR | +51.114 | +51.254 | 22 | 2 | 0.3 | 0 | 83.7 | 0 | 40 | 40 | 140 | m527 | 0.0216789 | 0.0216789 | 0.000235669 | 0.0000231 | 0.0000329936
3 x DUMMY | L40*40*3 | STEEL/S355JR | +51.214 | +51.254 | 22 | 2 | 0.3 | 0 | 83.7 | 0 | 40 | 40 | 180 | m525 | 0.0278729 | 0.0278729 | 0.000235669 | 0.000028233 | 0.0000424204
3 x DUMMY | L40*40*3 | STEEL/S355JR | +51.114 | +51.154 | 22 | 2 | 0.3 | 0 | 83.7 | 0 | 40 | 40 | 179 | m505 | 0.0277181 | 0.0277181 | 0.000235669 | 0.000036216 | 0.0000421847
4 x DUMMY | FL5*40 | STEEL/S355JR | +51.272 | +51.312 | 22 | 2 | 0.7 | 0 | 57.9 | 0 | 40 | 5 | 411 | p582 | 0.03739 | 0.03739 | 0.0002 | 0.0000822 | 0.0000822
4 x DUMMY | PL3*435 | Undefined/VEM 6320H | +50.370 | +52.214 | 22 | 2 | 0 | 0 |  | 1.6 | 435 | 3 | 1844 | p374 | 1.61795 | 0.80214 | 0.000009 | 0.00240642 | 0.00240642
4 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 0.9 | 0 | 83.7 | 0.1 | 40 | 40 | 485 | m531 | 0.0751021 | 0.0751021 | 0.000235669 | 0.000112035 | 0.000114299
4 x DUMMY | L40*40*3 | STEEL/S355JR | +52.202 | +52.242 | 22 | 2 | 0.9 | 0 | 83.7 | 0.1 | 40 | 40 | 485 | m531 | 0.0751021 | 0.0751021 | 0.000235669 | 0.000112035 | 0.000114299
2 x DUMMY | FL5*40 | STEEL/S355JR | +51.272 | +51.312 | 22 | 2 | 0.9 | 0 | 57.8 | 0.1 | 40 | 5 | 578 | p583 | 0.05242 | 0.05242 | 0.0002 | 0.0001156 | 0.0001156
2 x DUMMY | PL3*602 | Undefined/VEM 6320H | +50.370 | +52.214 | 22 | 2 | 0 | 0 |  | 2.2 | 602 | 3 | 1844 | p376 | 2.23485 | 1.11009 | 0.000009 | 0.00333026 | 0.00333026
2 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 652 | m532 | 0.100962 | 0.100962 | 0.000235669 | 0.000150612 | 0.000153656
2 x DUMMY | L40*40*3 | STEEL/S355JR | +52.202 | +52.242 | 22 | 2 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 652 | m532 | 0.100962 | 0.100962 | 0.000235669 | 0.000150612 | 0.000153656
24 x DUMMY | FL5*40 | STEEL/S355JR | +51.272 | +51.312 | 22 | 2 | 1.1 | 0 | 57.7 | 0.1 | 40 | 5 | 670 | p570 | 0.0607 | 0.0607 | 0.0002 | 0.000134 | 0.000134
24 x DUMMY | PL3*694 | Undefined/VEM 6320H | +50.370 | +52.214 | 22 | 2 | 0 | 0 |  | 2.6 | 694 | 3 | 1844 | p364 | 2.5747 | 1.27974 | 0.000009 | 0.00383921 | 0.00383921
24 x DUMMY | L40*40*3 | STEEL/S355JR | +52.202 | +52.242 | 22 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 744 | m522 | 0.115208 | 0.115208 | 0.000235669 | 0.000171864 | 0.000175338
2 x DUMMY | FL5*40 | STEEL/S355JR | +51.272 | +51.312 | 22 | 2 | 0.7 | 0 | 57.8 | 0 | 40 | 5 | 523 | p581 | 0.04747 | 0.04747 | 0.0002 | 0.0001046 | 0.0001046
2 x DUMMY | PL3*547 | Undefined/VEM 6320H | +50.370 | +52.214 | 22 | 2 | 0 | 0 |  | 1.9 | 547 | 3 | 1844 | p372 | 2.03168 | 1.00867 | 0.000009 | 0.003026 | 0.003026
2 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 597 | m530 | 0.0924452 | 0.0924452 | 0.000235669 | 0.000137907 | 0.000140694
2 x DUMMY | L40*40*3 | STEEL/S355JR | +52.202 | +52.242 | 22 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 597 | m530 | 0.0924452 | 0.0924452 | 0.000235669 | 0.000137907 | 0.000140694
2 x DUMMY | FL5*40 | STEEL/S355JR | +51.272 | +51.312 | 22 | 2 | 0.7 | 0 | 57.8 | 0 | 40 | 5 | 520 | p571 | 0.0472 | 0.0472 | 0.0002 | 0.000104 | 0.000104
2 x DUMMY | PL3*544 | Undefined/VEM 6320H | +50.370 | +52.214 | 22 | 2 | 0 | 0 |  | 1.9 | 544 | 3 | 1844 | p373 | 2.0206 | 1.00314 | 0.000009 | 0.00300941 | 0.00300941
8 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 594 | m523 | 0.0919807 | 0.0919807 | 0.000235669 | 0.000137214 | 0.000139987
2 x DUMMY | L40*40*3 | STEEL/S355JR | +52.202 | +52.242 | 22 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 594 | m523 | 0.0919807 | 0.0919807 | 0.000235669 | 0.000137214 | 0.000139987
4 x DUMMY | FL5*40 | STEEL/S355JR | +51.448 | +51.488 | 22 | 2 | 2.1 | 0 | 57.5 | 0.1 | 40 | 5 | 1360 | p578 | 0.1228 | 0.1228 | 0.0002 | 0.000272 | 0.000272
2 x DUMMY | PL3*1384 | Undefined/VEM 6320H | +50.370 | +52.566 | 22 | 2 | 0 | 0 |  | 6.1 | 1384 | 3 | 2196 | p382 | 6.10071 | 3.03926 | 0.000009 | 0.0090925 | 0.00911779
4 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 2.7 | 0 | 83.7 | 0.2 | 40 | 40 | 1434 | m528 | 0.222054 | 0.222054 | 0.000235669 | 0.000331254 | 0.000337949
4 x DUMMY | L40*40*3 | STEEL/S355JR | +52.554 | +52.594 | 22 | 2 | 2.7 | 0.1 | 83.7 | 0.2 | 40 | 40 | 1434 | m528 | 0.222054 | 0.222054 | 0.000235669 | 0.000331254 | 0.000337949
DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m939 | 0.0197871 | 0.0197871 | 0.000480255 | 0.0000322827 | 0.000048986
DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m939 | 0.0197871 | 0.0197871 | 0.000480255 | 0.0000322827 | 0.000048986
6 x DUMMY | FL5*40 | STEEL/S355JR | +51.448 | +51.488 | 22 | 2 | 0.7 | 0 | 57.8 | 0 | 40 | 5 | 520 | p571 | 0.0472 | 0.0472 | 0.0002 | 0.000104 | 0.000104
6 x DUMMY | PL3*544 | Undefined/VEM 6320H | +50.370 | +52.566 | 22 | 2 | 0 | 0 |  | 2.4 | 544 | 3 | 2196 | p371 | 2.40569 | 1.19462 | 0.000009 | 0.00358387 | 0.00358387
6 x DUMMY | L40*40*3 | STEEL/S355JR | +52.554 | +52.594 | 22 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 594 | m523 | 0.0919807 | 0.0919807 | 0.000235669 | 0.000137214 | 0.000139987
2 x DUMMY | FL5*40 | STEEL/S355JR | +51.448 | +51.488 | 22 | 2 | 0.7 | 0 | 57.8 | 0 | 40 | 5 | 516 | p580 | 0.046841 | 0.046841 | 0.0002 | 0.000103202 | 0.000103202
2 x DUMMY | PL3*540 | Undefined/VEM 6320H | +50.370 | +52.566 | 22 | 2 | 0 | 0 |  | 2.4 | 540 | 3 | 2196 | p370 | 2.38814 | 1.18586 | 0.000009 | 0.00355759 | 0.00355759
2 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 590 | m535 | 0.0913629 | 0.0913629 | 0.000235669 | 0.000136292 | 0.000139047
2 x DUMMY | L40*40*3 | STEEL/S355JR | +52.554 | +52.594 | 22 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 590 | m535 | 0.0913629 | 0.0913629 | 0.000235669 | 0.000136293 | 0.000139047
DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m936 | 0.0197869 | 0.0197869 | 0.000480255 | 0.0000484495 | 0.0000489855
DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m936 | 0.0197869 | 0.0197869 | 0.000480255 | 0.0000484495 | 0.0000489855
2 x DUMMY | FL5*40 | STEEL/S355JR | +51.448 | +51.488 | 22 | 2 | 0.9 | 0 | 57.7 | 0.1 | 40 | 5 | 620 | p579 | 0.0562009 | 0.0562009 | 0.0002 | 0.000124002 | 0.000124002
2 x DUMMY | PL3*644 | Undefined/VEM 6320H | +50.370 | +52.566 | 22 | 2 | 0 | 0 |  | 2.8 | 644 | 3 | 2196 | p369 | 2.84553 | 1.41425 | 0.000009 | 0.00424274 | 0.00424274
2 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 694 | m534 | 0.107467 | 0.107467 | 0.000235669 | 0.000160316 | 0.000163557
2 x DUMMY | L40*40*3 | STEEL/S355JR | +52.554 | +52.594 | 22 | 2 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 694 | m534 | 0.107467 | 0.107467 | 0.000235669 | 0.000160316 | 0.000163557
2 x DUMMY | PL3*1384 | Undefined/VEM 6320H | +50.370 | +52.566 | 22 | 2 | 0 | 0 |  | 6.1 | 1384 | 3 | 2196 | p383 | 6.06766 | 3.03926 | 0.000009 | 0.00906717 | 0.00911779
2 x DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m940 | 0.0197871 | 0.0197871 | 0.000480255 | 0.0000322826 | 0.0000489859
2 x DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m940 | 0.0197871 | 0.0197871 | 0.000480255 | 0.0000322826 | 0.0000489859
2 x DUMMY | FL5*40 | STEEL/S355JR | +51.448 | +51.488 | 22 | 2 | 0.9 | 0 | 57.7 | 0.1 | 40 | 5 | 620 | p579 | 0.0562 | 0.0562 | 0.0002 | 0.000124 | 0.000124
2 x DUMMY | PL3*644 | Undefined/VEM 6320H | +50.370 | +52.566 | 22 | 2 | 0 | 0 |  | 2.8 | 644 | 3 | 2196 | p369 | 2.84549 | 1.41422 | 0.000009 | 0.00424267 | 0.00424267
2 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 694 | m534 | 0.107466 | 0.107466 | 0.000235669 | 0.000160314 | 0.000163554
2 x DUMMY | L40*40*3 | STEEL/S355JR | +52.554 | +52.594 | 22 | 2 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 694 | m534 | 0.107466 | 0.107466 | 0.000235669 | 0.000160314 | 0.000163554
DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m941 | 0.019787 | 0.019787 | 0.000480255 | 0.0000356347 | 0.0000489858
DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m942 | 0.0197871 | 0.0197871 | 0.000480255 | 0.0000341118 | 0.0000489859
DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 22 | 2 | 0.5 | 0 | 51.5 | 0 | 50 | 50 | 129 | m943 | 0.0250249 | 0.0250249 | 0.000480255 | 0.0000556924 | 0.0000619529
DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 22 | 2 | 0.5 | 0 | 51.5 | 0 | 50 | 50 | 129 | m944 | 0.0250246 | 0.0250246 | 0.000480255 | 0.0000405554 | 0.0000619522
DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m936 | 0.0197871 | 0.0197871 | 0.000480255 | 0.0000484501 | 0.0000489861
DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m936 | 0.0197871 | 0.0197871 | 0.000480255 | 0.0000484501 | 0.0000489861
DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102.1 | m936 | 0.0197989 | 0.0197989 | 0.000480255 | 0.000048479 | 0.0000490153
DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 22 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102.1 | m936 | 0.0197989 | 0.0197989 | 0.000480255 | 0.000048479 | 0.0000490153
20 x DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 25 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m935 | 0.00969956 | 0.00969956 | 0.000480255 | 0.00002375 | 0.0000240127
20 x DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 25 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m935 | 0.00969956 | 0.00969956 | 0.000480255 | 0.00002375 | 0.0000240127
2 x DUMMY | FL5*40 | STEEL/S355JR | +51.448 | +51.488 | 25 | 2 | 2.1 | 0 | 57.5 | 0.1 | 40 | 5 | 1360 | p578 | 0.1228 | 0.1228 | 0.0002 | 0.000272 | 0.000272
12 x DUMMY | D12 | STEEL/S355JR | +51.231 | +51.393 | 25 | 2 | 0.2 | 0 | 47 | 0 | 12 | 12 | 291.4 | m929 | 0.0108771 | 0.0108771 | 0.000101823 | 0.0000295288 | 0.0000295288
DUMMY | PL3*1384 | Undefined/VEM 6320H | +50.370 | +52.566 | 25 | 2 | 0 | 0 |  | 6.1 | 1384 | 3 | 2196 | p382 | 6.10071 | 3.03926 | 0.000009 | 0.0090925 | 0.00911779
2 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 25 | 2 | 2.7 | 0 | 83.7 | 0.2 | 40 | 40 | 1434 | m528 | 0.222054 | 0.222054 | 0.000235669 | 0.000331254 | 0.000337949
2 x DUMMY | L40*40*3 | STEEL/S355JR | +52.554 | +52.594 | 25 | 2 | 2.7 | 0.1 | 83.7 | 0.2 | 40 | 40 | 1434 | m528 | 0.222054 | 0.222054 | 0.000235669 | 0.000331254 | 0.000337949
DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 25 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m939 | 0.0197871 | 0.0197871 | 0.000480255 | 0.0000322827 | 0.0000489859
DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 25 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m939 | 0.0197871 | 0.0197871 | 0.000480255 | 0.0000322827 | 0.0000489859
12 x DUMMY | D12 | STEEL/S355JR | +50.631 | +50.793 | 25 | 2 | 0.2 | 0 | 47 | 0 | 12 | 12 | 291.4 | m929 | 0.0108771 | 0.0108771 | 0.000101823 | 0.0000295288 | 0.0000295288
12 x DUMMY | L40*40*3 | STEEL/S355JR | +50.345 | +52.591 | 25 | 2 | 4.2 | 0 | 83.7 | 0.3 | 40 | 40 | 2246 | m518 | 0.347792 | 0.347792 | 0.000235669 | 0.000510612 | 0.000529312
12 x DUMMY | PL60*50 | STEEL/S355JR | +51.804 | +51.864 | 22 | 2 | 3.9 | 0 | 10.8 | 0 | 50 | 60 | 170 | p687 | 0.0434 | 0.0434 | 0.0102 | 0.00051 | 0.00051
12 x DUMMY | PL50*50 | STEEL/S355JR | +51.932 | +51.982 | 22 | 2 | 0.9 | 0 | 15.3 | 0 | 50 | 50 | 50 | p594 | 0.015 | 0.015 | 0.0025 | 0.000125 | 0.000125
6 x DUMMY | L60*60*4 | STEEL/S355JR | +51.025 | +51.070 | 22 | 2 | 32 | 0 | 63 | 2.1 | 60 | 60 | 8660.8 | m931 | 2.01912 | 2.01912 | 0.000471338 | 0.00401861 | 0.00408216
2 x DUMMY | L70*70*6 | STEEL/S355JR | +52.032 | +52.102 | 22 | 2 | 0.7 | 0 | 42.7 | 0 | 70 | 70 | 130 | m113 | 0.0353957 | 0.0353957 | 0.000812739 | 0.00010452 | 0.000105656
2 x DUMMY | L70*70*6 | STEEL/S355JR | +50.582 | +50.652 | 22 | 2 | 0.7 | 0 | 42.7 | 0 | 70 | 70 | 130 | m113 | 0.0353957 | 0.0353957 | 0.000812739 | 0.00010452 | 0.000105656
2 x DUMMY | L70*70*6 | STEEL/S355JR | +52.032 | +52.102 | 22 | 2 | 0.7 | 0 | 42.7 | 0 | 70 | 70 | 130 | m114 | 0.0353957 | 0.0353957 | 0.000812739 | 0.00010452 | 0.000105656
2 x DUMMY | L70*70*6 | STEEL/S355JR | +50.582 | +50.652 | 22 | 2 | 0.7 | 0 | 42.7 | 0 | 70 | 70 | 130 | m114 | 0.0353957 | 0.0353957 | 0.000812739 | 0.00010452 | 0.000105656
DUMMY | L70*70*6 | STEEL/S355JR | +52.032 | +52.102 | 25 | 2 | 0.7 | 0 | 42.7 | 0 | 70 | 70 | 130 | m113 | 0.0353957 | 0.0353957 | 0.000812739 | 0.00010452 | 0.000105656
DUMMY | L70*70*6 | STEEL/S355JR | +50.582 | +50.652 | 25 | 2 | 0.7 | 0 | 42.7 | 0 | 70 | 70 | 130 | m113 | 0.0353957 | 0.0353957 | 0.000812739 | 0.00010452 | 0.000105656
DUMMY | L70*70*6 | STEEL/S355JR | +52.032 | +52.102 | 25 | 2 | 0.7 | 0 | 42.7 | 0 | 70 | 70 | 130 | m114 | 0.0353957 | 0.0353957 | 0.000812739 | 0.00010452 | 0.000105656
DUMMY | L70*70*6 | STEEL/S355JR | +50.582 | +50.652 | 25 | 2 | 0.7 | 0 | 42.7 | 0 | 70 | 70 | 130 | m114 | 0.0353957 | 0.0353957 | 0.000812739 | 0.00010452 | 0.000105656
2 x DUMMY | FL8*150 | STEEL/S355JR | +50.552 | +50.652 | 22 | 2 | 3.5 | 0 | 34.2 | 0.1 | 150 | 8 | 359.7 | p315 | 0.118593 | 0.118593 | 0.0012 | 0.00044124 | 0.00044124
2 x DUMMY | FL8*150 | STEEL/S355JR | +50.552 | +50.652 | 22 | 2 | 3.5 | 0 | 34.2 | 0.1 | 150 | 8 | 355.4 | p314 | 0.117234 | 0.117234 | 0.0012 | 0.00043608 | 0.00043608
6 x DUMMY | FL8*150 | STEEL/S355JR | +50.552 | +50.652 | 22 | 2 | 3.5 | 0 | 34.2 | 0.1 | 150 | 8 | 359.7 | p312 | 0.118593 | 0.118593 | 0.0012 | 0.00044124 | 0.00044124
2 x DUMMY | FL8*150 | STEEL/S355JR | +50.552 | +50.652 | 22 | 2 | 3.5 | 0 | 34.2 | 0.1 | 150 | 8 | 359.7 | p313 | 0.118593 | 0.118593 | 0.0012 | 0.00044124 | 0.00044124
9 x DUMMY | FL5*40 | STEEL/S355JR | +51.448 | +51.488 | 25 | 2 | 1.1 | 0 | 57.7 | 0.1 | 40 | 5 | 670 | p570 | 0.0607 | 0.0607 | 0.0002 | 0.000134 | 0.000134
9 x DUMMY | PL3*694 | Undefined/VEM 6320H | +50.370 | +52.566 | 25 | 2 | 0 | 0 |  | 3.1 | 694 | 3 | 2196 | p368 | 3.06539 | 1.52402 | 0.000009 | 0.00457207 | 0.00457207
9 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 25 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 744 | m522 | 0.115208 | 0.115208 | 0.000235669 | 0.000171864 | 0.000175338
9 x DUMMY | L40*40*3 | STEEL/S355JR | +52.554 | +52.594 | 25 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 744 | m522 | 0.115208 | 0.115208 | 0.000235669 | 0.000171864 | 0.000175338
DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 25 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m936 | 0.019787 | 0.019787 | 0.000480255 | 0.0000484497 | 0.0000489857
DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 25 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m936 | 0.019787 | 0.019787 | 0.000480255 | 0.0000484497 | 0.0000489857
DUMMY | FL5*40 | STEEL/S355JR | +51.448 | +51.488 | 25 | 2 | 1.1 | 0 | 57.7 | 0.1 | 40 | 5 | 670 | p570 | 0.0607009 | 0.0607009 | 0.0002 | 0.000134002 | 0.000134002
DUMMY | PL3*694 | Undefined/VEM 6320H | +50.370 | +52.566 | 25 | 2 | 0 | 0 |  | 3.1 | 694 | 3 | 2196 | p368 | 3.06543 | 1.52405 | 0.000009 | 0.00457214 | 0.00457214
DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 25 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 744 | m522 | 0.11521 | 0.11521 | 0.000235669 | 0.000171866 | 0.00017534
DUMMY | L40*40*3 | STEEL/S355JR | +52.554 | +52.594 | 25 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 744 | m522 | 0.11521 | 0.11521 | 0.000235669 | 0.000171866 | 0.00017534
DUMMY | PL3*1384 | Undefined/VEM 6320H | +50.370 | +52.566 | 25 | 2 | 0 | 0 |  | 6.1 | 1384 | 3 | 2196 | p383 | 6.06766 | 3.03926 | 0.000009 | 0.00906717 | 0.00911779
DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 25 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m940 | 0.019787 | 0.019787 | 0.000480255 | 0.0000322823 | 0.0000489858
DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 25 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102 | m940 | 0.019787 | 0.019787 | 0.000480255 | 0.0000322823 | 0.0000489858
DUMMY | L50*50*5 | STEEL/S355JR | +50.677 | +50.727 | 25 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102.1 | m936 | 0.019799 | 0.019799 | 0.000480255 | 0.0000484791 | 0.0000490154
DUMMY | L50*50*5 | STEEL/S355JR | +52.127 | +52.177 | 25 | 2 | 0.3 | 0 | 51.5 | 0 | 50 | 50 | 102.1 | m936 | 0.019799 | 0.019799 | 0.000480255 | 0.0000484791 | 0.0000490154
18 x DUMMY | PL12*121 | STEEL/S355JR | +51.915 | +52.178 | 22 | 2 | 2.4 | 0 | 24.5 | 0.1 | 121 | 12 | 262.8 | p162 | 0.0623089 | 0.0318 | 0.000144 | 0.00032355 | 0.00032355
18 x DUMMY | PL12*121 | STEEL/S355JR | +51.915 | +52.178 | 22 | 2 | 2.4 | 0 | 24.5 | 0.1 | 121 | 12 | 262.8 | p162 | 0.0623075 | 0.031799 | 0.000144 | 0.000323542 | 0.000323542
6 x DUMMY | PL12*262 | STEEL/S355JR | +51.915 | +52.177 | 22 | 2 | 16.8 | 0 | 22.6 | 0.3 | 262 | 12 | 680 | p165 | 0.378928 | 0.378928 | 0.003144 | 0.00213792 | 0.00213792
6 x DUMMY | FL12*180 | STEEL/S355JR | +51.903 | +51.915 | 22 | 2 | 11.4 | 0.1 | 23 | 0.3 | 180 | 12 | 680 | p167 | 0.26544 | 0.26544 | 0.00216 | 0.0014688 | 0.0014688
18 x DUMMY | PL12*121 | STEEL/S355JR | +52.026 | +52.178 | 22 | 2 | 1.4 | 0 | 25.3 | 0 | 121 | 12 | 151.8 | p163 | 0.0347541 | 0.0183688 | 0.000144 | 0.000174805 | 0.000174805
18 x DUMMY | PL12*121 | STEEL/S355JR | +52.026 | +52.178 | 22 | 2 | 1.4 | 0 | 25.3 | 0 | 121 | 12 | 151.8 | p163 | 0.0347536 | 0.0183684 | 0.000144 | 0.000174801 | 0.000174801
2 x DUMMY | PL12*152 | STEEL/S355JR | +52.026 | +52.178 | 22 | 2 | 8.8 | 0 | 23.6 | 0.2 | 152 | 12 | 660 | p171 | 0.209225 | 0.220128 | 0.001824 | 0.00112817 | 0.00120384
6 x DUMMY | PL12*140 | STEEL/S355JR | +52.014 | +52.026 | 22 | 2 | 8.8 | 0.1 | 23.5 | 0.2 | 140 | 12 | 660 | p172 | 0.204 | 0.204 | 0.00168 | 0.0011088 | 0.0011088
12 x DUMMY | PL12*122.7 | STEEL/S355JR | +50.922 | +50.934 | 22 | 2 | 2.4 | 0 | 24.5 | 0.1 | 122.7 | 12 | 225.8 | p153 | 0.0615536 | 0.0277057 | 0.000144 | 0.000321668 | 0.000321668
12 x DUMMY | PL12*122.7 | STEEL/S355JR | +51.570 | +51.582 | 22 | 2 | 2.4 | 0 | 24.5 | 0.1 | 122.7 | 12 | 225.8 | p153 | 0.0615536 | 0.0277057 | 0.000144 | 0.000321668 | 0.000321668
12 x DUMMY | PL12*122.7 | STEEL/S355JR | +51.246 | +51.258 | 22 | 2 | 2.4 | 0 | 24.5 | 0.1 | 122.7 | 12 | 225.8 | p153 | 0.0615536 | 0.0277057 | 0.000144 | 0.000321668 | 0.000321668
2 x DUMMY | PL12*152 | STEEL/S355JR | +52.026 | +52.178 | 22 | 2 | 8.8 | 0 | 23.6 | 0.2 | 152 | 12 | 660 | p171 | 0.209216 | 0.220128 | 0.001824 | 0.00112811 | 0.00120384
5 x DUMMY | C140*60 | STEEL/S355JR | +52.292 | +52.432 | 22 | 2 | 29.5 | 0.1 | 30.8 | 0.9 | 140 | 60 | 1841.4 | m410 | 0.908038 | 0.908038 | 0.00203822 | 0.00354508 | 0.00375317
5 x DUMMY | UC254*254*73 | STEEL/S355JR | +52.178 | +52.432 | 22 | 2 | 134.6 | 0.5 | 20.3 | 2.8 | 254.2 | 254 | 1841.4 | m390 | 2.73521 | 2.73521 | 0.0093121 | 0.0165807 | 0.0171473
5 x DUMMY | UC254*254*73 | STEEL/S355JR | +52.178 | +52.432 | 22 | 2 | 134.6 | 0.5 | 20.3 | 2.8 | 254.2 | 254 | 1841.4 | m391 | 2.73521 | 2.73521 | 0.0093121 | 0.0165807 | 0.0171473
10 x DUMMY | UC254*254*73 | STEEL/S355JR | +52.178 | +52.432 | 22 | 2 | 240.9 | 0.8 | 20.3 | 5 | 254.2 | 254 | 3295.8 | m392 | 4.89557 | 4.89557 | 0.0093121 | 0.0301746 | 0.0306908
10 x DUMMY | UC254*254*73 | STEEL/S355JR | +50.496 | +50.750 | 22 | 2 | 240.9 | 0.8 | 20.3 | 5 | 254.2 | 254 | 3295.8 | m392 | 4.89557 | 4.89557 | 0.0093121 | 0.0301746 | 0.0306908
