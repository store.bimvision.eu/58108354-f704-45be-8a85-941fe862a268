Properties of the parts of a building model (IFC2X3), part 3 of 16

# IfcDiscreteAccessory: Angle (1712)
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
6 x Angle | L70*70*6 | +54.690 | +54.756 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m105 | 0.0163367 | 0.000812739 | 0.0000482406 | 0.0000487649
6 x Angle | L70*70*6 | +53.709 | +53.774 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m106 | 0.0163367 | 0.000812739 | 0.0000482406 | 0.0000487649
6 x Angle | L70*70*6 | +53.698 | +53.764 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m106 | 0.0163367 | 0.000812739 | 0.0000482406 | 0.0000487649
6 x Angle | L70*70*6 | +52.717 | +52.782 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m106 | 0.0163367 | 0.000812739 | 0.0000482406 | 0.0000487649
6 x Angle | L70*70*6 | +52.706 | +52.771 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m106 | 0.0163367 | 0.000812739 | 0.0000482406 | 0.0000487649
6 x Angle | L70*70*6 | +51.137 | +51.203 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m106 | 0.0163367 | 0.000812739 | 0.0000482406 | 0.0000487649
6 x Angle | L70*70*6 | +51.724 | +51.790 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m106 | 0.0163367 | 0.000812739 | 0.0000482406 | 0.0000487649
6 x Angle | L70*70*6 | +51.714 | +51.779 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m105 | 0.0163367 | 0.000812739 | 0.0000482406 | 0.0000487649
24 x Angle | L50*50*5 | +58.175 | +58.225 | 9 | 99 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m934 | 0.00969956 | 0.000480255 | 0.00002375 | 0.0000240127
3 x Angle | L70*70*8 | +58.328 | +58.403 | 3 | 99 | 0.7 | 0 | 32.6 | 0 | 70 | 70 | 75 | m354 | 0.0204217 | 0.00106497 | 0.0000632074 | 0.0000798769
3 x Angle | L70*70*8 | +58.328 | +58.403 | 3 | 99 | 0.7 | 0 | 32.6 | 0 | 70 | 70 | 75 | m355 | 0.0204217 | 0.00106497 | 0.0000632074 | 0.0000798769
6 x Angle | L100*75*8 | +58.207 | +58.308 | 3 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546336 | 0.00135032 | 0.000213788 | 0.000216079
3 x Angle | L70*70*8 | +58.302 | +58.377 | 3 | 99 | 0.7 | 0 | 32.6 | 0 | 70 | 70 | 75 | m358 | 0.0204217 | 0.00106497 | 0.0000792042 | 0.0000798769
3 x Angle | L70*70*8 | +58.302 | +58.377 | 3 | 99 | 0.7 | 0 | 32.6 | 0 | 70 | 70 | 75 | m359 | 0.0204217 | 0.00106497 | 0.0000792042 | 0.0000798769
3 x Angle | L70*70*8 | +57.570 | +57.640 | 3 | 99 | 0.5 | 0 | 32.6 | 0 | 70 | 70 | 65 | m357 | 0.0176978 | 0.00106497 | 0.00006864 | 0.0000692229
2 x Angle | L70*70*8 | +57.570 | +57.640 | 3 | 99 | 0.5 | 0 | 32.6 | 0 | 70 | 70 | 65 | m356 | 0.0176978 | 0.00106497 | 0.00006864 | 0.0000692229
3 x Angle | L70*70*8 | +58.255 | +58.330 | 3 | 99 | 0.7 | 0 | 32.6 | 0 | 70 | 70 | 75 | m359 | 0.0204217 | 0.00106497 | 0.0000792042 | 0.0000798769
Angle | L70*70*8 | +58.255 | +58.330 | 3 | 99 | 0.7 | 0 | 32.6 | 0 | 70 | 70 | 75 | m358 | 0.0204217 | 0.00106497 | 0.0000792042 | 0.0000798769
3 x Angle | L70*70*8 | +57.670 | +57.740 | 3 | 99 | 0.5 | 0 | 32.6 | 0 | 70 | 70 | 65 | m357 | 0.0176978 | 0.00106497 | 0.00006864 | 0.0000692229
3 x Angle | L70*70*8 | +57.670 | +57.740 | 3 | 99 | 0.5 | 0 | 32.6 | 0 | 70 | 70 | 65 | m356 | 0.0176978 | 0.00106497 | 0.00006864 | 0.0000692229
3 x Angle | L70*70*6 | +57.595 | +57.665 | 3 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 65 | m104 | 0.0176978 | 0.000812739 | 0.00005226 | 0.000052828
3 x Angle | L70*70*6 | +57.595 | +57.665 | 3 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 65 | m103 | 0.0176978 | 0.000812739 | 0.00005226 | 0.000052828
Angle | L70*70*8 | +57.570 | +57.640 | 3 | 99 | 0.5 | 0 | 32.6 | 0 | 70 | 70 | 65 | m370 | 0.0176978 | 0.00106497 | 0.00006864 | 0.0000692229
Angle | L70*70*8 | +58.255 | +58.330 | 3 | 99 | 0.7 | 0 | 32.6 | 0 | 70 | 70 | 75 | m358 | 0.0204217 | 0.00106497 | 0.0000792042 | 0.0000798768
Angle | L70*70*8 | +58.255 | +58.330 | 3 | 99 | 0.7 | 0 | 32.6 | 0 | 70 | 70 | 75 | m358 | 0.0204217 | 0.00106497 | 0.0000792043 | 0.0000798769
5 x Angle | L100*75*8 | +57.695 | +57.805 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
6 x Angle | L50*50*8 | +56.217 | +56.267 | 7008 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | m723 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +55.887 | +55.937 | 7008 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | m723 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +56.052 | +56.102 | 7008 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | m723 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
3 x Angle | L60*60*8 | +55.773 | +56.780 | 2 | 3 | 85 | 0 | 32.9 | 2.9 | 60 | 60 | 11988.7 | m757 | 2.79495 | 0.000903185 | 0.0107417 | 0.010828
3 x Angle | L60*60*8 | +55.773 | +56.780 | 2 | 3 | 85 | 0 | 32.9 | 2.9 | 60 | 60 | 11988.7 | m756 | 2.79495 | 0.000903185 | 0.0107417 | 0.010828
6 x Angle | L100*75*8 | +57.462 | +57.573 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
6 x Angle | L40*40*6 | +52.102 | +52.142 | 25 | 2 | 0.1 | 0 | 44 | 0 | 40 | 40 | 40 | m563 | 0.00619398 | 0.000448408 | 0.00001776 | 0.0000179363
8 x Angle | L50*50*5 | +50.677 | +50.727 | 25 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m934 | 0.00969956 | 0.000480255 | 0.00002375 | 0.0000240127
8 x Angle | L50*50*5 | +52.127 | +52.177 | 25 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m934 | 0.00969956 | 0.000480255 | 0.00002375 | 0.0000240127
3 x Angle | L40*40*3 | +50.342 | +50.382 | 25 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 594 | m555 | 0.0919807 | 0.000235669 | 0.000137214 | 0.000139987
3 x Angle | L40*40*3 | +52.554 | +52.594 | 25 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 594 | m555 | 0.0919807 | 0.000235669 | 0.000137214 | 0.000139987
4 x Angle | L40*40*3 | +50.345 | +52.591 | 25 | 2 | 4.2 | 0 | 83.7 | 0.3 | 40 | 40 | 2246 | m543 | 0.347792 | 0.000235669 | 0.000510612 | 0.000529312
Angle | L40*40*3 | +50.342 | +50.382 | 25 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 590 | m557 | 0.0913629 | 0.000235669 | 0.000136292 | 0.000139047
Angle | L40*40*3 | +52.554 | +52.594 | 25 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 590 | m557 | 0.0913629 | 0.000235669 | 0.000136293 | 0.000139047
Angle | L100*75*8 | +57.932 | +58.038 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
24 x Angle | L50*50*5 | +57.545 | +57.595 | 9 | 99 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m934 | 0.00969956 | 0.000480255 | 0.00002375 | 0.0000240127
24 x Angle | L40*40*6 | +58.320 | +58.360 | 9 | 99 | 0.1 | 0 | 44 | 0 | 40 | 40 | 40 | m563 | 0.00619398 | 0.000448408 | 0.00001776 | 0.0000179363
24 x Angle | L40*40*6 | +58.150 | +58.190 | 9 | 99 | 0.1 | 0 | 44 | 0 | 40 | 40 | 40 | m563 | 0.00619398 | 0.000448408 | 0.00001776 | 0.0000179363
6 x Angle | L40*40*3 | +57.320 | +57.360 | 9 | 3 | 0.9 | 0 | 83.7 | 0.1 | 40 | 40 | 492 | m558 | 0.076186 | 0.000235669 | 0.000113652 | 0.000115949
6 x Angle | L40*40*3 | +58.280 | +58.320 | 9 | 3 | 0.9 | 0 | 83.7 | 0.1 | 40 | 40 | 492 | m558 | 0.076186 | 0.000235669 | 0.000113652 | 0.000115949
18 x Angle | L40*40*3 | +57.323 | +58.317 | 9 | 3 | 1.7 | 0 | 83.7 | 0.2 | 40 | 40 | 994 | m544 | 0.153921 | 0.000235669 | 0.0002214 | 0.000234255
3 x Angle | L60*60*5 | +57.535 | +57.595 | 9 | 99 | 0.5 | 0 | 51 | 0 | 60 | 53 | 108 | m740 | 0.0251791 | 0.000582166 | 0.0000385472 | 0.0000628757
3 x Angle | L60*60*5 | +57.535 | +57.595 | 9 | 99 | 0.5 | 0 | 51 | 0 | 60 | 53 | 108 | m741 | 0.0251781 | 0.000582166 | 0.0000385443 | 0.0000628734
3 x Angle | L60*60*5 | +58.165 | +58.225 | 9 | 99 | 0.5 | 0 | 51 | 0 | 60 | 53 | 108 | m740 | 0.0251791 | 0.000582166 | 0.0000385472 | 0.0000628757
3 x Angle | L60*60*5 | +58.165 | +58.225 | 9 | 99 | 0.5 | 0 | 51 | 0 | 60 | 53 | 108 | m741 | 0.0251781 | 0.000582166 | 0.0000385443 | 0.0000628734
6 x Angle | L40*40*3 | +57.320 | +57.360 | 9 | 3 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 665 | m550 | 0.102975 | 0.000235669 | 0.000153615 | 0.00015672
6 x Angle | L40*40*3 | +58.280 | +58.320 | 9 | 3 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 665 | m550 | 0.102975 | 0.000235669 | 0.000153615 | 0.00015672
6 x Angle | L40*40*3 | +57.320 | +57.360 | 9 | 3 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 640 | m547 | 0.0991037 | 0.000235669 | 0.00014784 | 0.000150828
6 x Angle | L40*40*3 | +58.280 | +58.320 | 9 | 3 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 640 | m547 | 0.0991038 | 0.000235669 | 0.00014784 | 0.000150828
3 x Angle | L60*60*5 | +57.535 | +57.595 | 9 | 99 | 0.5 | 0 | 51 | 0 | 60 | 53 | 108 | m741 | 0.0251791 | 0.000582166 | 0.0000385473 | 0.0000628757
3 x Angle | L60*60*5 | +57.535 | +57.595 | 9 | 99 | 0.5 | 0 | 51 | 0 | 60 | 53 | 108 | m740 | 0.0251781 | 0.000582166 | 0.0000385442 | 0.0000628734
3 x Angle | L60*60*5 | +58.165 | +58.225 | 9 | 99 | 0.5 | 0 | 51 | 0 | 60 | 53 | 108 | m741 | 0.0251791 | 0.000582166 | 0.0000385473 | 0.0000628757
3 x Angle | L60*60*5 | +58.165 | +58.225 | 9 | 99 | 0.5 | 0 | 51 | 0 | 60 | 53 | 108 | m740 | 0.0251781 | 0.000582166 | 0.0000385442 | 0.0000628734
2 x Angle | L60*60*5 | +57.535 | +57.595 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 63 | m745 | 0.014687 | 0.000582166 | 0.0000322686 | 0.0000366755
2 x Angle | L60*60*5 | +57.535 | +57.595 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 64.1 | m744 | 0.0149424 | 0.000582166 | 0.0000310322 | 0.0000373133
3 x Angle | L60*60*5 | +57.535 | +57.595 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 63 | m747 | 0.0146871 | 0.000582166 | 0.0000322689 | 0.0000366757
3 x Angle | L60*60*5 | +57.535 | +57.595 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 64.1 | m746 | 0.0149425 | 0.000582166 | 0.0000310319 | 0.0000373135
2 x Angle | L60*60*5 | +58.165 | +58.225 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 63 | m745 | 0.014687 | 0.000582166 | 0.0000322686 | 0.0000366755
2 x Angle | L60*60*5 | +58.165 | +58.225 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 64.1 | m744 | 0.0149424 | 0.000582166 | 0.0000310322 | 0.0000373133
3 x Angle | L60*60*5 | +58.165 | +58.225 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 63 | m747 | 0.0146871 | 0.000582166 | 0.0000322689 | 0.0000366757
3 x Angle | L60*60*5 | +58.165 | +58.225 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 64.1 | m746 | 0.0149425 | 0.000582166 | 0.0000310319 | 0.0000373135
3 x Angle | L60*60*5 | +57.535 | +57.595 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 63 | m747 | 0.014687 | 0.000582166 | 0.0000322686 | 0.0000366755
3 x Angle | L60*60*5 | +57.535 | +57.595 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 64.1 | m746 | 0.0149424 | 0.000582166 | 0.0000310322 | 0.0000373133
3 x Angle | L60*60*5 | +57.535 | +57.595 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 63 | m745 | 0.0146871 | 0.000582166 | 0.0000322688 | 0.0000366757
3 x Angle | L60*60*5 | +57.535 | +57.595 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 64.1 | m744 | 0.0149425 | 0.000582166 | 0.0000310319 | 0.0000373135
3 x Angle | L60*60*5 | +58.165 | +58.225 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 63 | m747 | 0.014687 | 0.000582166 | 0.0000322686 | 0.0000366755
3 x Angle | L60*60*5 | +58.165 | +58.225 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 64.1 | m746 | 0.0149424 | 0.000582166 | 0.0000310322 | 0.0000373133
3 x Angle | L60*60*5 | +58.165 | +58.225 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 63 | m745 | 0.0146871 | 0.000582166 | 0.0000322688 | 0.0000366757
3 x Angle | L60*60*5 | +58.165 | +58.225 | 9 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 64.1 | m744 | 0.0149425 | 0.000582166 | 0.0000310319 | 0.0000373135
Angle | L60*60*5 | +57.535 | +57.595 | 3 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 63 | m745 | 0.014687 | 0.000582166 | 0.0000322686 | 0.0000366755
Angle | L60*60*5 | +57.535 | +57.595 | 3 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 64.1 | m744 | 0.0149424 | 0.000582166 | 0.0000310322 | 0.0000373133
Angle | L60*60*5 | +58.165 | +58.225 | 3 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 63 | m745 | 0.014687 | 0.000582166 | 0.0000322686 | 0.0000366755
Angle | L60*60*5 | +58.165 | +58.225 | 3 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 64.1 | m744 | 0.0149424 | 0.000582166 | 0.0000310322 | 0.0000373133
6 x Angle | L50*50*8 | +57.162 | +57.212 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | m723 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +57.090 | +57.140 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | m723 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +57.006 | +57.056 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | m723 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +56.907 | +56.957 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | m723 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +56.795 | +56.846 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | m723 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +56.532 | +56.582 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | m723 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +56.379 | +56.429 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | m723 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
5 x Angle | L50*50*8 | +51.293 | +51.344 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +51.458 | +51.508 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +51.623 | +51.673 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +55.554 | +55.604 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +55.389 | +55.440 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +55.224 | +55.275 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +55.060 | +55.110 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +54.895 | +54.945 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +53.902 | +53.953 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +54.067 | +54.118 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +54.232 | +54.283 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +54.397 | +54.447 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +54.562 | +54.612 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +53.570 | +53.620 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +53.405 | +53.455 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +53.240 | +53.290 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +53.075 | +53.126 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +52.910 | +52.961 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +52.577 | +52.628 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +52.412 | +52.463 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +52.248 | +52.298 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +52.083 | +52.133 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
6 x Angle | L50*50*8 | +51.918 | +51.968 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm134 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
3 x Angle | L60*60*8 | +56.721 | +57.330 | 2 | 3 | 85.1 | 0 | 32.9 | 2.9 | 60 | 60 | 12001 | m759 | 2.79783 | 0.000903185 | 0.0107524 | 0.0108391
3 x Angle | L60*60*8 | +56.721 | +57.330 | 2 | 3 | 85.1 | 0 | 32.9 | 2.9 | 60 | 60 | 12001 | m758 | 2.79783 | 0.000903185 | 0.0107524 | 0.0108391
3 x Angle | L80*80*8 | +57.687 | +58.317 | 2 | 3 | 115.8 | 0 | 32.3 | 3.9 | 80 | 80 | 12027.6 | m881 | 3.7456 | 0.00122675 | 0.0146264 | 0.0147549
3 x Angle | L70*70*10 | +52.313 | +52.383 | 2 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.326 | +52.402 | 2 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.313 | +52.383 | 2 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.326 | +52.402 | 2 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.230 | +52.301 | 2 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.244 | +52.319 | 2 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.230 | +52.301 | 2 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.244 | +52.319 | 2 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
6 x Angle | L100*75*8 | +52.478 | +52.591 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
6 x Angle | L100*75*8 | +52.189 | +52.302 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
2 x Angle | L80*80*8 | +52.180 | +52.843 | 2 | 3 | 68.2 | 0 | 32.3 | 2.3 | 80 | 80 | 7082 | m880 | 2.20545 | 0.00122675 | 0.00861171 | 0.00868786
3 x Angle | L60*60*8 | +51.215 | +51.859 | 2 | 3 | 50.2 | 0 | 32.9 | 1.7 | 60 | 60 | 7084.4 | m760 | 1.6516 | 0.000903185 | 0.00634761 | 0.00639851
Angle | L100*75*8 | +57.695 | +57.805 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546266 | 0.00135032 | 0.00021376 | 0.000216051
6 x Angle | L100*75*8 | +56.778 | +56.891 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
6 x Angle | L100*75*8 | +57.149 | +57.262 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
6 x Angle | L100*75*8 | +55.786 | +55.899 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
6 x Angle | L100*75*8 | +56.486 | +56.599 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
4 x Angle | L100*75*8 | +56.157 | +56.270 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
3 x Angle | L80*80*8 | +55.744 | +56.812 | 2 | 3 | 115.7 | 0 | 32.3 | 3.8 | 80 | 80 | 11999 | m878 | 3.73668 | 0.00122675 | 0.0145908 | 0.0147198
3 x Angle | L60*60*8 | +54.781 | +55.828 | 2 | 3 | 85 | 0 | 32.9 | 2.9 | 60 | 60 | 11979 | m762 | 2.7927 | 0.000903185 | 0.0107332 | 0.0108193
3 x Angle | L60*60*8 | +54.781 | +55.828 | 2 | 3 | 85 | 0 | 32.9 | 2.9 | 60 | 60 | 11979 | m761 | 2.7927 | 0.000903185 | 0.0107332 | 0.0108193
6 x Angle | L100*75*8 | +54.794 | +54.906 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
6 x Angle | L100*75*8 | +55.494 | +55.607 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
6 x Angle | L100*75*8 | +55.164 | +55.277 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
3 x Angle | L80*80*8 | +54.752 | +55.820 | 2 | 3 | 115.7 | 0 | 32.3 | 3.8 | 80 | 80 | 11999 | m877 | 3.73668 | 0.00122675 | 0.0145908 | 0.0147198
3 x Angle | L60*60*8 | +53.789 | +54.836 | 2 | 3 | 85 | 0 | 32.9 | 2.9 | 60 | 60 | 11979 | m762 | 2.79269 | 0.000903185 | 0.0107332 | 0.0108192
3 x Angle | L60*60*8 | +53.789 | +54.836 | 2 | 3 | 85 | 0 | 32.9 | 2.9 | 60 | 60 | 11979 | m761 | 2.79269 | 0.000903185 | 0.0107332 | 0.0108192
6 x Angle | L100*75*8 | +53.801 | +53.914 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
6 x Angle | L100*75*8 | +54.502 | +54.615 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
6 x Angle | L100*75*8 | +54.172 | +54.285 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
3 x Angle | L80*80*8 | +53.759 | +54.828 | 2 | 3 | 115.7 | 0 | 32.3 | 3.8 | 80 | 80 | 11999 | m876 | 3.73667 | 0.00122675 | 0.0145908 | 0.0147198
3 x Angle | L60*60*8 | +52.796 | +53.843 | 2 | 3 | 85 | 0 | 32.9 | 2.9 | 60 | 60 | 11979 | m764 | 2.79268 | 0.000903185 | 0.0107331 | 0.0108192
3 x Angle | L60*60*8 | +52.796 | +53.843 | 2 | 3 | 85 | 0 | 32.9 | 2.9 | 60 | 60 | 11979 | m763 | 2.79268 | 0.000903185 | 0.0107331 | 0.0108192
6 x Angle | L100*75*8 | +52.809 | +52.922 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
6 x Angle | L100*75*8 | +53.509 | +53.622 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
6 x Angle | L100*75*8 | +53.180 | +53.293 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
3 x Angle | L80*80*8 | +52.767 | +53.835 | 2 | 3 | 115.7 | 0 | 32.3 | 3.8 | 80 | 80 | 11999 | m875 | 3.73667 | 0.00122675 | 0.0145908 | 0.0147198
3 x Angle | L60*60*8 | +51.804 | +52.851 | 2 | 3 | 85 | 0 | 32.9 | 2.9 | 60 | 60 | 11979 | m762 | 2.79268 | 0.000903185 | 0.0107331 | 0.0108192
3 x Angle | L60*60*8 | +51.804 | +52.851 | 2 | 3 | 85 | 0 | 32.9 | 2.9 | 60 | 60 | 11979 | m761 | 2.79267 | 0.000903185 | 0.0107331 | 0.0108192
3 x Angle | L70*70*10 | +52.355 | +52.431 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.437 | +52.513 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.456 | +52.526 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.373 | +52.444 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.231 | +52.307 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.107 | +52.177 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.250 | +52.320 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.120 | +52.196 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.108 | +52.183 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.983 | +52.054 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.126 | +52.197 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.997 | +52.072 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.437 | +52.513 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.456 | +52.526 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.355 | +52.431 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.373 | +52.444 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.861 | +51.936 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.736 | +51.806 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.879 | +51.949 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.749 | +51.825 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.984 | +52.060 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.859 | +51.930 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.002 | +52.073 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.873 | +51.949 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.861 | +51.936 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.736 | +51.806 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.879 | +51.949 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.749 | +51.825 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.984 | +52.060 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.859 | +51.930 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.002 | +52.073 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.873 | +51.949 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.108 | +52.183 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.983 | +52.054 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.126 | +52.197 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +51.997 | +52.072 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.231 | +52.307 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.107 | +52.177 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
6 x Angle | L50*50*4 | +51.877 | +52.037 | 9 | 99 | 0.5 | 0 | 63.4 | 0 | 50 | 44 | 160 | m772 | 0.0310386 | 0.000389809 | 0.0000576 | 0.0000623694
3 x Angle | L50*50*4 | +51.899 | +52.049 | 9 | 99 | 0.5 | 0 | 63.4 | 0 | 50 | 44 | 150 | m773 | 0.0290987 | 0.000389809 | 0.000054 | 0.0000584713
6 x Angle | L50*50*4 | +51.630 | +51.790 | 9 | 99 | 0.5 | 0 | 63.4 | 0 | 50 | 44 | 160 | m772 | 0.0310386 | 0.000389809 | 0.0000576 | 0.0000623694
3 x Angle | L50*50*4 | +51.652 | +51.802 | 9 | 99 | 0.5 | 0 | 63.4 | 0 | 50 | 44 | 150 | m773 | 0.0290987 | 0.000389809 | 0.000054 | 0.0000584713
6 x Angle | L50*50*4 | +51.382 | +51.542 | 9 | 99 | 0.5 | 0 | 63.4 | 0 | 50 | 44 | 160 | m772 | 0.0310386 | 0.000389809 | 0.0000576 | 0.0000623694
3 x Angle | L50*50*4 | +51.404 | +51.554 | 9 | 99 | 0.5 | 0 | 63.4 | 0 | 50 | 44 | 150 | m773 | 0.0290987 | 0.000389809 | 0.000054 | 0.0000584713
3 x Angle | L60*60*6 | +52.911 | +52.971 | 6 | 99 | 2.8 | 0 | 43 | 0.1 | 60 | 60 | 517.5 | m659 | 0.120645 | 0.000690446 | 0.000334227 | 0.000357303
3 x Angle | L50*50*4 | +51.899 | +52.049 | 9 | 99 | 0.5 | 0 | 63.4 | 0 | 50 | 44 | 150 | m771 | 0.0290987 | 0.000389809 | 0.000054 | 0.0000584713
3 x Angle | L60*60*6 | +52.911 | +52.972 | 6 | 99 | 3.5 | 0 | 43 | 0.2 | 60 | 60 | 640 | m660 | 0.149205 | 0.000690446 | 0.00043776 | 0.000441885
3 x Angle | L60*60*6 | +52.912 | +52.972 | 6 | 99 | 2.8 | 0 | 43 | 0.1 | 60 | 60 | 517.5 | m658 | 0.120645 | 0.000690446 | 0.000334227 | 0.000357303
3 x Angle | L70*70*10 | +52.250 | +52.320 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m893 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L70*70*10 | +52.120 | +52.196 | 6 | 99 | 0.7 | 0 | 26.4 | 0 | 70 | 70 | 70 | m892 | 0.0190592 | 0.0013121 | 0.000091 | 0.0000918471
3 x Angle | L50*50*4 | +51.652 | +51.802 | 9 | 99 | 0.5 | 0 | 63.4 | 0 | 50 | 44 | 150 | m771 | 0.0290987 | 0.000389809 | 0.000054 | 0.0000584713
3 x Angle | L50*50*4 | +51.404 | +51.554 | 9 | 99 | 0.5 | 0 | 63.4 | 0 | 50 | 44 | 150 | m771 | 0.0290987 | 0.000389809 | 0.000054 | 0.0000584713
Angle | L50*50*8 | +51.293 | +51.344 | 2 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 60 | -38ALm288 | 0.0116395 | 0.000741401 | 0.00004416 | 0.0000444841
Angle | L80*80*8 | +52.180 | +52.843 | 2 | 3 | 68.2 | 0 | 32.3 | 2.3 | 80 | 80 | 7082 | m880 | 2.20545 | 0.00122675 | 0.00861171 | 0.00868785
2 x Angle | L100*75*8 | +56.157 | +56.269 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
36 x Angle | L40*40*6 | +57.720 | +57.760 | 12 | 99 | 0.1 | 0 | 44 | 0 | 40 | 40 | 40 | m563 | 0.00619398 | 0.000448408 | 0.00001776 | 0.0000179363
6 x Angle | L40*40*3 | +58.280 | +58.320 | 9 | 99 | 0.1 | 0 | 83.7 | 0 | 40 | 40 | 78 | m503 | 0.0120783 | 0.000235669 | 0.000018018 | 0.0000183822
Angle | L40*40*3 | +58.320 | +58.360 | 9 | 99 | 0.2 | 0 | 83.7 | 0 | 40 | 40 | 102 | m499 | 0.0157947 | 0.000235669 | 0.000023562 | 0.0000240382
6 x Angle | L40*40*3 | +58.280 | +58.320 | 9 | 99 | 0.1 | 0 | 83.7 | 0 | 30 | 40 | 78 | m504 | 0.0120783 | 0.000235669 | 0.000015678 | 0.0000183822
Angle | L40*40*3 | +58.320 | +58.360 | 9 | 99 | 0.2 | 0 | 83.7 | 0 | 40 | 40 | 102 | m500 | 0.0157947 | 0.000235669 | 0.000023562 | 0.0000240382
2 x Angle | L40*40*3 | +58.320 | +58.360 | 9 | 99 | 0.2 | 0 | 83.7 | 0 | 40 | 40 | 112 | m501 | 0.0173432 | 0.000235669 | 0.000025872 | 0.0000263949
2 x Angle | L40*40*3 | +58.320 | +58.360 | 9 | 99 | 0.2 | 0 | 83.7 | 0 | 40 | 40 | 112 | m502 | 0.0173432 | 0.000235669 | 0.000025872 | 0.0000263949
6 x Angle | L70*70*6 | +57.520 | +57.590 | 9 | 99 | 2.7 | 0 | 42.7 | 0.1 | 70 | 70 | 420 | m87 | 0.114355 | 0.000812739 | 0.00033768 | 0.00034135
3 x Angle | L70*70*6 | +57.520 | +57.590 | 9 | 99 | 0.5 | 0 | 42.7 | 0 | 55 | 70 | 84.1 | m96 | 0.022897 | 0.000812739 | 0.0000600441 | 0.0000683475
3 x Angle | L70*70*6 | +57.450 | +57.520 | 9 | 99 | 0.9 | 0 | 42.7 | 0 | 70 | 70 | 154.1 | m102 | 0.0419562 | 0.000812739 | 0.000123893 | 0.000125239
3 x Angle | L70*70*6 | +57.520 | +57.590 | 9 | 99 | 2.1 | 0 | 42.7 | 0.1 | 70 | 70 | 331.9 | m125 | 0.0903698 | 0.000812739 | 0.000213093 | 0.000269754
6 x Angle | L70*70*6 | +57.520 | +57.590 | 9 | 99 | 2.1 | 0 | 42.7 | 0.1 | 70 | 70 | 331.9 | m125 | 0.0903701 | 0.000812739 | 0.000213094 | 0.000269755
6 x Angle | L70*70*6 | +57.520 | +57.590 | 9 | 99 | 2.8 | 0 | 42.7 | 0.1 | 70 | 70 | 445 | m88 | 0.121163 | 0.000812739 | 0.000357781 | 0.00036167
6 x Angle | L70*70*6 | +58.150 | +58.220 | 9 | 99 | 0.5 | 0 | 42.7 | 0 | 55 | 70 | 84.1 | m96 | 0.022897 | 0.000812739 | 0.0000600441 | 0.0000683475
2 x Angle | L70*70*6 | +58.080 | +58.150 | 9 | 99 | 0.9 | 0 | 42.7 | 0 | 70 | 70 | 154.1 | m102 | 0.0419562 | 0.000812739 | 0.000123893 | 0.000125239
6 x Angle | L70*70*6 | +58.150 | +58.220 | 9 | 99 | 0.5 | 0 | 42.7 | 0 | 55 | 70 | 84.1 | m98 | 0.022897 | 0.000812739 | 0.0000600441 | 0.0000683475
3 x Angle | L70*70*6 | +58.080 | +58.150 | 9 | 99 | 0.9 | 0 | 42.7 | 0 | 70 | 70 | 154.1 | m100 | 0.0419562 | 0.000812739 | 0.000123893 | 0.000125239
4 x Angle | L70*70*8 | +58.337 | +58.407 | 3 | 99 | 0.7 | 0 | 32.6 | 0 | 55 | 70 | 70 | m322 | 0.0190592 | 0.00106497 | 0.00006552 | 0.0000745478
3 x Angle | L70*70*6 | +58.150 | +58.220 | 9 | 99 | 2.1 | 0 | 42.7 | 0.1 | 70 | 70 | 331.9 | m125 | 0.0903698 | 0.000812739 | 0.000213093 | 0.000269754
6 x Angle | L70*70*6 | +58.150 | +58.220 | 9 | 99 | 2.1 | 0 | 42.7 | 0.1 | 70 | 70 | 331.9 | m125 | 0.0903701 | 0.000812739 | 0.000213094 | 0.000269755
11 x Angle | L40*40*3 | +57.320 | +57.360 | 9 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 331 | m548 | 0.0512553 | 0.000235669 | 0.0000764611 | 0.0000780065
11 x Angle | L40*40*3 | +58.234 | +58.274 | 9 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 331 | m548 | 0.0512553 | 0.000235669 | 0.0000764612 | 0.0000780065
11 x Angle | L40*40*3 | +57.323 | +58.271 | 9 | 3 | 1.7 | 0 | 83.7 | 0.1 | 40 | 40 | 948 | m545 | 0.146797 | 0.000235669 | 0.000210774 | 0.000223414
6 x Angle | L40*40*3 | +58.280 | +58.320 | 9 | 3 | 3.5 | 0.1 | 83.7 | 0.3 | 40 | 40 | 1821 | m549 | 0.281981 | 0.000235669 | 0.000420651 | 0.000429153
12 x Angle | L40*40*3 | +58.280 | +58.320 | 9 | 3 | 0.7 | 0 | 83.7 | 0 | 40 | 40 | 331 | m546 | 0.0512552 | 0.000235669 | 0.000068247 | 0.0000780064
3 x Angle | L70*70*6 | +57.520 | +57.590 | 9 | 99 | 0.5 | 0 | 42.7 | 0 | 55 | 70 | 84.1 | m98 | 0.022897 | 0.000812739 | 0.0000600441 | 0.0000683475
3 x Angle | L70*70*6 | +57.450 | +57.520 | 9 | 99 | 0.9 | 0 | 42.7 | 0 | 70 | 70 | 154.1 | m99 | 0.0419562 | 0.000812739 | 0.000123893 | 0.000125239
3 x Angle | L70*70*6 | +57.520 | +57.590 | 9 | 99 | 2.1 | 0 | 42.7 | 0.1 | 70 | 70 | 331.9 | m125 | 0.0903698 | 0.000812739 | 0.00021309 | 0.000269754
2 x Angle | L70*70*6 | +58.080 | +58.150 | 9 | 99 | 0.9 | 0 | 42.7 | 0 | 70 | 70 | 154.1 | m99 | 0.0419562 | 0.000812739 | 0.000123893 | 0.000125239
3 x Angle | L70*70*6 | +58.080 | +58.150 | 9 | 99 | 0.9 | 0 | 42.7 | 0 | 70 | 70 | 154.1 | m95 | 0.0419562 | 0.000812739 | 0.000123893 | 0.000125239
3 x Angle | L70*70*6 | +58.150 | +58.220 | 9 | 99 | 2.1 | 0 | 42.7 | 0.1 | 70 | 70 | 331.9 | m125 | 0.0903698 | 0.000812739 | 0.00021309 | 0.000269754
Angle | L40*40*3 | +57.320 | +57.360 | 3 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 331 | m548 | 0.0512553 | 0.000235669 | 0.0000764611 | 0.0000780065
Angle | L40*40*3 | +58.234 | +58.274 | 3 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 331 | m548 | 0.0512553 | 0.000235669 | 0.0000764612 | 0.0000780065
Angle | L40*40*3 | +57.323 | +58.271 | 3 | 3 | 1.7 | 0 | 83.7 | 0.1 | 40 | 40 | 948 | m545 | 0.146797 | 0.000235669 | 0.000210774 | 0.000223414
5 x Angle | L70*70*6 | +58.150 | +58.220 | 9 | 99 | 11 | 0 | 42.7 | 0.5 | 70 | 70 | 1725 | m89 | 0.469674 | 0.000812739 | 0.0013869 | 0.00140198
2 x Angle | L70*70*6 | +57.520 | +57.590 | 9 | 99 | 0.5 | 0 | 42.7 | 0 | 55 | 70 | 84.1 | m90 | 0.022897 | 0.000812739 | 0.0000600441 | 0.0000683475
2 x Angle | L70*70*6 | +57.450 | +57.520 | 9 | 99 | 0.9 | 0 | 42.7 | 0 | 70 | 70 | 154.1 | m95 | 0.0419562 | 0.000812739 | 0.000123893 | 0.000125239
3 x Angle | L40*40*3 | +57.810 | +57.867 | 5 | 3 | 3 | 0 | 83.7 | 0.2 | 40 | 40 | 1544 | m551 | 0.239088 | 0.000235669 | 0.000356664 | 0.000363873
3 x Angle | L40*40*3 | +57.812 | +58.111 | 5 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 384 | m498 | 0.0594613 | 0.000235669 | 0.0000835391 | 0.0000904953
2 x Angle | L40*40*3 | +57.812 | +58.111 | 5 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 384 | m497 | 0.0594607 | 0.000235669 | 0.0000835376 | 0.0000904944
3 x Angle | L40*40*3 | +58.071 | +58.111 | 5 | 3 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 695.5 | m496 | 0.107695 | 0.000235669 | 0.000155491 | 0.000163903
Angle | L40*40*3 | +57.812 | +58.111 | 5 | 3 | 0.7 | 0 | 83.7 | 0.1 | 40 | 40 | 384 | m497 | 0.0594607 | 0.000235669 | 0.0000835366 | 0.0000904944
Angle | L70*70*6 | +58.080 | +58.150 | 9 | 99 | 0.9 | 0 | 42.7 | 0 | 65 | 70 | 154.1 | m101 | 0.0419562 | 0.000812739 | 0.00011927 | 0.000125239
2 x Angle | L70*70*8 | +58.337 | +58.407 | 3 | 99 | 0.7 | 0 | 32.6 | 0 | 55 | 65 | 70 | m323 | 0.0190592 | 0.00106497 | 0.0000627195 | 0.0000745478
Angle | L70*70*6 | +58.080 | +58.150 | 9 | 99 | 0.9 | 0 | 42.7 | 0 | 65 | 70 | 154.1 | m97 | 0.0419562 | 0.000812739 | 0.00011927 | 0.000125239
12 x Angle | L70*70*6 | +57.650 | +57.720 | 12 | 99 | 0.7 | 0 | 42.7 | 0 | 70 | 70 | 130 | m85 | 0.0353957 | 0.000812739 | 0.00010452 | 0.000105656
12 x Angle | L70*70*6 | +57.075 | +57.145 | 12 | 99 | 0.7 | 0 | 42.7 | 0 | 70 | 70 | 130 | m85 | 0.0353957 | 0.000812739 | 0.00010452 | 0.000105656
Angle | L60*60*5 | +57.735 | +57.795 | 12 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 92 | m743 | 0.0214484 | 0.000582166 | 0.0000479304 | 0.0000535597
36 x Angle | L50*50*5 | +57.745 | +57.795 | 12 | 99 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m934 | 0.00969956 | 0.000480255 | 0.00002375 | 0.0000240127
3 x Angle | L60*60*5 | +57.735 | +57.795 | 12 | 99 | 0.7 | 0 | 51 | 0 | 60 | 53 | 130 | m749 | 0.0303074 | 0.000582166 | 0.000069909 | 0.000075682
Angle | L60*60*5 | +57.735 | +57.795 | 12 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 92 | m742 | 0.0214483 | 0.000582166 | 0.0000479297 | 0.0000535595
Angle | L60*60*5 | +57.735 | +57.795 | 12 | 99 | 0.7 | 0 | 51 | 0 | 60 | 53 | 130 | m748 | 0.0303216 | 0.000582166 | 0.0000699828 | 0.0000757174
Angle | L60*60*5 | +57.160 | +57.220 | 12 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 92 | m743 | 0.0214485 | 0.000582166 | 0.0000479306 | 0.00005356
36 x Angle | L50*50*5 | +57.170 | +57.220 | 12 | 99 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m934 | 0.00969956 | 0.000480255 | 0.00002375 | 0.0000240127
2 x Angle | L60*60*5 | +57.160 | +57.220 | 12 | 99 | 0.7 | 0 | 51 | 0 | 60 | 53 | 130 | m749 | 0.0303213 | 0.000582166 | 0.0000699408 | 0.0000757166
Angle | L60*60*5 | +57.160 | +57.220 | 12 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 92 | m742 | 0.0214483 | 0.000582166 | 0.0000479297 | 0.0000535595
2 x Angle | L60*60*5 | +57.160 | +57.220 | 12 | 99 | 0.7 | 0 | 51 | 0 | 60 | 53 | 130 | m748 | 0.0303214 | 0.000582166 | 0.0000699823 | 0.0000757169
12 x Angle | L40*40*3 | +56.835 | +56.875 | 12 | 3 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 594 | m555 | 0.0919807 | 0.000235669 | 0.000137214 | 0.000139987
12 x Angle | L40*40*3 | +57.795 | +57.835 | 12 | 3 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 594 | m555 | 0.0919807 | 0.000235669 | 0.000137214 | 0.000139987
12 x Angle | L40*40*3 | +56.835 | +56.875 | 12 | 3 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 635 | m556 | 0.0983295 | 0.000235669 | 0.000146685 | 0.00014965
12 x Angle | L40*40*3 | +57.795 | +57.835 | 12 | 3 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 635 | m556 | 0.0983295 | 0.000235669 | 0.000146685 | 0.00014965
24 x Angle | L40*40*3 | +56.838 | +57.832 | 12 | 3 | 1.7 | 0 | 83.7 | 0.2 | 40 | 40 | 994 | m544 | 0.153921 | 0.000235669 | 0.0002214 | 0.000234255
Angle | L60*60*5 | +57.735 | +57.795 | 12 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 92 | m743 | 0.0214483 | 0.000582166 | 0.0000479305 | 0.0000535595
Angle | L60*60*5 | +57.735 | +57.795 | 12 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 92 | m742 | 0.0214484 | 0.000582166 | 0.0000479299 | 0.0000535596
Angle | L60*60*5 | +57.735 | +57.795 | 12 | 99 | 0.7 | 0 | 51 | 0 | 60 | 53 | 130 | m748 | 0.0303217 | 0.000582166 | 0.0000699829 | 0.0000757175
Angle | L60*60*5 | +57.160 | +57.220 | 12 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 92 | m743 | 0.0214483 | 0.000582166 | 0.0000479303 | 0.0000535594
Angle | L60*60*5 | +57.160 | +57.220 | 12 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 92 | m742 | 0.0214482 | 0.000582166 | 0.0000479297 | 0.0000535593
Angle | L60*60*5 | +57.735 | +57.795 | 12 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 92 | m743 | 0.0214482 | 0.000582166 | 0.0000479306 | 0.0000535593
Angle | L60*60*5 | +57.735 | +57.795 | 12 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 92 | m742 | 0.0214484 | 0.000582166 | 0.0000479304 | 0.0000535596
Angle | L60*60*5 | +57.735 | +57.795 | 12 | 99 | 0.7 | 0 | 51 | 0 | 60 | 53 | 130 | m748 | 0.0303217 | 0.000582166 | 0.000069983 | 0.0000757176
Angle | L60*60*5 | +57.160 | +57.220 | 12 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 92 | m743 | 0.0214482 | 0.000582166 | 0.0000479306 | 0.0000535593
Angle | L60*60*5 | +57.160 | +57.220 | 12 | 99 | 0.7 | 0 | 51 | 0 | 60 | 53 | 130 | m749 | 0.0303212 | 0.000582166 | 0.0000699407 | 0.0000757165
Angle | L60*60*5 | +57.160 | +57.220 | 12 | 99 | 0.3 | 0 | 51 | 0 | 60 | 53 | 92 | m742 | 0.0214482 | 0.000582166 | 0.0000479301 | 0.0000535593
Angle | L60*60*5 | +57.160 | +57.220 | 12 | 99 | 0.7 | 0 | 51 | 0 | 60 | 53 | 130 | m748 | 0.0303217 | 0.000582166 | 0.0000699829 | 0.0000757176
6 x Angle | L75*50*6 | +58.548 | +59.392 | 5 | 3 | 4.8 | 0 | 43.2 | 0.2 | 75 | 50 | 844 | m691 | 0.205932 | 0.000719745 | 0.000577702 | 0.000607476
15 x Angle | L65*50*8 | +58.334 | +58.399 | 4 | 99 | 0.3 | 0 | 33.3 | 0 | 65 | 50 | 50 | m727 | 0.0112425 | 0.000859873 | 0.00004 | 0.0000429936
15 x Angle | L65*50*8 | +58.334 | +58.399 | 4 | 99 | 0.3 | 0 | 33.3 | 0 | 65 | 50 | 50 | m726 | 0.0112425 | 0.000859873 | 0.00004 | 0.0000429936
3 x Angle | L70*70*8 | +58.317 | +58.387 | 4 | 99 | 0.3 | 0 | 32.6 | 0 | 70 | 70 | 50 | m321 | 0.0136137 | 0.00106497 | 0.0000528 | 0.0000532484
3 x Angle | L70*70*8 | +58.317 | +58.387 | 4 | 99 | 0.3 | 0 | 32.6 | 0 | 70 | 70 | 50 | m320 | 0.0136137 | 0.00106497 | 0.0000528 | 0.0000532484
3 x Angle | L50*50*8 | +58.020 | +58.070 | 4 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 70 | m725 | 0.0135855 | 0.000741401 | 0.0000515432 | 0.0000519214
3 x Angle | L50*50*8 | +58.020 | +58.070 | 4 | 99 | 0.3 | 0 | 33.3 | 0 | 50 | 50 | 70 | m724 | 0.0135855 | 0.000741401 | 0.0000515432 | 0.0000519214
3 x Angle | L75*50*6 | +58.561 | +59.392 | 5 | 3 | 4.7 | 0 | 43.2 | 0.2 | 75 | 50 | 831.3 | m692 | 0.202825 | 0.000719745 | 0.000568794 | 0.00059831
2 x Angle | L75*50*6 | +58.561 | +59.392 | 5 | 3 | 4.7 | 0 | 43.2 | 0.2 | 75 | 50 | 831.3 | m693 | 0.202825 | 0.000719745 | 0.000568794 | 0.00059831
2 x Angle | L60*60*6 | +56.974 | +57.036 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +56.973 | +57.036 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
Angle | L60*60*6 | +56.756 | +56.820 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +57.137 | +57.200 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +57.063 | +57.125 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
Angle | L60*60*6 | +56.870 | +56.932 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +57.195 | +57.256 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +57.195 | +57.256 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
24 x Angle | L40*40*3 | +50.342 | +50.382 | 9 | 3 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 744 | m553 | 0.115208 | 0.000235669 | 0.000171864 | 0.000175338
24 x Angle | L40*40*3 | +52.554 | +52.594 | 9 | 3 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 744 | m553 | 0.115208 | 0.000235669 | 0.000171864 | 0.000175338
12 x Angle | L40*40*3 | +50.342 | +50.382 | 9 | 3 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 631 | m552 | 0.0977101 | 0.000235669 | 0.000145761 | 0.000148707
12 x Angle | L40*40*3 | +52.554 | +52.594 | 9 | 3 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 631 | m552 | 0.0977101 | 0.000235669 | 0.000145761 | 0.000148707
2 x Angle | L60*60*6 | +55.658 | +55.723 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +55.658 | +55.723 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +57.138 | +57.200 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +57.062 | +57.124 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +56.870 | +56.933 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +56.756 | +56.819 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
Angle | L60*60*6 | +56.870 | +56.933 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
Angle | L60*60*6 | +56.757 | +56.820 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +56.620 | +56.684 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +56.480 | +56.545 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +56.324 | +56.388 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +56.160 | +56.225 | 7008 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +55.995 | +56.060 | 7008 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +55.833 | +55.898 | 7008 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +56.620 | +56.684 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +56.480 | +56.545 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +56.324 | +56.388 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +56.160 | +56.225 | 7008 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +55.995 | +56.060 | 7008 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +55.833 | +55.898 | 7008 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +55.498 | +55.563 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +55.333 | +55.398 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +55.170 | +55.234 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +55.005 | +55.069 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +54.841 | +54.905 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +54.666 | +54.731 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +54.506 | +54.570 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +54.341 | +54.405 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +54.176 | +54.241 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +54.011 | +54.076 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +53.848 | +53.913 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +53.674 | +53.738 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +53.513 | +53.578 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +53.348 | +53.413 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +53.184 | +53.248 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +53.019 | +53.084 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +52.856 | +52.921 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +52.681 | +52.746 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +52.521 | +52.586 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +52.356 | +52.421 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +52.191 | +52.256 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +52.026 | +52.091 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +51.864 | +51.929 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +51.711 | +51.776 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +51.566 | +51.631 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +51.402 | +51.466 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +51.252 | +51.316 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +51.090 | +51.155 | 2 | 99 | 8 | 0 | 43 | 0.3 | 60 | 60 | 1502 | m646 | 0.350165 | 0.000690446 | 0.00102737 | 0.00103705
2 x Angle | L60*60*6 | +55.498 | +55.563 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +55.333 | +55.398 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +55.170 | +55.234 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +55.005 | +55.070 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +54.841 | +54.906 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +54.666 | +54.731 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +54.506 | +54.570 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +54.341 | +54.405 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +54.176 | +54.241 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +54.011 | +54.076 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +53.849 | +53.913 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +53.674 | +53.738 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +53.513 | +53.578 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +53.348 | +53.413 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +53.184 | +53.248 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +53.019 | +53.084 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +52.856 | +52.921 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +52.681 | +52.746 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +52.521 | +52.586 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +52.356 | +52.421 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +52.191 | +52.256 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +52.027 | +52.091 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +51.864 | +51.929 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +51.711 | +51.776 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +51.566 | +51.631 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +51.402 | +51.466 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +51.252 | +51.316 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665
2 x Angle | L60*60*6 | +51.090 | +51.155 | 2 | 99 | 3 | 0 | 43 | 0.1 | 60 | 60 | 560 | m647 | 0.130554 | 0.000690446 | 0.00038304 | 0.00038665

# IfcDiscreteAccessory: Beam (329)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x Beam | IPE180 | +51.876 | +52.063 | 6 | 3 | 3 | 0 | 37.1 | 0.1 | 180 | 91 | 161 | m962 | 0.112374 | 0.0023949 | 0.000279443 | 0.000385595
3 x Beam | IPE180 | +51.629 | +51.816 | 6 | 3 | 2.7 | 0 | 37.1 | 0.1 | 180 | 91 | 141 | m961 | 0.0984152 | 0.0023949 | 0.000232939 | 0.000337697
3 x Beam | IPE180 | +51.381 | +51.568 | 6 | 3 | 2.7 | 0 | 37.1 | 0.1 | 180 | 91 | 141 | m961 | 0.0984152 | 0.0023949 | 0.000232939 | 0.000337697
2 x Beam | UB254*146*37 | +56.642 | +56.788 | 1 | 3 | 22 | 0 | 28.9 | 0.6 | 256 | 146.4 | 590.9 | m256 | 0.633421 | 0.00471338 | 0.00275774 | 0.00278516
6 x Beam | PC180*70 | +51.121 | +51.301 | 9 | 99 | 5.9 | 0 | 29.3 | 0.2 | 180 | 70 | 273 | m193 | 0.168344 | 0.0026879 | 0.000718918 | 0.000733796
3 x Beam | C152*76 | +52.952 | +53.040 | 6 | 3 | 30.3 | 0 | 32.6 | 0.9 | 152.4 | 76.2 | 1690.4 | m307 | 0.987645 | 0.00228026 | 0.00346921 | 0.00385454
3 x Beam | C152*76 | +52.828 | +52.917 | 6 | 3 | 6.4 | 0 | 32.6 | 0.2 | 152.4 | 76.2 | 351.2 | m306 | 0.205195 | 0.00228026 | 0.000651424 | 0.000800825
3 x Beam | C152*76 | +53.281 | +53.370 | 6 | 3 | 30.3 | 0 | 32.6 | 0.9 | 152.4 | 76.2 | 1690.4 | m307 | 0.987645 | 0.00228026 | 0.00346921 | 0.00385454
3 x Beam | C152*76 | +53.199 | +53.287 | 6 | 3 | 30.3 | 0 | 32.6 | 0.9 | 152.4 | 76.2 | 1690.4 | m307 | 0.987645 | 0.00228026 | 0.00346921 | 0.00385454
3 x Beam | C152*76 | +53.075 | +53.164 | 6 | 3 | 30.3 | 0 | 32.6 | 0.9 | 152.4 | 76.2 | 1690.4 | m307 | 0.987645 | 0.00228026 | 0.00346921 | 0.00385454
3 x Beam | C152*76 | +52.828 | +52.917 | 6 | 3 | 6.4 | 0 | 32.6 | 0.2 | 152.4 | 76.2 | 351.2 | m305 | 0.205195 | 0.00228026 | 0.000651424 | 0.000800826
3 x Beam | C152*76 | +52.704 | +52.793 | 6 | 3 | 30.3 | 0 | 32.6 | 0.9 | 152.4 | 76.2 | 1690.4 | m307 | 0.987645 | 0.00228026 | 0.00346921 | 0.00385454
3 x Beam | C152*76 | +53.151 | +53.308 | 6 | 3 | 17.7 | 0 | 32.6 | 0.6 | 152.4 | 76.2 | 984 | m302 | 0.574919 | 0.00228026 | 0.00215759 | 0.00224377
3 x Beam | C152*76 | +53.151 | +53.308 | 6 | 3 | 17.7 | 0 | 32.6 | 0.6 | 152.4 | 76.2 | 984 | m301 | 0.574919 | 0.00228026 | 0.00215759 | 0.00224377
3 x Beam | C152*76 | +52.903 | +53.102 | 6 | 3 | 26.6 | 0 | 32.6 | 0.9 | 152.4 | 76.2 | 1484 | m300 | 0.867052 | 0.00228026 | 0.00325393 | 0.0033839
3 x Beam | C152*76 | +53.027 | +53.225 | 6 | 3 | 26.6 | 0 | 32.6 | 0.9 | 152.4 | 76.2 | 1484 | m299 | 0.867052 | 0.00228026 | 0.00325393 | 0.0033839
3 x Beam | C152*76 | +53.027 | +53.225 | 6 | 3 | 26.6 | 0 | 32.6 | 0.9 | 152.4 | 76.2 | 1484 | m298 | 0.867053 | 0.00228026 | 0.00325393 | 0.0033839
3 x Beam | C152*76 | +52.629 | +52.854 | 6 | 3 | 32.3 | 0 | 32.6 | 1.1 | 152.4 | 76.2 | 1810 | m296 | 1.05752 | 0.00228026 | 0.00396875 | 0.00412726
Beam | C152*76 | +52.629 | +52.854 | 6 | 3 | 32.3 | 0 | 32.6 | 1.1 | 152.4 | 76.2 | 1810 | m297 | 1.05752 | 0.00228026 | 0.00396875 | 0.00412726
3 x Beam | C152*76 | +52.903 | +53.102 | 6 | 3 | 26.6 | 0 | 32.6 | 0.9 | 152.4 | 76.2 | 1484 | m292 | 0.867052 | 0.00228026 | 0.00325393 | 0.0033839
3 x Beam | C152*76 | +52.780 | +52.978 | 6 | 3 | 26.6 | 0 | 32.6 | 0.9 | 152.4 | 76.2 | 1484 | m291 | 0.867052 | 0.00228026 | 0.00325393 | 0.0033839
3 x Beam | C152*76 | +52.780 | +52.978 | 6 | 3 | 26.6 | 0 | 32.6 | 0.9 | 152.4 | 76.2 | 1484 | m290 | 0.867052 | 0.00228026 | 0.00325393 | 0.0033839
2 x Beam | C152*76 | +52.629 | +52.854 | 6 | 3 | 32.3 | 0 | 32.6 | 1.1 | 152.4 | 76.2 | 1810 | m295 | 1.05752 | 0.00228026 | 0.00396875 | 0.00412726
15 x Beam | SHS75*75*4.0 | +58.336 | +58.411 | 4 | 3 | 19.1 | 0.2 | 32 | 0.6 | 75 | 75 | 2130 | m698 | 0.609746 | 0.00114395 | 0.00241968 | 0.00243661
3 x Beam | C160*65 | +57.110 | +57.270 | 3 | 3 | 4.8 | 0 | 29.3 | 0.1 | 160 | 65 | 257.3 | m455 | 0.141813 | 0.00240764 | 0.000555488 | 0.000619366
3 x Beam | C160*65 | +57.110 | +57.270 | 3 | 3 | 4.8 | 0 | 29.3 | 0.1 | 160 | 65 | 257.3 | m456 | 0.141813 | 0.00240764 | 0.000555488 | 0.000619366
