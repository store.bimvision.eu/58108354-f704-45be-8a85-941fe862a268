Properties of the parts of a building model (IFC2X3), part 9 of 16

# IfcDiscreteAccessory: Plate (5440)
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x Plate | PLT8*155 | +54.691 | +54.713 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 155 | 8 | 160 | p480 | 0.05464 | 0.0248 | 0.000064 | 0.0001984 | 0.0001984
3 x Plate | FL8*150 | +54.684 | +54.705 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +54.025 | +54.046 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*80 | +54.985 | +55.007 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*110 | +54.823 | +54.844 | 2 | 99 | 1.1 | 0 | 35.9 | 0 | 110 | 8 | 160.1 | p521 | 0.039556 | 0.0176168 | 0.000064 | 0.000140934 | 0.000140934
3 x Plate | FL8*80 | +55.727 | +55.748 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p474 | 0.0294129 | 0.0127877 | 0.000064 | 0.000102301 | 0.000102301
2 x Plate | FL8*80 | +55.720 | +55.741 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294545 | 0.0128066 | 0.000064 | 0.000102453 | 0.000102453
3 x Plate | FL8*80 | +55.645 | +55.666 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294129 | 0.0127877 | 0.000064 | 0.000102301 | 0.000102301
3 x Plate | FL8*80 | +55.637 | +55.658 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*80 | +55.562 | +55.583 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | FL8*80 | +54.896 | +54.917 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p474 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +54.903 | +54.924 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +54.978 | +54.999 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +55.480 | +55.501 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | FL8*80 | +55.397 | +55.419 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
2 x Plate | FL8*80 | +55.308 | +55.336 | 2 | 99 | 1.2 | 0 | 36.1 | 0 | 80 | 8 | 250 | p418 | 0.04528 | 0.02 | 0.000064 | 0.00016 | 0.00016
3 x Plate | FL8*80 | +55.225 | +55.246 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +55.143 | +55.164 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +55.060 | +55.082 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*150 | +54.197 | +54.218 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +54.032 | +54.053 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | PLT8*170 | +54.437 | +54.460 | 2 | 99 | 2 | 0 | 34.7 | 0.1 | 170 | 8 | 190 | p537 | 0.07036 | 0.0323 | 0.000064 | 0.0002584 | 0.0002584
3 x Plate | FL8*150 | +54.519 | +54.540 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +54.355 | +54.376 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*130 | +54.117 | +54.135 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p530 | 0.0545267 | 0.0247032 | 0.000064 | 0.000197625 | 0.000197625
3 x Plate | FL8*150 | +54.362 | +54.383 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +54.190 | +54.211 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +54.527 | +54.548 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
2 x Plate | FL8*130 | +54.446 | +54.465 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p538 | 0.05452 | 0.0247 | 0.000064 | 0.0001976 | 0.0001976
3 x Plate | FL8*130 | +54.109 | +54.131 | 2 | 99 | 1.2 | 0 | 35.3 | 0 | 130 | 8 | 160 | p529 | 0.0462407 | 0.0208003 | 0.000064 | 0.000166402 | 0.000166402
2 x Plate | PLT8*190 | +54.272 | +54.301 | 2 | 99 | 3 | 0 | 34.2 | 0.1 | 190 | 8 | 249.7 | p462 | 0.101966 | 0.0474646 | 0.000064 | 0.000379717 | 0.000379717
3 x Plate | FL8*80 | +55.068 | +55.089 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +55.150 | +55.171 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +55.233 | +55.254 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
2 x Plate | FL8*80 | +55.390 | +55.411 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
2 x Plate | FL8*80 | +55.472 | +55.494 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
2 x Plate | FL8*80 | +55.555 | +55.576 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*50 | +55.315 | +55.329 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | PLT8*85 | +52.857 | +52.956 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 170 | p453 | 0.0329793 | 0.0144498 | 0.000064 | 0.000115597 | 0.000115597
6 x Plate | PLT8*95 | +53.828 | +53.937 | 2 | 99 | 1.1 | 0 | 35.9 | 0 | 95 | 8 | 180 | p476 | 0.0386005 | 0.0171004 | 0.000064 | 0.000136802 | 0.000136802
6 x Plate | FL8*50 | +53.954 | +54.019 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925324 | 0.000064 | 0.0000740259 | 0.0000740259
6 x Plate | FL8*50 | +53.872 | +53.937 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925322 | 0.000064 | 0.0000740258 | 0.0000740258
6 x Plate | FL8*60 | +53.769 | +53.854 | 2 | 99 | 1.2 | 0 | 36.9 | 0 | 60 | 8 | 310.1 | p422 | 0.0431384 | 0.0186081 | 0.000064 | 0.000148865 | 0.000148865
6 x Plate | FL8*60 | +54.594 | +54.679 | 2 | 99 | 1.2 | 0 | 36.9 | 0 | 60 | 8 | 310.1 | p422 | 0.0431388 | 0.0186083 | 0.000064 | 0.000148866 | 0.000148866
6 x Plate | FL8*50 | +54.521 | +54.587 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222676 | 0.00925328 | 0.000064 | 0.0000740262 | 0.0000740262
6 x Plate | FL8*50 | +54.439 | +54.504 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222676 | 0.00925326 | 0.000064 | 0.0000740261 | 0.0000740261
6 x Plate | FL8*60 | +53.677 | +53.751 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +53.594 | +53.668 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +53.092 | +53.166 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +53.009 | +53.083 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*50 | +52.935 | +52.991 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | FL8*60 | +53.512 | +53.586 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +53.430 | +53.503 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +53.339 | +53.421 | 2 | 99 | 0.9 | 0 | 37 | 0 | 60 | 8 | 270 | p417 | 0.03768 | 0.0162 | 0.000064 | 0.0001296 | 0.0001296
6 x Plate | FL8*60 | +53.257 | +53.330 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +53.174 | +53.248 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*50 | +54.357 | +54.422 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925325 | 0.000064 | 0.000074026 | 0.000074026
6 x Plate | FL8*50 | +54.274 | +54.339 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925325 | 0.000064 | 0.000074026 | 0.000074026
6 x Plate | FL8*50 | +54.119 | +54.184 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222676 | 0.00925326 | 0.000064 | 0.0000740261 | 0.0000740261
6 x Plate | FL8*50 | +54.201 | +54.257 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | FL8*50 | +54.037 | +54.102 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925325 | 0.000064 | 0.000074026 | 0.000074026
6 x Plate | PLT6*67 | +53.816 | +53.979 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
6 x Plate | PLT6*67 | +54.516 | +54.680 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
6 x Plate | PLT6*67 | +54.186 | +54.350 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
3 x Plate | FL8*150 | +52.952 | +52.973 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p525 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*130 | +53.766 | +53.785 | 2 | 99 | 2.1 | 0 | 34.8 | 0.1 | 130 | 8 | 260 | p532 | 0.07384 | 0.0338 | 0.000064 | 0.0002704 | 0.0002704
3 x Plate | PLT8*160 | +53.619 | +53.640 | 2 | 99 | 2 | 0 | 34.8 | 0.1 | 160 | 8 | 190 | p533 | 0.0664 | 0.0304 | 0.000064 | 0.0002432 | 0.0002432
3 x Plate | FL8*130 | +53.610 | +53.633 | 2 | 99 | 1.4 | 0 | 35.2 | 0.1 | 130 | 8 | 180 | p534 | 0.05176 | 0.0234 | 0.000064 | 0.0001872 | 0.0001872
3 x Plate | FL8*130 | +52.960 | +52.978 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p535 | 0.05452 | 0.0247 | 0.000064 | 0.0001976 | 0.0001976
3 x Plate | FL8*60 | +54.812 | +54.828 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90 | p520 | 0.0132002 | 0.0054001 | 0.000064 | 0.0000432008 | 0.0000432008
3 x Plate | FL8*110 | +54.806 | +54.828 | 2 | 99 | 1.2 | 0 | 35.7 | 0 | 110 | 8 | 171.1 | p451 | 0.0421506 | 0.0188261 | 0.000064 | 0.000150609 | 0.000150609
2 x Plate | FL8*60 | +53.831 | +53.846 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90 | p520 | 0.0132 | 0.00539998 | 0.000064 | 0.0000431998 | 0.0000431998
3 x Plate | FL8*130 | +52.803 | +52.822 | 2 | 99 | 2.1 | 0 | 34.8 | 0.1 | 130 | 8 | 260 | p536 | 0.07384 | 0.0338 | 0.000064 | 0.0002704 | 0.0002704
3 x Plate | FL8*150 | +52.875 | +52.896 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | PLT8*160 | +52.868 | +52.889 | 2 | 99 | 1.6 | 0 | 35 | 0.1 | 160 | 8 | 160 | p477 | 0.05632 | 0.0256 | 0.000064 | 0.0002048 | 0.0002048
3 x Plate | PLT8*155 | +53.699 | +53.720 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 155 | 8 | 160 | p473 | 0.05464 | 0.0248 | 0.000064 | 0.0001984 | 0.0001984
3 x Plate | FL8*150 | +53.692 | +53.713 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +53.033 | +53.054 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*80 | +53.993 | +54.014 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*110 | +53.831 | +53.852 | 2 | 99 | 1.1 | 0 | 35.9 | 0 | 110 | 8 | 160.1 | p521 | 0.039556 | 0.0176168 | 0.000064 | 0.000140934 | 0.000140934
3 x Plate | PLT8*85 | +54.735 | +54.756 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 159.8 | p478 | 0.0310913 | 0.0135869 | 0.000064 | 0.000108695 | 0.000108695
2 x Plate | FL8*80 | +54.727 | +54.749 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294545 | 0.0128066 | 0.000064 | 0.000102453 | 0.000102453
3 x Plate | PLT8*85 | +54.652 | +54.673 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 159.8 | p479 | 0.0310913 | 0.0135869 | 0.000064 | 0.000108695 | 0.000108695
2 x Plate | FL8*80 | +54.645 | +54.666 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | PLT8*85 | +54.570 | +54.591 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 159.8 | p479 | 0.0310915 | 0.013587 | 0.000064 | 0.000108696 | 0.000108696
3 x Plate | PLT8*85 | +53.903 | +53.924 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 160 | p478 | 0.0311189 | 0.0135995 | 0.000064 | 0.000108796 | 0.000108796
3 x Plate | FL8*80 | +53.911 | +53.932 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | PLT8*85 | +53.986 | +54.007 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 160 | p479 | 0.0311189 | 0.0135995 | 0.000064 | 0.000108796 | 0.000108796
3 x Plate | PLT8*85 | +54.488 | +54.509 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 159.8 | p479 | 0.0310915 | 0.013587 | 0.000064 | 0.000108696 | 0.000108696
3 x Plate | PLT8*85 | +54.405 | +54.426 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 159.8 | p479 | 0.0310915 | 0.013587 | 0.000064 | 0.000108696 | 0.000108696
3 x Plate | PLT8*85 | +54.315 | +54.344 | 2 | 99 | 1.2 | 0 | 35.9 | 0 | 85 | 8 | 250 | p421 | 0.04786 | 0.02125 | 0.000064 | 0.00017 | 0.00017
3 x Plate | PLT8*85 | +54.233 | +54.254 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 160 | p479 | 0.0311189 | 0.0135995 | 0.000064 | 0.000108796 | 0.000108796
3 x Plate | PLT8*85 | +54.150 | +54.172 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 160 | p479 | 0.0311189 | 0.0135995 | 0.000064 | 0.000108796 | 0.000108796
3 x Plate | PLT8*85 | +54.068 | +54.089 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 160 | p479 | 0.0311189 | 0.0135995 | 0.000064 | 0.000108796 | 0.000108796
3 x Plate | FL8*150 | +53.205 | +53.226 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +53.040 | +53.061 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | PLT8*170 | +53.444 | +53.468 | 2 | 99 | 2 | 0 | 34.7 | 0.1 | 170 | 8 | 190 | p537 | 0.07036 | 0.0323 | 0.000064 | 0.0002584 | 0.0002584
3 x Plate | FL8*150 | +53.527 | +53.548 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +53.362 | +53.383 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*130 | +53.124 | +53.143 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p530 | 0.0545267 | 0.0247032 | 0.000064 | 0.000197625 | 0.000197625
3 x Plate | FL8*150 | +53.370 | +53.391 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +53.197 | +53.219 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +53.534 | +53.556 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*130 | +53.454 | +53.473 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p538 | 0.05452 | 0.0247 | 0.000064 | 0.0001976 | 0.0001976
3 x Plate | FL8*130 | +53.117 | +53.138 | 2 | 99 | 1.2 | 0 | 35.3 | 0 | 130 | 8 | 160 | p529 | 0.0462407 | 0.0208003 | 0.000064 | 0.000166402 | 0.000166402
3 x Plate | PLT8*190 | +53.280 | +53.309 | 2 | 99 | 3 | 0 | 34.2 | 0.1 | 190 | 8 | 249.7 | p462 | 0.101966 | 0.0474646 | 0.000064 | 0.000379717 | 0.000379717
3 x Plate | FL8*80 | +54.075 | +54.097 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +54.158 | +54.179 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +54.240 | +54.261 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +54.398 | +54.419 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*80 | +54.480 | +54.501 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*80 | +54.563 | +54.584 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*50 | +54.323 | +54.336 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | PLT8*85 | +51.865 | +51.963 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 170 | p453 | 0.0329807 | 0.0144505 | 0.000064 | 0.000115603 | 0.000115603
6 x Plate | PLT8*95 | +52.835 | +52.945 | 2 | 99 | 1.1 | 0 | 35.9 | 0 | 95 | 8 | 180 | p476 | 0.0386006 | 0.0171004 | 0.000064 | 0.000136802 | 0.000136802
6 x Plate | FL8*50 | +52.962 | +53.027 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925324 | 0.000064 | 0.0000740259 | 0.0000740259
6 x Plate | FL8*50 | +52.879 | +52.945 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925322 | 0.000064 | 0.0000740258 | 0.0000740258
6 x Plate | FL8*60 | +52.777 | +52.862 | 2 | 99 | 1.1 | 0 | 36.9 | 0 | 60 | 8 | 305.1 | p420 | 0.0424584 | 0.0183081 | 0.000064 | 0.000146465 | 0.000146465
6 x Plate | FL8*60 | +53.601 | +53.687 | 2 | 99 | 1.2 | 0 | 36.9 | 0 | 60 | 8 | 310.1 | p419 | 0.0431388 | 0.0186083 | 0.000064 | 0.000148866 | 0.000148866
6 x Plate | FL8*50 | +53.529 | +53.594 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222676 | 0.00925328 | 0.000064 | 0.0000740262 | 0.0000740262
6 x Plate | FL8*50 | +53.447 | +53.512 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222676 | 0.00925326 | 0.000064 | 0.0000740261 | 0.0000740261
6 x Plate | FL8*60 | +52.685 | +52.758 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +52.602 | +52.676 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +52.100 | +52.173 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +52.017 | +52.091 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*50 | +51.943 | +51.999 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | FL8*60 | +52.520 | +52.594 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +52.437 | +52.511 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +52.347 | +52.429 | 2 | 99 | 0.9 | 0 | 37 | 0 | 60 | 8 | 270 | p417 | 0.03768 | 0.0162 | 0.000064 | 0.0001296 | 0.0001296
6 x Plate | FL8*60 | +52.264 | +52.338 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +52.182 | +52.256 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*50 | +53.364 | +53.429 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925325 | 0.000064 | 0.000074026 | 0.000074026
6 x Plate | FL8*50 | +53.282 | +53.347 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925325 | 0.000064 | 0.000074026 | 0.000074026
6 x Plate | FL8*50 | +53.127 | +53.192 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222676 | 0.00925326 | 0.000064 | 0.0000740261 | 0.0000740261
6 x Plate | FL8*50 | +53.209 | +53.265 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | FL8*50 | +53.044 | +53.109 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925325 | 0.000064 | 0.000074026 | 0.000074026
6 x Plate | PLT6*67 | +52.823 | +52.987 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
6 x Plate | PLT6*67 | +53.524 | +53.688 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
6 x Plate | PLT6*67 | +53.194 | +53.358 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
3 x Plate | FL8*150 | +51.960 | +51.981 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p525 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | PLT8*160 | +52.627 | +52.648 | 2 | 99 | 2 | 0 | 34.8 | 0.1 | 160 | 8 | 190 | p533 | 0.0664 | 0.0304 | 0.000064 | 0.0002432 | 0.0002432
3 x Plate | FL8*130 | +52.618 | +52.640 | 2 | 99 | 1.4 | 0 | 35.2 | 0.1 | 130 | 8 | 180 | p534 | 0.05176 | 0.0234 | 0.000064 | 0.0001872 | 0.0001872
3 x Plate | FL8*130 | +51.967 | +51.986 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p530 | 0.05452 | 0.0247 | 0.000064 | 0.0001976 | 0.0001976
3 x Plate | FL8*60 | +53.820 | +53.835 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90 | p520 | 0.0132002 | 0.00540009 | 0.000064 | 0.0000432008 | 0.0000432008
3 x Plate | FL8*110 | +53.813 | +53.835 | 2 | 99 | 1.2 | 0 | 35.7 | 0 | 110 | 8 | 171.1 | p451 | 0.0421507 | 0.0188262 | 0.000064 | 0.000150609 | 0.000150609
3 x Plate | FL8*60 | +52.839 | +52.854 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90 | p520 | 0.0132001 | 0.00540004 | 0.000064 | 0.0000432003 | 0.0000432003
3 x Plate | FL8*130 | +51.811 | +51.830 | 2 | 99 | 2.1 | 0 | 34.8 | 0.1 | 130 | 8 | 260 | p536 | 0.07384 | 0.0338 | 0.000064 | 0.0002704 | 0.0002704
3 x Plate | FL8*150 | +51.883 | +51.904 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | PLT8*155 | +51.876 | +51.897 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 155 | 8 | 160 | p473 | 0.05464 | 0.0248 | 0.000064 | 0.0001984 | 0.0001984
3 x Plate | PLT8*155 | +52.707 | +52.728 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 155 | 8 | 160 | p473 | 0.05464 | 0.0248 | 0.000064 | 0.0001984 | 0.0001984
3 x Plate | FL8*150 | +52.700 | +52.721 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +52.040 | +52.061 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*80 | +53.001 | +53.022 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*110 | +52.839 | +52.860 | 2 | 99 | 1.1 | 0 | 35.9 | 0 | 110 | 8 | 160.1 | p521 | 0.0395562 | 0.0176169 | 0.000064 | 0.000140935 | 0.000140935
3 x Plate | PLT8*85 | +53.742 | +53.764 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 159.8 | p478 | 0.0310913 | 0.0135869 | 0.000064 | 0.000108695 | 0.000108695
2 x Plate | FL8*80 | +53.735 | +53.756 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294545 | 0.0128066 | 0.000064 | 0.000102453 | 0.000102453
3 x Plate | FL8*80 | +53.660 | +53.681 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294129 | 0.0127877 | 0.000064 | 0.000102301 | 0.000102301
3 x Plate | FL8*80 | +53.653 | +53.674 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*80 | +53.578 | +53.599 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | FL8*80 | +52.911 | +52.932 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p474 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +52.918 | +52.940 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +52.993 | +53.015 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +53.495 | +53.516 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | FL8*80 | +53.413 | +53.434 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | FL8*80 | +53.323 | +53.352 | 2 | 99 | 1.2 | 0 | 36.1 | 0 | 80 | 8 | 250 | p418 | 0.04528 | 0.02 | 0.000064 | 0.00016 | 0.00016
3 x Plate | FL8*80 | +53.241 | +53.262 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +53.158 | +53.179 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +53.076 | +53.097 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*150 | +52.213 | +52.234 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +52.048 | +52.069 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*130 | +52.454 | +52.476 | 2 | 99 | 1.4 | 0 | 35.3 | 0 | 130 | 8 | 170 | p548 | 0.049 | 0.0221 | 0.000064 | 0.0001768 | 0.0001768
3 x Plate | FL8*150 | +52.535 | +52.556 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +52.370 | +52.391 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*130 | +52.132 | +52.151 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p530 | 0.0545267 | 0.0247032 | 0.000064 | 0.000197625 | 0.000197625
3 x Plate | FL8*150 | +52.378 | +52.399 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +52.205 | +52.226 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +52.542 | +52.563 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*130 | +52.462 | +52.481 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p538 | 0.05452 | 0.0247 | 0.000064 | 0.0001976 | 0.0001976
3 x Plate | FL8*130 | +52.125 | +52.146 | 2 | 99 | 1.2 | 0 | 35.3 | 0 | 130 | 8 | 160 | p529 | 0.0462407 | 0.0208003 | 0.000064 | 0.000166402 | 0.000166402
3 x Plate | PLT8*190 | +52.288 | +52.316 | 2 | 99 | 3 | 0 | 34.2 | 0.1 | 190 | 8 | 249.7 | p462 | 0.101966 | 0.0474646 | 0.000064 | 0.000379717 | 0.000379717
3 x Plate | FL8*80 | +53.083 | +53.104 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +53.166 | +53.187 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +53.248 | +53.269 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +53.405 | +53.427 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*80 | +53.488 | +53.509 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*80 | +53.570 | +53.591 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*50 | +53.330 | +53.344 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
3 x Plate | PLT10*222.4 | +51.791 | +52.018 | 6 | 99 | 3 | 0 | 28.2 | 0.1 | 222.4 | 10 | 249.4 | p84 | 0.0828831 | 0.0554538 | 0.0001 | 0.000374338 | 0.000374338
3 x Plate | FL8*50 | +53.936 | +53.987 | 6 | 14 | 5.9 | 0 | 37.1 | 0.2 | 50 | 8 | 1911.4 | p298 | 0.222362 | 0.222362 | 0.0004 | 0.000763033 | 0.000763033
3 x Plate | FL8*50 | +53.532 | +53.582 | 6 | 14 | 5.9 | 0 | 37.1 | 0.2 | 50 | 8 | 1911.4 | p298 | 0.222362 | 0.222362 | 0.0004 | 0.000763033 | 0.000763033
3 x Plate | FL8*50 | +53.127 | +53.178 | 6 | 14 | 5.9 | 0 | 37.1 | 0.2 | 50 | 8 | 1911.4 | p298 | 0.222362 | 0.222362 | 0.0004 | 0.000763033 | 0.000763033
3 x Plate | PL10*222.4 | +51.791 | +52.018 | 6 | 99 | 3 | 0 | 28.2 | 0.1 | 222.4 | 10 | 249.4 | p265 | 0.0828829 | 0.0554534 | 0.0001 | 0.000374337 | 0.000374337
3 x Plate | PL8*152.4 | +52.823 | +53.098 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p297 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
3 x Plate | PL8*152.4 | +52.822 | +53.097 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p297 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
6 x Plate | FL8*50 | +53.138 | +53.975 | 6 | 14 | 2.6 | 0 | 37.2 | 0.1 | 50 | 8 | 837.3 | p295 | 0.0979251 | 0.0979251 | 0.0004 | 0.000334914 | 0.000334914
3 x Plate | FL8*50 | +53.137 | +53.974 | 6 | 14 | 2.6 | 0 | 37.2 | 0.1 | 50 | 8 | 837.3 | p295 | 0.0979251 | 0.0979251 | 0.0004 | 0.000334914 | 0.000334914
6 x Plate | FL8*50 | +53.137 | +53.975 | 6 | 14 | 2.6 | 0 | 37.2 | 0.1 | 50 | 8 | 837.3 | p295 | 0.0979251 | 0.0979251 | 0.0004 | 0.000334914 | 0.000334914
6 x Plate | PL8*62 | +51.022 | +51.217 | 6 | 99 | 0.7 | 0 | 37.2 | 0 | 62 | 8 | 195 | p294 | 0.0279983 | 0.01209 | 0.000064 | 0.00009592 | 0.00009592
6 x Plate | PL8*104 | +51.418 | +51.475 | 6 | 99 | 1.4 | 0 | 35.3 | 0 | 104 | 8 | 200 | p293 | 0.0497905 | 0.0497905 | 0.0016 | 0.000179194 | 0.000179194
6 x Plate | PL8*154 | +51.295 | +51.401 | 6 | 99 | 2 | 0 | 34.7 | 0.1 | 154 | 8 | 200 | p292 | 0.07059 | 0.07059 | 0.0016 | 0.000259192 | 0.000259192
3 x Plate | FL8*80 | +52.902 | +53.023 | 6 | 99 | 0.7 | 0 | 37.1 | 0 | 80 | 8 | 120.8 | p299 | 0.022535 | 0.0096614 | 0.000064 | 0.000077291 | 0.000077291
3 x Plate | FL8*80 | +52.902 | +52.982 | 6 | 99 | 0.3 | 0 | 38.2 | 0 | 80 | 8 | 80 | p416 | 0.0153599 | 0.00639996 | 0.000064 | 0.0000511997 | 0.0000511997
6 x Plate | PL8*152.4 | +52.405 | +52.700 | 6 | 99 | 2.3 | 0 | 34.8 | 0.1 | 152.4 | 8 | 295 | p290 | 0.079558 | 0.044958 | 0.000064 | 0.000291629 | 0.000291629
2 x Plate | FL8*70 | +52.775 | +52.846 | 6 | 99 | 4.2 | 0 | 35.9 | 0.1 | 70 | 8 | 948 | p309 | 0.149008 | 0.149008 | 0.00056 | 0.00053088 | 0.00053088
6 x Plate | PL8*152.4 | +53.009 | +53.303 | 6 | 99 | 2.3 | 0 | 34.8 | 0.1 | 152.4 | 8 | 295 | p289 | 0.079558 | 0.044958 | 0.000064 | 0.000291629 | 0.000291629
3 x Plate | PL8*152.4 | +52.947 | +53.221 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p297 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
3 x Plate | PL8*152.4 | +52.946 | +53.221 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p297 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
3 x Plate | PL8*152.4 | +52.947 | +53.221 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p296 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
3 x Plate | PL8*152.4 | +52.946 | +53.221 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p296 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
6 x Plate | FL8*150 | +53.210 | +53.361 | 6 | 99 | 0.9 | 0 | 36 | 0 | 150 | 8 | 150 | p288 | 0.0371845 | 0.0225 | 0.000064 | 0.0001316 | 0.0001316
6 x Plate | FL8*150 | +53.197 | +53.347 | 6 | 99 | 0.9 | 0 | 36 | 0 | 150 | 8 | 150 | p288 | 0.0371845 | 0.0225 | 0.000064 | 0.0001316 | 0.0001316
6 x Plate | FL8*150 | +53.128 | +53.278 | 6 | 99 | 0.9 | 0 | 36 | 0 | 150 | 8 | 150 | p288 | 0.0371845 | 0.0225 | 0.000064 | 0.0001316 | 0.0001316
6 x Plate | FL8*150 | +53.115 | +53.265 | 6 | 99 | 0.9 | 0 | 36 | 0 | 150 | 8 | 150 | p288 | 0.0371845 | 0.0225 | 0.000064 | 0.0001316 | 0.0001316
3 x Plate | PL8*152.4 | +52.823 | +53.098 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p296 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
3 x Plate | PL8*152.4 | +52.822 | +53.097 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p296 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
3 x Plate | PL8*152.4 | +52.700 | +52.974 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p297 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
3 x Plate | PL8*152.4 | +52.699 | +52.974 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p297 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
3 x Plate | PL8*152.4 | +52.700 | +52.974 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p296 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
3 x Plate | PL8*152.4 | +52.699 | +52.974 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p296 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
3 x Plate | PL8*152.4 | +52.576 | +52.851 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p297 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
3 x Plate | PL8*152.4 | +52.575 | +52.850 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p297 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
3 x Plate | PL8*152.4 | +52.576 | +52.851 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p296 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
3 x Plate | PL8*152.4 | +52.575 | +52.850 | 6 | 99 | 2.2 | 0 | 34.7 | 0.1 | 152.4 | 8 | 275 | p296 | 0.0775168 | 0.04191 | 0.000064 | 0.000284412 | 0.000284412
6 x Plate | FL8*150 | +53.004 | +53.154 | 6 | 99 | 0.9 | 0 | 36 | 0 | 150 | 8 | 150 | p288 | 0.0371845 | 0.0225 | 0.000064 | 0.0001316 | 0.0001316
6 x Plate | FL8*150 | +52.991 | +53.141 | 6 | 99 | 0.9 | 0 | 36 | 0 | 150 | 8 | 150 | p288 | 0.0371845 | 0.0225 | 0.000064 | 0.0001316 | 0.0001316
6 x Plate | FL8*150 | +52.881 | +53.031 | 6 | 99 | 0.9 | 0 | 36 | 0 | 150 | 8 | 150 | p288 | 0.0371845 | 0.0225 | 0.000064 | 0.0001316 | 0.0001316
6 x Plate | FL8*150 | +52.868 | +53.018 | 6 | 99 | 0.9 | 0 | 36 | 0 | 150 | 8 | 150 | p288 | 0.0371845 | 0.0225 | 0.000064 | 0.0001316 | 0.0001316
6 x Plate | FL8*150 | +52.757 | +52.907 | 6 | 99 | 0.9 | 0 | 36 | 0 | 150 | 8 | 150 | p288 | 0.0371845 | 0.0225 | 0.000064 | 0.0001316 | 0.0001316
6 x Plate | FL8*150 | +52.744 | +52.894 | 6 | 99 | 0.9 | 0 | 36 | 0 | 150 | 8 | 150 | p288 | 0.0371845 | 0.0225 | 0.000064 | 0.0001316 | 0.0001316
6 x Plate | FL8*150 | +52.634 | +52.784 | 6 | 99 | 0.9 | 0 | 36 | 0 | 150 | 8 | 150 | p288 | 0.0371845 | 0.0225 | 0.000064 | 0.0001316 | 0.0001316
6 x Plate | FL8*150 | +52.620 | +52.770 | 6 | 99 | 0.9 | 0 | 36 | 0 | 150 | 8 | 150 | p288 | 0.0371845 | 0.0225 | 0.000064 | 0.0001316 | 0.0001316
3 x Plate | FL6*50 | +53.269 | +53.275 | 6 | 99 | 1.2 | 0 | 48.1 | 0.1 | 50 | 6 | 512 | p659 | 0.057944 | 0.057944 | 0.0003 | 0.0001536 | 0.0001536
3 x Plate | FL6*50 | +53.268 | +53.274 | 6 | 99 | 1.2 | 0 | 48.1 | 0.1 | 50 | 6 | 512 | p659 | 0.057944 | 0.057944 | 0.0003 | 0.0001536 | 0.0001536
2 x Plate | FL6*50 | +53.268 | +53.275 | 6 | 99 | 1.4 | 0 | 48 | 0.1 | 50 | 6 | 612 | p660 | 0.0691404 | 0.0691404 | 0.0003 | 0.00018359 | 0.00018359
3 x Plate | PL6*138.1 | +53.131 | +53.269 | 6 | 99 | 2.8 | 0 | 45.1 | 0.1 | 138.1 | 6 | 500 | p663 | 0.124653 | 0.124653 | 0.003 | 0.000351706 | 0.000351706
3 x Plate | PL6*138.1 | +53.131 | +53.269 | 6 | 99 | 2.8 | 0 | 45.1 | 0.1 | 138.1 | 6 | 500 | p663 | 0.124653 | 0.124653 | 0.003 | 0.000351708 | 0.000351708
3 x Plate | PL6*138.6 | +53.130 | +53.269 | 6 | 99 | 3.3 | 0 | 44.8 | 0.1 | 138.6 | 6 | 500 | p662 | 0.146008 | 0.146008 | 0.003 | 0.000415014 | 0.000415014
3 x Plate | PL6*96.4 | +53.172 | +53.269 | 6 | 99 | 2.3 | 0 | 45.6 | 0.1 | 96.4 | 6 | 500 | p661 | 0.10331 | 0.10331 | 0.003 | 0.000288437 | 0.000288437
6 x Plate | PL8*200 | +51.006 | +51.225 | 6 | 99 | 3.3 | 0 | 34.1 | 0.1 | 200 | 8 | 257 | p291 | 0.113438 | 0.113438 | 0.0016 | 0.000423994 | 0.000423994
Plate | PLT8*130.4 | +56.846 | +56.862 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130.4 | 8 | 190 | p544 | 0.0546798 | 0.0247809 | 0.000064 | 0.000198213 | 0.000198213
Plate | FL8*80 | +58.044 | +58.060 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 145 | p501 | 0.0267989 | 0.0115995 | 0.000064 | 0.0000927959 | 0.0000927959
Plate | FL8*80 | +57.992 | +58.008 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 140.5 | p492 | 0.0260142 | 0.0112428 | 0.000064 | 0.0000899426 | 0.0000899426
Plate | FL8*60 | +52.252 | +52.267 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90 | p520 | 0.0131873 | 0.00539441 | 0.000064 | 0.0000431553 | 0.0000431553
Plate | FL8*150 | +51.498 | +51.527 | 2 | 99 | 2.4 | 0 | 34.6 | 0.1 | 150 | 8 | 250 | p503 | 0.0814 | 0.0375 | 0.000064 | 0.0003 | 0.0003
Plate | FL8*150 | +52.252 | +52.272 | 2 | 99 | 1.2 | 0 | 35.3 | 0 | 135 | 8 | 135 | p463 | 0.045059 | 0.018225 | 0.000064 | 0.000161996 | 0.000161996
Plate | FL8*150 | +52.823 | +52.843 | 2 | 99 | 1.2 | 0 | 35.3 | 0 | 140 | 8 | 140 | p504 | 0.0466654 | 0.0196 | 0.000064 | 0.000168096 | 0.000168096
Plate | PLT8*160 | +51.722 | +51.743 | 2 | 99 | 2 | 0 | 34.8 | 0.1 | 160 | 8 | 185 | p502 | 0.06472 | 0.0296 | 0.000064 | 0.0002368 | 0.0002368
Plate | FL8*130 | +51.672 | +51.691 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p547 | 0.05452 | 0.0247 | 0.000064 | 0.0001976 | 0.0001976
2 x Plate | FL8*60 | +56.808 | +56.823 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90.2 | p520 | 0.0132 | 0.00540999 | 0.000064 | 0.0000432 | 0.0000432
2 x Plate | FL8*60 | +55.815 | +55.831 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90.2 | p520 | 0.0132 | 0.00540999 | 0.000064 | 0.0000431999 | 0.0000431999
Plate | FL8*60 | +54.823 | +54.839 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90.2 | p520 | 0.0132 | 0.00541 | 0.000064 | 0.0000432 | 0.0000432
Plate | FL8*70 | +52.775 | +52.846 | 6 | 99 | 4.2 | 0 | 35.9 | 0.2 | 70 | 8 | 968 | p311 | 0.152128 | 0.152128 | 0.00056 | 0.00054208 | 0.00054208
Plate | FL6*50 | +53.268 | +53.275 | 6 | 99 | 1.4 | 0 | 48 | 0.1 | 50 | 6 | 612.1 | p660 | 0.0691522 | 0.0691522 | 0.0003 | 0.000183622 | 0.000183622
12 x Plate | PLT12*95 | +56.735 | +56.747 | 12 | 99 | 2 | 0 | 25.1 | 0 | 95 | 12 | 220 | -38ANp171 | 0.04936 | 0.04936 | 0.00114 | 0.0002508 | 0.0002508
6 x Plate | PLT6*157 | +57.995 | +58.431 | 5 | 99 | 2.6 | 0 | 44.9 | 0.1 | 157 | 6 | 435.8 | -38ANp260 | 0.116299 | 0.0684206 | 0.000036 | 0.000329422 | 0.000329422
6 x Plate | PLT6*157 | +57.971 | +58.407 | 5 | 99 | 2.6 | 0 | 44.9 | 0.1 | 157 | 6 | 435.8 | -38ANp260 | 0.116299 | 0.0684206 | 0.000036 | 0.000329422 | 0.000329422
3 x Plate | PLT6*79.5 | +58.068 | +58.503 | 5 | 99 | 1.6 | 0 | 46.2 | 0.1 | 79.5 | 6 | 435.8 | -38ANp261 | 0.0734649 | 0.0346461 | 0.000036 | 0.000202477 | 0.000202477
6 x Plate | PLT6*79.5 | +58.019 | +58.455 | 5 | 99 | 1.6 | 0 | 46.2 | 0.1 | 79.5 | 6 | 435.8 | -38ANp261 | 0.0734649 | 0.0346461 | 0.000036 | 0.000202477 | 0.000202477
6 x Plate | PLT6*79.5 | +57.971 | +58.407 | 5 | 99 | 1.6 | 0 | 46.2 | 0.1 | 79.5 | 6 | 435.8 | -38ANp261 | 0.0734649 | 0.0346461 | 0.000036 | 0.000202477 | 0.000202477
6 x Plate | PLT6*157 | +58.068 | +58.503 | 5 | 99 | 2.6 | 0 | 44.9 | 0.1 | 157 | 6 | 435.8 | -38ANp260 | 0.116299 | 0.0684206 | 0.000036 | 0.000329422 | 0.000329422
6 x Plate | PLT6*157 | +58.019 | +58.455 | 5 | 99 | 2.6 | 0 | 44.9 | 0.1 | 157 | 6 | 435.8 | -38ANp260 | 0.116299 | 0.0684206 | 0.000036 | 0.000329422 | 0.000329422
6 x Plate | PLT10*157 | +58.092 | +58.528 | 5 | 99 | 4.2 | 0 | 28 | 0.1 | 157 | 10 | 435.8 | -38ANp254 | 0.120628 | 0.0684206 | 0.0001 | 0.000549036 | 0.000549036
6 x Plate | PLT6*79.5 | +58.044 | +58.479 | 5 | 99 | 1.6 | 0 | 46.2 | 0.1 | 79.5 | 6 | 435.8 | -38ANp261 | 0.0734649 | 0.0346461 | 0.000036 | 0.000202477 | 0.000202477
6 x Plate | PLT6*79.5 | +57.995 | +58.431 | 5 | 99 | 1.6 | 0 | 46.2 | 0.1 | 79.5 | 6 | 435.8 | -38ANp261 | 0.0734649 | 0.0346461 | 0.000036 | 0.000202477 | 0.000202477
3 x Plate | PLT10*109.9 | +58.399 | +58.411 | 5 | 99 | 1.6 | 0 | 29.3 | 0 | 110 | 10 | 207.3 | -38ANp42 | 0.0464394 | 0.0227842 | 0.0001 | 0.000202848 | 0.000202848
6 x Plate | PLT6*157 | +58.044 | +58.479 | 5 | 99 | 2.6 | 0 | 44.9 | 0.1 | 157 | 6 | 435.8 | -38ANp260 | 0.116299 | 0.0684206 | 0.000036 | 0.000329422 | 0.000329422
12 x Plate | PLT10*79.5 | +57.407 | +57.417 | 5 | 99 | 1.7 | 0 | 29.5 | 0.1 | 79.5 | 10 | 283.4 | -38ANp38 | 0.0501671 | 0.0225303 | 0.0001 | 0.000216303 | 0.000216303
12 x Plate | PLT10*79.5 | +57.192 | +57.202 | 5 | 99 | 1.7 | 0 | 29.5 | 0.1 | 79.5 | 10 | 283.4 | -38ANp38 | 0.0501671 | 0.0225303 | 0.0001 | 0.000216303 | 0.000216303
6 x Plate | PLT10*217 | +57.722 | +57.732 | 5 | 99 | 4.4 | 0.1 | 27.6 | 0.1 | 217 | 10 | 283.4 | p48 | 0.120479 | 0.0614979 | 0.0001 | 0.000555991 | 0.000555991
12 x Plate | PLT10*79.5 | +57.625 | +57.635 | 5 | 99 | 1.7 | 0 | 29.5 | 0.1 | 79.5 | 10 | 283.4 | -38ANp38 | 0.0501671 | 0.0225303 | 0.0001 | 0.000216303 | 0.000216303
6 x Plate | PLT12*170 | +57.409 | +58.409 | 5 | 99 | 15.9 | 0 | 23 | 0.3 | 170 | 12 | 1000 | -38ANp54 | 0.36808 | 0.36808 | 0.00204 | 0.00204 | 0.00204
12 x Plate | PLT10*79.5 | +59.055 | +59.065 | 5 | 99 | 1.7 | 0 | 29.5 | 0.1 | 79.5 | 10 | 283.4 | -38ANp35 | 0.0501671 | 0.0225303 | 0.0001 | 0.000216303 | 0.000216303
12 x Plate | PLT10*79.5 | +58.845 | +58.855 | 5 | 99 | 1.7 | 0 | 29.5 | 0.1 | 79.5 | 10 | 283.4 | -38ANp35 | 0.0501671 | 0.0225303 | 0.0001 | 0.000216303 | 0.000216303
6 x Plate | PLT10*166 | +59.704 | +59.714 | 5 | 99 | 3.9 | 0.1 | 28 | 0.1 | 166 | 10 | 304 | -38ANp34 | 0.110328 | 0.110328 | 0.00166 | 0.00050464 | 0.00050464
12 x Plate | PLT10*79.5 | +58.450 | +58.460 | 5 | 99 | 1.7 | 0 | 29.5 | 0.1 | 79.5 | 10 | 283.4 | -38ANp38 | 0.0501671 | 0.0225303 | 0.0001 | 0.000216303 | 0.000216303
12 x Plate | PLT10*79.5 | +58.250 | +58.260 | 5 | 99 | 1.7 | 0 | 29.5 | 0.1 | 79.5 | 10 | 283.4 | -38ANp38 | 0.0501671 | 0.0225303 | 0.0001 | 0.000216303 | 0.000216303
12 x Plate | PLT10*79.5 | +58.695 | +58.705 | 5 | 99 | 1.7 | 0 | 29.5 | 0.1 | 79.5 | 10 | 283.4 | p96 | 0.0501671 | 0.0225303 | 0.0001 | 0.000216303 | 0.000216303
12 x Plate | PLT10*79.5 | +58.005 | +58.015 | 5 | 99 | 1.7 | 0 | 29.5 | 0.1 | 79.5 | 10 | 283.4 | p96 | 0.0501671 | 0.0225303 | 0.0001 | 0.000216303 | 0.000216303
12 x Plate | PLT10*79.5 | +57.475 | +57.485 | 5 | 99 | 1.7 | 0 | 29.5 | 0.1 | 79.5 | 10 | 283.4 | -38ANp38 | 0.0501671 | 0.0225303 | 0.0001 | 0.000216303 | 0.000216303
6 x Plate | PLT10*137 | +56.992 | +57.175 | 5 | 99 | 1.6 | 0 | 28.9 | 0 | 137 | 10 | 183 | -38ANp33 | 0.046287 | 0.025071 | 0.0001 | 0.000203472 | 0.000203472
6 x Plate | PLT20*230 | +56.972 | +56.992 | 5 | 99 | 11.8 | 0.1 | 14.6 | 0.2 | 230 | 20 | 330 | -38ANp78 | 0.1742 | 0.1742 | 0.0046 | 0.001518 | 0.001518
6 x Plate | PLT12*170 | +57.775 | +58.540 | 5 | 99 | 12.3 | 0 | 23.1 | 0.3 | 170 | 12 | 765 | -38ANp55 | 0.28254 | 0.28254 | 0.00204 | 0.0015606 | 0.0015606
6 x Plate | PLT10*170 | +57.792 | +57.893 | 12 | 99 | 2.7 | 0 | 28.2 | 0.1 | 170 | 10 | 200 | -38ANp255 | 0.0754 | 0.0754 | 0.0017 | 0.00034 | 0.00034
6 x Plate | PLT8*120 | +57.345 | +57.565 | 12 | 99 | 1.7 | 0 | 35.1 | 0.1 | 120 | 8 | 220 | -38ANp305 | 0.0582398 | 0.0582398 | 0.00096 | 0.000211199 | 0.000211199
6 x Plate | PLT8*120 | +57.791 | +58.024 | 3 | 99 | 1.4 | 0 | 35.2 | 0.1 | 120 | 8 | 200 | -38ANp306 | 0.05312 | 0.05312 | 0.00096 | 0.000192 | 0.000192
12 x Plate | FL10*100 | +56.735 | +56.745 | 12 | 99 | 1.6 | 0 | 29.3 | 0 | 100 | 10 | 200 | p81 | 0.046 | 0.046 | 0.001 | 0.0002 | 0.0002
12 x Plate | FL10*180 | +56.735 | +56.745 | 5 | 99 | 3.5 | 0 | 28 | 0.1 | 180 | 10 | 240 | -38ANp175 | 0.0948 | 0.0948 | 0.0018 | 0.000432 | 0.000432
4 x Plate | FL10*150 | +57.073 | +57.264 | 3 | 99 | 2.2 | 0 | 28.5 | 0.1 | 150 | 10 | 191 | -38ANp28 | 0.06412 | 0.06412 | 0.0015 | 0.0002865 | 0.0002865
10 x Plate | FL10*150 | +57.116 | +57.240 | 3 | 99 | 1.4 | 0 | 29.3 | 0 | 124 | 10 | 124 | -38ANp17 | 0.04268 | 0.04268 | 0.0015 | 0.000186 | 0.000186
2 x Plate | PLT10*204.4 | +56.747 | +56.974 | 4 | 99 | 2.8 | 0 | 28.2 | 0.1 | 204.5 | 10 | 261.9 | -38ANp299 | 0.0796498 | 0.0535223 | 0.0001 | 0.000360051 | 0.000360051
3 x Plate | FL8*80 | +57.980 | +58.060 | 4 | 99 | 1.2 | 0 | 36 | 0 | 80 | 8 | 253.9 | -38ANp138 | 0.0473918 | 0.0473918 | 0.00064 | 0.000167679 | 0.000167679
41 x Plate | FL8*80 | +58.227 | +58.307 | 4 | 99 | 1.2 | 0 | 36 | 0 | 80 | 8 | 253.9 | -38ANp208 | 0.0473918 | 0.0473918 | 0.00064 | 0.000167679 | 0.000167679
33 x Plate | FL8*80 | +57.980 | +58.060 | 4 | 99 | 1.2 | 0 | 36 | 0 | 80 | 8 | 253.9 | -38ANp274 | 0.0473918 | 0.0473918 | 0.00064 | 0.000167679 | 0.000167679
6 x Plate | PLT12*146.5 | +56.735 | +56.747 | 4 | 99 | 3.7 | 0 | 23.9 | 0.1 | 146.5 | 12 | 265 | -38ANp302 | 0.087521 | 0.087521 | 0.001758 | 0.00046587 | 0.00046587
3 x Plate | PLT10*204.3 | +58.071 | +58.317 | 4 | 99 | 3 | 0 | 28.2 | 0.1 | 204.3 | 10 | 296.6 | -38ANp300 | 0.0832007 | 0.0606055 | 0.0001 | 0.000375543 | 0.000375543
18 x Plate | FL12*90 | +56.735 | +56.747 | 4 | 99 | 2.2 | 0 | 24.9 | 0.1 | 90 | 12 | 265 | -38ANp53 | 0.05622 | 0.05622 | 0.00108 | 0.0002862 | 0.0002862
3 x Plate | PLT10*204.3 | +58.071 | +58.317 | 4 | 99 | 3 | 0 | 28.2 | 0.1 | 204.3 | 10 | 296.6 | -38ANp300 | 0.0832006 | 0.0606055 | 0.0001 | 0.000375543 | 0.000375543
4 x Plate | PLT10*204.4 | +56.747 | +56.974 | 4 | 99 | 2.8 | 0 | 28.2 | 0.1 | 204.3 | 10 | 261.9 | -38ANp299 | 0.0796498 | 0.0535223 | 0.0001 | 0.000360051 | 0.000360051
3 x Plate | PLT6*79.5 | +58.068 | +58.503 | 5 | 99 | 1.6 | 0 | 46.2 | 0.1 | 79.5 | 6 | 435.8 | -38ANp303 | 0.0752055 | 0.0346461 | 0.000036 | 0.000207277 | 0.000207277
3 x Plate | PLT10*116.8 | +58.538 | +58.550 | 5 | 99 | 1.1 | 0 | 29.7 | 0 | 116.8 | 10 | 144.2 | -38ANp41 | 0.0322072 | 0.0168422 | 0.0001 | 0.000137747 | 0.000137747
Plate | PLT10*212.3 | +57.160 | +57.170 | 3 | 99 | 3 | 0 | 28.1 | 0.1 | 212.3 | 10 | 281.5 | -38ANp287 | 0.0852131 | 0.0597613 | 0.0001 | 0.00038644 | 0.000387565
Plate | PLT10*220.9 | +57.160 | +57.170 | 3 | 99 | 3 | 0 | 28.1 | 0.1 | 220.9 | 10 | 247.2 | -38ANp286 | 0.0855569 | 0.0546158 | 0.0001 | 0.000387764 | 0.000388889
Plate | PLT10*209.4 | +57.160 | +57.170 | 3 | 99 | 2.8 | 0 | 28.2 | 0.1 | 209.4 | 10 | 235.2 | -38ANp285 | 0.0783404 | 0.0492581 | 0.0001 | 0.00035368 | 0.000354805
2 x Plate | PLT10*191.4 | +57.160 | +57.170 | 3 | 99 | 8.8 | 0.1 | 27.2 | 0.2 | 191.4 | 10 | 597.2 | -38ANp301 | 0.239582 | 0.114297 | 0.0001 | 0.00112163 | 0.00112163
Plate | FL10*150 | +57.073 | +57.264 | 3 | 99 | 2.2 | 0 | 28.5 | 0.1 | 150 | 10 | 191 | -38ANp195 | 0.06412 | 0.06412 | 0.0015 | 0.0002865 | 0.0002865
2 x Plate | FL10*150 | +57.116 | +57.240 | 3 | 99 | 1.4 | 0 | 29.3 | 0 | 124 | 10 | 124 | -38ANp203 | 0.04268 | 0.04268 | 0.0015 | 0.000186 | 0.000186
Plate | FL10*150 | +57.073 | +57.264 | 3 | 99 | 2.2 | 0 | 28.5 | 0.1 | 150 | 10 | 191 | -38ANp204 | 0.06412 | 0.06412 | 0.0015 | 0.0002865 | 0.0002865
6 x Plate | PLT10*215.9 | +57.160 | +57.170 | 3 | 99 | 3.3 | 0 | 28.1 | 0.1 | 215.9 | 10 | 321.6 | -38ANp297 | 0.0938833 | 0.0694363 | 0.0001 | 0.000426272 | 0.000426272
6 x Plate | PLT10*215.9 | +57.160 | +57.170 | 3 | 99 | 3.3 | 0 | 28.1 | 0.1 | 215.9 | 10 | 321.6 | -38ANp297 | 0.0938858 | 0.0694391 | 0.0001 | 0.000426283 | 0.000426283
3 x Plate | PLT10*232.6 | +57.160 | +57.170 | 3 | 99 | 3 | 0 | 28.1 | 0.1 | 232.6 | 10 | 237.7 | -38ANp284 | 0.0854497 | 0.0552896 | 0.0001 | 0.000387188 | 0.000388313
4 x Plate | FL10*150 | +57.148 | +57.240 | 3 | 99 | 1.1 | 0 | 29.9 | 0 | 92 | 10 | 92 | -38ANp26 | 0.03244 | 0.03244 | 0.0015 | 0.000138 | 0.000138
2 x Plate | PLT10*212.7 | +57.160 | +57.170 | 3 | 99 | 3.3 | 0 | 28.1 | 0.1 | 212.7 | 10 | 316.8 | -38ANp296 | 0.0916816 | 0.0673771 | 0.0001 | 0.000415869 | 0.000415869
2 x Plate | PLT10*212.7 | +57.160 | +57.170 | 3 | 99 | 3.3 | 0 | 28.1 | 0.1 | 212.7 | 10 | 316.8 | -38ANp296 | 0.0916825 | 0.067378 | 0.0001 | 0.000415873 | 0.000415873
Plate | PLT10*219.7 | +57.160 | +57.170 | 3 | 99 | 3 | 0 | 28.2 | 0.1 | 219.7 | 10 | 241.9 | -38ANp279 | 0.0825452 | 0.0531436 | 0.0001 | 0.000373347 | 0.000374472
4 x Plate | FL10*150 | +56.820 | +57.240 | 3 | 99 | 4.8 | 0 | 27.8 | 0.1 | 150 | 10 | 420.2 | p47 | 0.137464 | 0.137464 | 0.0015 | 0.0006303 | 0.0006303
2 x Plate | PLT10*233 | +57.160 | +57.170 | 3 | 99 | 3 | 0 | 28.1 | 0.1 | 233 | 10 | 237.7 | -38ANp284 | 0.0854358 | 0.0553835 | 0.0001 | 0.000387098 | 0.000388223
Plate | PLT10*116 | +57.124 | +57.240 | 3 | 99 | 1.4 | 0 | 29.3 | 0 | 116 | 10 | 160 | -38ANp27 | 0.04264 | 0.04264 | 0.0016 | 0.0001856 | 0.0001856
2 x Plate | PLT12*90.7 | +56.601 | +57.257 | 3 | 99 | 5.5 | 0 | 24.5 | 0.1 | 90.7 | 12 | 656.8 | p118 | 0.134862 | 0.0595718 | 0.000144 | 0.000704061 | 0.000704061
Plate | PLT10*116 | +57.124 | +57.240 | 3 | 99 | 1.4 | 0 | 29.3 | 0 | 116 | 10 | 160 | -38ANp295 | 0.04264 | 0.04264 | 0.0016 | 0.0001856 | 0.0001856
Plate | PLT10*116.4 | +57.160 | +57.170 | 3 | 99 | 2.2 | 0 | 28.9 | 0.1 | 116.4 | 10 | 305.3 | p67 | 0.0624195 | 0.0355211 | 0.0001 | 0.000274864 | 0.000274864
2 x Plate | PLT12*90.7 | +56.601 | +57.257 | 3 | 99 | 5.5 | 0 | 24.5 | 0.1 | 90.7 | 12 | 656.8 | -38ANp23 | 0.134862 | 0.0595718 | 0.000144 | 0.000704061 | 0.000704061
Plate | PLT10*225.2 | +57.160 | +57.170 | 3 | 99 | 3 | 0 | 28.2 | 0.1 | 225.2 | 10 | 230.5 | -38ANp282 | 0.0807422 | 0.0519292 | 0.0001 | 0.000364929 | 0.000366052
5 x Plate | FL10*150 | +56.972 | +57.240 | 3 | 99 | 3.2 | 0 | 28.1 | 0.1 | 150 | 10 | 267.8 | p45 | 0.088696 | 0.088696 | 0.0015 | 0.0004017 | 0.0004017
6 x Plate | FL10*150 | +56.972 | +57.240 | 3 | 99 | 3.2 | 0 | 28.1 | 0.1 | 150 | 10 | 268 | p45 | 0.08876 | 0.08876 | 0.0015 | 0.000402 | 0.000402
Plate | FL10*150 | +56.972 | +57.240 | 3 | 99 | 3.2 | 0 | 28.1 | 0.1 | 150 | 10 | 267.8 | p46 | 0.088696 | 0.088696 | 0.0015 | 0.0004017 | 0.0004017
Plate | PLT10*177.4 | +57.160 | +57.170 | 3 | 99 | 3.1 | 0 | 28.1 | 0.1 | 177.4 | 10 | 297.5 | -38ANp281 | 0.0880536 | 0.0527662 | 0.0001 | 0.000398775 | 0.0003999
Plate | PLT10*177.4 | +57.160 | +57.170 | 3 | 99 | 3.1 | 0 | 28.1 | 0.1 | 177.4 | 10 | 297.5 | -38ANp281 | 0.0880535 | 0.0527661 | 0.0001 | 0.000398775 | 0.0003999
Plate | PLT10*232.6 | +57.160 | +57.170 | 3 | 99 | 3 | 0 | 28.1 | 0.1 | 232.6 | 10 | 235.7 | -38ANp280 | 0.0845923 | 0.0548232 | 0.0001 | 0.000383097 | 0.000384222
2 x Plate | FL12*150 | +56.670 | +57.240 | 3 | 99 | 8 | 0 | 23.5 | 0.2 | 150 | 12 | 569.5 | p122 | 0.188118 | 0.188118 | 0.0018 | 0.0010251 | 0.0010251
Plate | PLT10*220.1 | +57.160 | +57.170 | 3 | 99 | 3 | 0 | 28.2 | 0.1 | 220.1 | 10 | 241.9 | -38ANp279 | 0.0825653 | 0.0532518 | 0.0001 | 0.000373423 | 0.000374548
2 x Plate | FL10*150 | +57.073 | +57.240 | 3 | 99 | 2 | 0 | 28.7 | 0.1 | 150 | 10 | 167.2 | -38ANp211 | 0.056504 | 0.056504 | 0.0015 | 0.0002508 | 0.0002508
4 x Plate | PLT12*179.4 | +56.625 | +56.804 | 1 | 99 | 4.2 | 0 | 23.6 | 0.1 | 179.4 | 12 | 256 | p123 | 0.102303 | 0.0459266 | 0.000144 | 0.000551119 | 0.000551119
Plate | PLT12*179.4 | +56.624 | +56.804 | 1 | 99 | 4.2 | 0 | 23.6 | 0.1 | 179.4 | 12 | 256 | p123 | 0.102303 | 0.0459266 | 0.000144 | 0.000551119 | 0.000551119
18 x Plate | FL6*40 | +57.720 | +57.760 | 12 | 99 | 0.2 | 0 | 51.8 | 0 | 40 | 6 | 85 | p646 | 0.0083 | 0.0034 | 0.000036 | 0.0000204 | 0.0000204
6 x Plate | PLT10*303.9 | +58.394 | +58.409 | 5 | 99 | 6.6 | 0 | 27.2 | 0.2 | 303.9 | 10 | 318.1 | p44 | 0.181045 | 0.0966708 | 0.0001 | 0.000848897 | 0.000848897
6 x Plate | PL8*160 | +57.270 | +57.430 | 3 | 99 | 1.7 | 0 | 35 | 0.1 | 160 | 8 | 164.9 | p284 | 0.058 | 0.0264 | 0.000064 | 0.0002112 | 0.0002112
6 x Plate | PL8*140 | +57.280 | +57.420 | 3 | 99 | 2 | 0 | 34.8 | 0.1 | 140 | 8 | 218.4 | p283 | 0.0669012 | 0.030583 | 0.000064 | 0.000244664 | 0.000244664
3 x Plate | FL5*40 | +57.314 | +57.354 | 12 | 99 | 0.7 | 0 | 57.8 | 0 | 40 | 5 | 520 | p589 | 0.0472 | 0.0472 | 0.0002 | 0.000104 | 0.000104
12 x Plate | FL5*40 | +57.315 | +57.355 | 12 | 99 | 0.9 | 0 | 57.8 | 0.1 | 40 | 5 | 561 | p588 | 0.05089 | 0.05089 | 0.0002 | 0.0001122 | 0.0001122
3 x Plate | FL5*40 | +57.315 | +57.355 | 12 | 99 | 0.7 | 0 | 57.8 | 0 | 40 | 5 | 520 | p589 | 0.0472 | 0.0472 | 0.0002 | 0.000104 | 0.000104
Plate | PL10*79.5 | +57.192 | +57.202 | 5 | 99 | 1.7 | 0 | 29.5 | 0.1 | 79.5 | 10 | 283.4 | p274 | 0.0501671 | 0.0225303 | 0.0001 | 0.000216303 | 0.000216303
11 x Plate | PL10*79.5 | +57.625 | +57.635 | 5 | 99 | 0.7 | 0 | 30.4 | 0 | 79.5 | 10 | 137.9 | p273 | 0.0241226 | 0.010963 | 0.0001 | 0.00010063 | 0.00010063
11 x Plate | PL10*79.5 | +57.407 | +57.417 | 5 | 99 | 0.7 | 0 | 30.4 | 0 | 79.5 | 10 | 137.9 | p273 | 0.0241226 | 0.010963 | 0.0001 | 0.00010063 | 0.00010063
6 x Plate | PL60*50 | +57.831 | +57.881 | 5 | 1 | 3.9 | 0 | 10.8 | 0 | 50 | 60 | 170 | p685 | 0.0434 | 0.0434 | 0.0102 | 0.00051 | 0.00051
6 x Plate | PL60*50 | +57.161 | +57.211 | 5 | 1 | 3.9 | 0 | 10.8 | 0 | 50 | 60 | 170 | p685 | 0.0434 | 0.0434 | 0.0102 | 0.00051 | 0.00051
6 x Plate | PL12*250 | +57.156 | +57.886 | 5 | 99 | 17.2 | 0 | 22.6 | 0.3 | 250 | 12 | 730 | p144 | 0.38852 | 0.38852 | 0.003 | 0.00219 | 0.00219
6 x Plate | PL10*196 | +57.156 | +57.886 | 5 | 99 | 11.1 | 0 | 27.1 | 0.3 | 196 | 10 | 730 | p275 | 0.30468 | 0.14308 | 0.0001 | 0.0014308 | 0.0014308
6 x Plate | PL60*50 | +58.665 | +58.715 | 5 | 1 | 3.9 | 0 | 10.8 | 0 | 50 | 60 | 170 | p685 | 0.0434 | 0.0434 | 0.0102 | 0.00051 | 0.00051
6 x Plate | PL60*50 | +57.995 | +58.045 | 5 | 1 | 3.9 | 0 | 10.8 | 0 | 50 | 60 | 170 | p685 | 0.0434 | 0.0434 | 0.0102 | 0.00051 | 0.00051
6 x Plate | PL12*250 | +57.990 | +58.720 | 5 | 99 | 17.2 | 0 | 22.6 | 0.3 | 250 | 12 | 730 | p144 | 0.38852 | 0.38852 | 0.003 | 0.00219 | 0.00219
10 x Plate | PLT6*172.1 | +57.075 | +57.262 | 3 | 99 | 0.9 | 0 | 46 | 0 | 172.1 | 6 | 187.6 | p233 | 0.0480321 | 0.032286 | 0.000036 | 0.000133148 | 0.000133148
10 x Plate | FL10*100 | +57.260 | +57.270 | 3 | 99 | 0.9 | 0 | 30.4 | 0 | 100 | 10 | 108.3 | p276 | 0.025826 | 0.025826 | 0.001 | 0.0001083 | 0.0001083
6 x Plate | PLT10*217 | +57.310 | +57.320 | 5 | 99 | 4.2 | 0.1 | 27.6 | 0.1 | 217 | 10 | 283.4 | p43 | 0.118327 | 0.0614979 | 0.0001 | 0.000546991 | 0.000546991
Plate | PL10*79.5 | +57.407 | +57.417 | 5 | 99 | 0.7 | 0 | 30.4 | 0 | 79.5 | 10 | 137.9 | p273 | 0.0241494 | 0.010975 | 0.0001 | 0.00010075 | 0.00010075
Plate | PL10*79.5 | +57.625 | +57.635 | 5 | 99 | 0.7 | 0 | 30.4 | 0 | 79.5 | 10 | 137.9 | p273 | 0.0241494 | 0.010975 | 0.0001 | 0.00010075 | 0.00010075
6 x Plate | PL12*151 | +56.747 | +56.898 | 12 | 99 | 11.6 | 0 | 23.2 | 0.3 | 151 | 12 | 820 | p156 | 0.270944 | 0.270944 | 0.001812 | 0.00148584 | 0.00148584
6 x Plate | PL12*220 | +56.735 | +56.747 | 12 | 99 | 17 | 0.2 | 22.7 | 0.3 | 220 | 12 | 820 | p146 | 0.38576 | 0.38576 | 0.00264 | 0.0021648 | 0.0021648
18 x Plate | PL12*104 | +56.747 | +56.898 | 12 | 99 | 1.2 | 0 | 25.4 | 0 | 104 | 12 | 151 | p149 | 0.0330705 | 0.0157051 | 0.000144 | 0.000165532 | 0.000165532
17 x Plate | PL12*104 | +56.747 | +56.898 | 12 | 99 | 1.2 | 0 | 25.4 | 0 | 104 | 12 | 151 | p149 | 0.0330693 | 0.0157042 | 0.000144 | 0.000165526 | 0.000165526
12 x Plate | PL60*50 | +56.950 | +57.010 | 12 | 99 | 3.9 | 0 | 10.8 | 0 | 50 | 60 | 170 | p685 | 0.0434 | 0.0434 | 0.0102 | 0.00051 | 0.00051
Plate | PL12*104 | +56.747 | +56.898 | 12 | 99 | 1.4 | 0 | 25.3 | 0 | 104 | 12 | 151 | p150 | 0.0353056 | 0.0157044 | 0.000144 | 0.000177645 | 0.000177645
21 x Plate | PL6*47.5 | +58.337 | +58.412 | 4 | 99 | 0.1 | 0 | 52.5 | 0 | 47.5 | 6 | 75 | p643 | 0.00682129 | 0.0035625 | 0.000036 | 0.0000165375 | 0.0000165375
20 x Plate | FL6*80 | +58.412 | +58.418 | 4 | 99 | 0.7 | 0 | 47.1 | 0 | 80 | 6 | 170 | p217 | 0.0302 | 0.0302 | 0.00048 | 0.0000816 | 0.0000816
21 x Plate | PL6*47.5 | +58.337 | +58.412 | 4 | 99 | 0.1 | 0 | 52.5 | 0 | 47.5 | 6 | 75 | p643 | 0.00682129 | 0.00356249 | 0.000036 | 0.0000165375 | 0.0000165375
42 x Plate | PL6*47.5 | +58.337 | +58.412 | 4 | 99 | 0.1 | 0 | 52.5 | 0 | 47.5 | 6 | 75 | p643 | 0.00682337 | 0.003564 | 0.000036 | 0.0000165432 | 0.0000165432
30 x Plate | PLT6*130 | +58.164 | +58.170 | 4 | 99 | 0.7 | 0 | 46.2 | 0 | 130 | 6 | 135 | p216 | 0.0373394 | 0.03828 | 0.00078 | 0.0001029 | 0.0001053
30 x Plate | FL6*60 | +58.328 | +58.334 | 4 | 99 | 0.1 | 0 | 55.7 | 0 | 34 | 6 | 34 | p215 | 0.00449439 | 0.00115613 | 0.000036 | 0.0000102777 | 0.0000102777
30 x Plate | PLT8*150.3 | +58.328 | +58.336 | 4 | 99 | 1.1 | 0 | 35.6 | 0 | 150.3 | 8 | 151 | p415 | 0.0407805 | 0.0226905 | 0.000064 | 0.000145917 | 0.000145917
30 x Plate | PLT8*150.3 | +58.245 | +58.253 | 4 | 99 | 1.1 | 0 | 35.6 | 0 | 150.3 | 8 | 151 | p415 | 0.0407805 | 0.0226905 | 0.000064 | 0.000145917 | 0.000145917
30 x Plate | PLT6*130 | +58.411 | +58.417 | 4 | 99 | 0.7 | 0 | 46.2 | 0 | 130 | 6 | 135 | p216 | 0.0373394 | 0.03828 | 0.00078 | 0.0001029 | 0.0001053
6 x Plate | FL10*100 | +58.317 | +58.417 | 4 | 99 | 1.1 | 0 | 29.7 | 0 | 100 | 10 | 140 | p278 | 0.0317243 | 0.014 | 0.0001 | 0.0001355 | 0.0001355
24 x Plate | PLT6*75 | +56.747 | +56.897 | 4 | 99 | 0.3 | 0 | 49.3 | 0 | 75 | 6 | 150 | p214 | 0.0167815 | 0.01125 | 0.000036 | 0.00004335 | 0.00004335
22 x Plate | FL6*80 | +58.412 | +58.418 | 4 | 99 | 0.7 | 0 | 47.1 | 0 | 80 | 6 | 170 | p212 | 0.0302 | 0.0302 | 0.00048 | 0.0000816 | 0.0000816
15 x Plate | PLT6*75 | +57.282 | +57.432 | 4 | 99 | 0.3 | 0 | 49.3 | 0 | 75 | 6 | 150 | p214 | 0.0167815 | 0.01125 | 0.000036 | 0.00004335 | 0.00004335
15 x Plate | FL12*80 | +57.270 | +57.282 | 4 | 99 | 2 | 0 | 25.4 | 0.1 | 80 | 12 | 265 | p125 | 0.05068 | 0.05068 | 0.00096 | 0.0002544 | 0.0002544
5 x Plate | FL20*60 | +58.317 | +58.337 | 4 | 99 | 2 | 0 | 18.1 | 0 | 60 | 20 | 210 | p179 | 0.036 | 0.036 | 0.0042 | 0.000252 | 0.000252
7 x Plate | FL20*60 | +58.317 | +58.337 | 4 | 99 | 2 | 0 | 18.1 | 0 | 60 | 20 | 210 | p178 | 0.036 | 0.036 | 0.0042 | 0.000252 | 0.000252
Plate | FL8*80 | +58.227 | +58.307 | 4 | 99 | 1.2 | 0 | 36 | 0 | 80 | 8 | 253.9 | p282 | 0.0473918 | 0.0473918 | 0.00064 | 0.000167679 | 0.000167679
Plate | L125*75*10 | +55.492 | +55.567 | 3 | 99 | 4.2 | 0 | 26 | 0.1 | 125 | 75 | 285 | m719 | 0.111309 | 0.111309 | 0.00191083 | 0.0005395 | 0.000544586
2 x Plate | FL10*110 | +55.725 | +55.735 | 3 | 99 | 2.2 | 0 | 28.7 | 0.1 | 110 | 10 | 250.3 | p279 | 0.0622675 | 0.0622675 | 0.0011 | 0.000275309 | 0.000275309
Plate | L125*75*10 | +55.650 | +55.725 | 3 | 99 | 6.2 | 0.1 | 26 | 0.2 | 125 | 75 | 410.3 | m718 | 0.160238 | 0.160238 | 0.00191083 | 0.000777534 | 0.000783976
Plate | L125*75*10 | +55.492 | +55.567 | 3 | 99 | 4.2 | 0 | 26 | 0.1 | 125 | 75 | 285 | m717 | 0.111309 | 0.111309 | 0.00191083 | 0.0005395 | 0.000544586
Plate | L125*75*10 | +55.650 | +55.725 | 3 | 99 | 6.2 | 0.1 | 26 | 0.2 | 125 | 75 | 410.3 | m716 | 0.160238 | 0.160238 | 0.00191083 | 0.000777534 | 0.000783976
6 x Plate | PL12*170 | +57.764 | +58.082 | 5 | 99 | 12.8 | 0 | 23 | 0.3 | 170 | 12 | 801.1 | p143 | 0.295681 | 0.295681 | 0.00204 | 0.00163425 | 0.00163425
6 x Plate | PLT12*282.5 | +57.775 | +58.093 | 5 | 99 | 11.1 | 0 | 23.2 | 0.3 | 282.5 | 12 | 801.1 | p126 | 0.257073 | 0.226307 | 0.000144 | 0.00140981 | 0.00140981
6 x Plate | PLT10*79.5 | +58.092 | +58.528 | 5 | 99 | 2.6 | 0 | 29.3 | 0.1 | 79.5 | 10 | 435.8 | p97 | 0.0774467 | 0.0346461 | 0.0001 | 0.000337461 | 0.000337461
12 x Plate | PLT10*79.5 | +57.982 | +58.417 | 5 | 99 | 2.6 | 0 | 29.3 | 0.1 | 79.5 | 10 | 435.8 | p97 | 0.077428 | 0.0346378 | 0.0001 | 0.000337378 | 0.000337378
