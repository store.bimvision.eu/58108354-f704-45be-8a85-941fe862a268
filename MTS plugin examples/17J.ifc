Properties of the parts of a building model (IFC2X3), part 10 of 16

# IfcDiscreteAccessory: Plate (5440)
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
6 x Plate | PL12*170 | +57.398 | +57.971 | 5 | 99 | 19.5 | 0 | 23 | 0.3 | 170 | 12 | 1217.6 | p140 | 0.447286 | 0.447286 | 0.00204 | 0.0024839 | 0.0024839
6 x Plate | FL12*60 | +57.397 | +57.409 | 5 | 99 | 0.9 | 0 | 27 | 0 | 60 | 12 | 170 | p142 | 0.02592 | 0.02592 | 0.00204 | 0.0001224 | 0.0001224
6 x Plate | PLT12*496.7 | +57.409 | +57.971 | 5 | 99 | 30.8 | 0 | 22.4 | 0.6 | 496.7 | 12 | 1270.8 | p127 | 0.688254 | 0.631276 | 0.000144 | 0.00391753 | 0.00391753
6 x Plate | PLT3*400 | +57.321 | +57.721 | 5 | 99 | 2.8 | 0 | 88 | 0.2 | 400 | 3 | 560.1 | p398 | 0.245934 | 0.224038 | 0.000009 | 0.000356151 | 0.000672111
3 x Plate | BL3*78.7 | +58.081 | +58.111 | 5 | 3 | 2.7 | 0.1 | 88.3 | 0.2 | 78.6 | 3 | 1470 | m713 | 0.240729 | 0.240729 | 0.00441 | 0.000347156 | 0.000347156
3 x Plate | PLT6*130 | +57.006 | +57.136 | 5 | 99 | 1.2 | 0 | 45.8 | 0.1 | 130 | 6 | 183 | p211 | 0.0529641 | 0.0529641 | 0.00078 | 0.000147409 | 0.000147409
3 x Plate | FL6*110 | +57.906 | +58.016 | 5 | 99 | 0.9 | 0 | 46.1 | 0 | 110 | 6 | 183 | p210 | 0.0451647 | 0.0451647 | 0.00066 | 0.00012473 | 0.00012473
3 x Plate | PLT6*130 | +57.006 | +57.136 | 5 | 99 | 1.2 | 0 | 45.8 | 0.1 | 130 | 6 | 183 | p211 | 0.052972 | 0.052972 | 0.00078 | 0.000147431 | 0.000147431
3 x Plate | FL6*110 | +57.906 | +58.016 | 5 | 99 | 0.9 | 0 | 46.1 | 0 | 110 | 6 | 183 | p210 | 0.0451714 | 0.0451714 | 0.00066 | 0.00012475 | 0.00012475
6 x Plate | PL10*120 | +58.005 | +58.015 | 5 | 99 | 1.4 | 0 | 29.1 | 0 | 120 | 10 | 196 | p263 | 0.0446468 | 0.02352 | 0.0001 | 0.000195212 | 0.000195212
6 x Plate | PL10*120 | +58.005 | +58.015 | 5 | 99 | 1.4 | 0 | 29.1 | 0 | 120 | 10 | 196 | p263 | 0.0446468 | 0.02352 | 0.0001 | 0.000195211 | 0.000195211
6 x Plate | PL10*196 | +57.990 | +58.720 | 5 | 99 | 11.1 | 0 | 27.1 | 0.3 | 196 | 10 | 730 | p275 | 0.30468 | 0.14308 | 0.0001 | 0.0014308 | 0.0014308
6 x Plate | PLT6*156.7 | +57.962 | +58.397 | 5 | 99 | 2.6 | 0 | 44.9 | 0.1 | 156.7 | 6 | 435.2 | p230 | 0.116891 | 0.0681958 | 0.000036 | 0.000330912 | 0.000330912
6 x Plate | FL8*70 | +58.617 | +58.687 | 5 | 99 | 0.7 | 0 | 37 | 0 | 70 | 8 | 165.1 | p414 | 0.0268756 | 0.011557 | 0.000064 | 0.000092456 | 0.000092456
6 x Plate | FL8*70 | +59.217 | +59.287 | 5 | 99 | 0.7 | 0 | 37 | 0 | 70 | 8 | 165.1 | p414 | 0.0268756 | 0.011557 | 0.000064 | 0.000092456 | 0.000092456
6 x Plate | FL8*80 | +58.547 | +58.556 | 5 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 165.1 | p413 | 0.0303376 | 0.013208 | 0.000064 | 0.000105664 | 0.000105664
6 x Plate | FL8*80 | +58.539 | +58.548 | 5 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 165.1 | p413 | 0.0303376 | 0.013208 | 0.000064 | 0.000105664 | 0.000105664
12 x Plate | PLT10*79.5 | +57.175 | +57.185 | 5 | 99 | 0.7 | 0 | 30.4 | 0 | 79.5 | 10 | 137.9 | p95 | 0.0241495 | 0.010975 | 0.0001 | 0.00010075 | 0.00010075
3 x Plate | PLT12*136.4 | +57.063 | +57.244 | 5 | 99 | 2.1 | 0 | 24.5 | 0.1 | 136.4 | 12 | 181.2 | p129 | 0.0511398 | 0.0247066 | 0.000144 | 0.000266971 | 0.000266971
3 x Plate | PLT12*97.9 | +57.063 | +57.244 | 5 | 99 | 1.6 | 0 | 25.3 | 0 | 97.9 | 12 | 181.2 | p115 | 0.0399749 | 0.0177485 | 0.000144 | 0.000202182 | 0.000202182
3 x Plate | PLT12*136.2 | +57.330 | +57.711 | 5 | 99 | 4.2 | 0 | 23.9 | 0.1 | 136.2 | 12 | 380.8 | p128 | 0.098555 | 0.051865 | 0.000144 | 0.000525318 | 0.000525318
3 x Plate | PLT12*85 | +57.330 | +57.711 | 5 | 99 | 3 | 0 | 24.9 | 0.1 | 85 | 12 | 380.8 | p114 | 0.0736934 | 0.032368 | 0.000144 | 0.000377616 | 0.000377616
3 x Plate | PLT10*136.9 | +56.992 | +57.192 | 5 | 99 | 1.7 | 0 | 28.9 | 0.1 | 137 | 10 | 200 | p42 | 0.0502818 | 0.02739 | 0.0001 | 0.000221812 | 0.000221812
6 x Plate | PLT20*147 | +56.972 | +56.992 | 5 | 99 | 7.6 | 0 | 15.3 | 0.1 | 147 | 20 | 330 | p177 | 0.1161 | 0.1161 | 0.00294 | 0.0009702 | 0.0009702
6 x Plate | PLT10*79.5 | +57.175 | +57.185 | 5 | 99 | 1.7 | 0 | 29.5 | 0.1 | 79.5 | 10 | 283.4 | p96 | 0.0501671 | 0.0225303 | 0.0001 | 0.000216303 | 0.000216303
3 x Plate | PLT10*136.9 | +56.992 | +57.192 | 5 | 99 | 1.7 | 0 | 28.9 | 0.1 | 137 | 10 | 200 | p41 | 0.0507591 | 0.02739 | 0.0001 | 0.0002241 | 0.0002241
36 x Plate | PL12*76.6 | +57.270 | +57.603 | 3 | 99 | 2.2 | 0 | 25.4 | 0.1 | 76.6 | 12 | 332.9 | p148 | 0.0571441 | 0.0254912 | 0.000144 | 0.000286324 | 0.000286324
12 x Plate | PL50*50 | +57.647 | +57.697 | 3 | 1 | 0.9 | 0 | 15.3 | 0 | 50 | 50 | 50 | p595 | 0.015 | 0.015 | 0.0025 | 0.000125 | 0.000125
6 x Plate | PL12*333 | +57.270 | +57.603 | 3 | 99 | 17.8 | 0 | 22.4 | 0.3 | 333 | 12 | 580 | p169 | 0.400009 | 0.408192 | 0.003996 | 0.00226121 | 0.00231768
6 x Plate | FL12*150 | +57.603 | +57.615 | 3 | 99 | 8.5 | 0.1 | 23.5 | 0.2 | 150 | 12 | 600 | p139 | 0.198 | 0.198 | 0.0018 | 0.00108 | 0.00108
3 x Plate | PLT6*105 | +57.282 | +57.432 | 4 | 99 | 0.5 | 0 | 48.1 | 0 | 105 | 6 | 150 | p213 | 0.0221465 | 0.01575 | 0.000036 | 0.00005865 | 0.00005865
3 x Plate | FL12*80 | +57.270 | +57.282 | 4 | 99 | 2.2 | 0 | 25.3 | 0.1 | 80 | 12 | 295 | p124 | 0.0562 | 0.0562 | 0.00096 | 0.0002832 | 0.0002832
4 x Plate | PL12*90.7 | +56.601 | +57.257 | 3 | 99 | 5.5 | 0 | 24.5 | 0.1 | 90.7 | 12 | 656.8 | p138 | 0.134862 | 0.0595718 | 0.000144 | 0.000704061 | 0.000704061
Plate | PLT8*291.9 | +56.767 | +57.173 | 3 | 99 | 5.3 | 0 | 33.5 | 0.2 | 291.9 | 8 | 402.9 | p439 | 0.180632 | 0.117588 | 0.000064 | 0.000686717 | 0.000686717
11 x Plate | PL10*95 | +56.827 | +56.954 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 127.5 | p247 | 0.0247588 | 0.0121135 | 0.0001 | 0.000104396 | 0.000104396
6 x Plate | PL10*200 | +56.952 | +56.967 | 1 | 99 | 3.2 | 0 | 28 | 0.1 | 200 | 10 | 206.1 | p243 | 0.0905699 | 0.0412238 | 0.0001 | 0.000412238 | 0.000412238
6 x Plate | PL10*140 | +56.817 | +56.827 | 1 | 99 | 2.3 | 0 | 28.5 | 0.1 | 140 | 10 | 205.5 | p242 | 0.0644472 | 0.0287687 | 0.0001 | 0.000287687 | 0.000287687
Plate | PL10*95 | +56.827 | +56.954 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 127.5 | p247 | 0.0247586 | 0.0121135 | 0.0001 | 0.000104395 | 0.000104395
2 x Plate | PLT6*187.6 | +57.075 | +57.262 | 3 | 99 | 1.2 | 0 | 45.8 | 0.1 | 187.6 | 6 | 202.1 | p234 | 0.0544815 | 0.037914 | 0.000036 | 0.000151634 | 0.000151634
2 x Plate | FL10*100 | +57.260 | +57.270 | 3 | 99 | 1.1 | 0 | 29.9 | 0 | 100 | 10 | 138.3 | p277 | 0.032426 | 0.032426 | 0.001 | 0.0001383 | 0.0001383
2 x Plate | FL12*200 | +56.817 | +56.829 | 3 | 99 | 8.5 | 0.1 | 23.1 | 0.2 | 200 | 12 | 458 | p136 | 0.198992 | 0.0916 | 0.000144 | 0.0010992 | 0.0010992
4 x Plate | FL12*180 | +56.805 | +56.817 | 1 | 99 | 6.9 | 0.1 | 23.2 | 0.2 | 180 | 12 | 408 | p135 | 0.160992 | 0.07344 | 0.000144 | 0.00088128 | 0.00088128
2 x Plate | FL12*180 | +56.805 | +56.817 | 1 | 99 | 6.9 | 0.1 | 23.2 | 0.2 | 180 | 12 | 408 | p133 | 0.160992 | 0.07344 | 0.000144 | 0.00088128 | 0.00088128
2 x Plate | FL12*200 | +56.805 | +56.817 | 1 | 99 | 7.6 | 0.1 | 23.1 | 0.2 | 200 | 12 | 408 | p132 | 0.177792 | 0.0816 | 0.000144 | 0.0009792 | 0.0009792
Plate | FL12*180 | +56.805 | +56.817 | 1 | 99 | 6.9 | 0.1 | 23.2 | 0.2 | 180 | 12 | 408 | p134 | 0.160992 | 0.07344 | 0.000144 | 0.00088128 | 0.00088128
2 x Plate | FL20*70 | +55.537 | +55.557 | 3 | 99 | 1.7 | 0 | 18 | 0 | 70 | 20 | 160 | A826 | 0.0316 | 0.0316 | 0.0032 | 0.000224 | 0.000224
2 x Plate | FL20*70 | +55.695 | +55.715 | 3 | 99 | 1.7 | 0 | 18 | 0 | 70 | 20 | 160 | A826 | 0.0316 | 0.0316 | 0.0032 | 0.000224 | 0.000224
Plate | FL8*50 | +56.710 | +56.764 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70.8 | p523 | 0.00891806 | 0.00353914 | 0.000064 | 0.0000279928 | 0.0000279928
Plate | FL8*60 | +56.565 | +56.637 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170.7 | p459 | 0.024017 | 0.0102392 | 0.000064 | 0.0000813515 | 0.0000813515
2 x Plate | FL8*50 | +57.410 | +57.474 | 2 | 99 | 0.7 | 0 | 38.4 | 0 | 50 | 8 | 180.4 | p484 | 0.0216869 | 0.00901746 | 0.000064 | 0.0000720236 | 0.0000720236
Plate | FL8*80 | +58.279 | +58.292 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 145 | p486 | 0.0267968 | 0.0115986 | 0.000064 | 0.0000927885 | 0.0000927885
2 x Plate | FL8*50 | +57.485 | +57.548 | 2 | 99 | 0.7 | 0 | 38.4 | 0 | 50 | 8 | 180.6 | p484 | 0.0216905 | 0.00903096 | 0.000064 | 0.000072036 | 0.000072036
Plate | FL8*80 | +58.176 | +58.190 | 2 | 99 | 0.7 | 0 | 36.7 | 0 | 80 | 8 | 150 | p467 | 0.027677 | 0.0119986 | 0.000064 | 0.0000959892 | 0.0000959892
Plate | FL8*80 | +57.992 | +58.008 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 140.3 | p492 | 0.0259949 | 0.011234 | 0.000064 | 0.0000898723 | 0.0000898723
2 x Plate | FL8*60 | +57.159 | +57.226 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 172.4 | p459 | 0.0240625 | 0.0103405 | 0.000064 | 0.00008153 | 0.00008153
30 x Plate | FL6*40 | +52.152 | +52.192 | 9 | 99 | 0.2 | 0 | 51.8 | 0 | 40 | 6 | 85 | p646 | 0.00829689 | 0.00339865 | 0.000036 | 0.0000203919 | 0.0000203919
6 x Plate | PLT10*210 | +51.226 | +51.236 | 9 | 99 | 4.7 | 0.1 | 27.6 | 0.1 | 209.9 | 10 | 280 | -38AMp139 | 0.1274 | 0.1274 | 0.0021 | 0.000588 | 0.000588
6 x Plate | PLT8*120 | +50.462 | +50.672 | 9 | 99 | 1.4 | 0 | 35.2 | 0.1 | 120 | 8 | 200 | -38AMp105 | 0.05312 | 0.05312 | 0.0016 | 0.000192 | 0.000192
6 x Plate | PLT8*120 | +51.541 | +51.672 | 9 | 99 | 1.4 | 0 | 35.2 | 0.1 | 120 | 8 | 200 | -38AMp140 | 0.05312 | 0.05312 | 0.00096 | 0.000192 | 0.000192
6 x Plate | PL10*200 | +51.490 | +51.690 | 9 | 99 | 3.9 | 0 | 27.8 | 0.1 | 200 | 10 | 250 | p238 | 0.109 | 0.109 | 0.002 | 0.0005 | 0.0005
12 x Plate | PL60*50 | +52.073 | +52.133 | 9 | 99 | 3.9 | 0 | 10.8 | 0 | 50 | 60 | 170 | p685 | 0.0434 | 0.0434 | 0.0102 | 0.00051 | 0.00051
6 x Plate | FL12*180 | +52.172 | +52.184 | 9 | 99 | 11.4 | 0.1 | 23 | 0.3 | 180 | 12 | 680 | p130 | 0.26544 | 0.26544 | 0.00216 | 0.0014688 | 0.0014688
3 x Plate | PL50*50 | +50.577 | +50.627 | 9 | 1 | 0.9 | 0 | 15.3 | 0 | 50 | 50 | 50 | p595 | 0.015 | 0.015 | 0.0025 | 0.000125 | 0.000125
6 x Plate | PL50*50 | +51.117 | +51.167 | 9 | 1 | 0.9 | 0 | 15.3 | 0 | 50 | 50 | 50 | p595 | 0.015 | 0.015 | 0.0025 | 0.000125 | 0.000125
6 x Plate | FL12*150 | +50.572 | +51.172 | 9 | 99 | 8.5 | 0 | 23.5 | 0.2 | 150 | 12 | 600 | p139 | 0.198 | 0.198 | 0.0018 | 0.00108 | 0.00108
3 x Plate | PL50*50 | +50.577 | +50.627 | 9 | 1 | 0.9 | 0 | 15.3 | 0 | 50 | 50 | 50 | p590 | 0.015 | 0.015 | 0.0025 | 0.000125 | 0.000125
5 x Plate | PL12*75 | +50.572 | +51.172 | 9 | 99 | 3.9 | 0 | 25.8 | 0.1 | 75 | 12 | 600 | p168 | 0.100417 | 0.1062 | 0.0009 | 0.000497926 | 0.000540001
24 x Plate | FL5*40 | +51.448 | +51.488 | 9 | 99 | 1.1 | 0 | 57.7 | 0.1 | 40 | 5 | 670 | p586 | 0.0607 | 0.0607 | 0.0002 | 0.000134 | 0.000134
12 x Plate | FL5*40 | +51.448 | +51.488 | 9 | 99 | 0.9 | 0 | 57.8 | 0.1 | 40 | 5 | 557 | p585 | 0.05053 | 0.05053 | 0.0002 | 0.0001114 | 0.0001114
12 x Plate | PLT20*270 | +50.242 | +50.262 | 9 | 99 | 11.4 | 0.1 | 14.6 | 0.2 | 270 | 20 | 270 | -38AMp78 | 0.1674 | 0.1674 | 0.0054 | 0.001458 | 0.001458
12 x Plate | PLT12*122.7 | +52.532 | +52.544 | 9 | 99 | 2.4 | 0 | 24.5 | 0.1 | 122.7 | 12 | 225.8 | -38AMp22 | 0.0615536 | 0.0277057 | 0.000144 | 0.000321668 | 0.000321668
12 x Plate | PLT12*122.7 | +52.290 | +52.302 | 9 | 99 | 2.4 | 0 | 24.5 | 0.1 | 122.7 | 12 | 225.8 | -38AMp22 | 0.0615536 | 0.0277057 | 0.000144 | 0.000321668 | 0.000321668
24 x Plate | PLT10*122.7 | +51.238 | +51.248 | 9 | 99 | 2.1 | 0 | 28.6 | 0.1 | 122.7 | 10 | 225.8 | -38AMp18 | 0.0602298 | 0.0277057 | 0.0001 | 0.000268057 | 0.000268057
24 x Plate | PLT10*122.7 | +51.478 | +51.488 | 9 | 99 | 2.1 | 0 | 28.6 | 0.1 | 122.7 | 10 | 225.8 | -38AMp18 | 0.0602298 | 0.0277057 | 0.0001 | 0.000268057 | 0.000268057
6 x Plate | FL8*150 | +52.052 | +52.152 | 9 | 99 | 3.1 | 0 | 34.4 | 0.1 | 150 | 8 | 325 | p281 | 0.107596 | 0.107596 | 0.0012 | 0.00039948 | 0.00039948
6 x Plate | FL8*150 | +50.552 | +50.652 | 9 | 99 | 3.1 | 0 | 34.4 | 0.1 | 150 | 8 | 325 | p281 | 0.107596 | 0.107596 | 0.0012 | 0.00039948 | 0.00039948
12 x Plate | FL8*150 | +52.052 | +52.152 | 9 | 99 | 3 | 0 | 34.4 | 0.1 | 150 | 8 | 309.7 | p280 | 0.102787 | 0.102787 | 0.0012 | 0.000381216 | 0.000381216
12 x Plate | FL8*150 | +50.552 | +50.652 | 9 | 99 | 3 | 0 | 34.4 | 0.1 | 150 | 8 | 309.7 | p280 | 0.102787 | 0.102787 | 0.0012 | 0.000381216 | 0.000381216
36 x Plate | PLT12*122.7 | +52.304 | +52.530 | 9 | 99 | 2.4 | 0 | 24.5 | 0.1 | 122.7 | 12 | 225.8 | p113 | 0.0615536 | 0.0277057 | 0.000144 | 0.000321668 | 0.000321668
18 x Plate | PL12*106 | +52.184 | +52.290 | 9 | 99 | 1.1 | 0 | 25.8 | 0 | 106 | 12 | 121 | p147 | 0.0283774 | 0.0128268 | 0.000144 | 0.000140283 | 0.000140283
18 x Plate | PL12*106 | +52.184 | +52.290 | 9 | 99 | 1.1 | 0 | 25.8 | 0 | 106 | 12 | 121 | p147 | 0.0283772 | 0.0128266 | 0.000144 | 0.000140282 | 0.000140282
6 x Plate | PL12*106 | +52.184 | +52.290 | 9 | 99 | 6.9 | 0 | 23.9 | 0.2 | 106 | 12 | 680 | p155 | 0.163024 | 0.163024 | 0.001272 | 0.00086496 | 0.00086496
12 x Plate | PL12*69 | +50.582 | +50.594 | 9 | 99 | 0.5 | 0 | 28.2 | 0 | 69 | 12 | 75 | p137 | 0.0134654 | 0.005175 | 0.000144 | 0.0000609 | 0.0000609
12 x Plate | PL12*69 | +51.150 | +51.162 | 9 | 99 | 0.5 | 0 | 28.2 | 0 | 69 | 12 | 75 | p137 | 0.0134654 | 0.005175 | 0.000144 | 0.0000609 | 0.0000609
12 x Plate | PL12*69 | +50.866 | +50.878 | 9 | 99 | 0.5 | 0 | 28.2 | 0 | 69 | 12 | 75 | p137 | 0.0134654 | 0.005175 | 0.000144 | 0.0000609 | 0.0000609
Plate | PL12*75 | +50.572 | +51.172 | 9 | 99 | 4.2 | 0 | 25.1 | 0.1 | 75 | 12 | 600 | p141 | 0.1062 | 0.1062 | 0.0009 | 0.000540001 | 0.000540001
12 x Plate | PL10*95 | +50.825 | +50.965 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p246 | 0.0288627 | 0.0132978 | 0.0001 | 0.0001228 | 0.000123131
12 x Plate | PL10*95 | +50.825 | +50.955 | 1 | 99 | 0.9 | 0 | 30.1 | 0 | 95 | 10 | 130.5 | p245 | 0.0268725 | 0.0123977 | 0.0001 | 0.000113796 | 0.00011413
12 x Plate | PL10*95 | +50.825 | +50.946 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 120.6 | p244 | 0.0247941 | 0.0114578 | 0.0001 | 0.000104394 | 0.00010473
6 x Plate | PL10*200 | +50.943 | +50.977 | 1 | 99 | 4.4 | 0 | 27.6 | 0.1 | 200 | 10 | 286 | p237 | 0.124106 | 0.0571934 | 0.0001 | 0.000571934 | 0.000571934
6 x Plate | PL10*140 | +50.815 | +50.825 | 1 | 99 | 4.4 | 0.1 | 28 | 0.1 | 140 | 10 | 410 | p241 | 0.1258 | 0.0574 | 0.0001 | 0.000574 | 0.000574
6 x Plate | PLT10*95 | +52.406 | +52.546 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p71 | 0.0288627 | 0.0132978 | 0.0001 | 0.0001228 | 0.000123131
12 x Plate | PLT10*95 | +52.406 | +52.536 | 1 | 99 | 0.9 | 0 | 30.1 | 0 | 95 | 10 | 130.5 | p69 | 0.0268725 | 0.0123977 | 0.0001 | 0.000113796 | 0.00011413
6 x Plate | PLT10*95 | +52.406 | +52.527 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 120.6 | p72 | 0.0247941 | 0.0114578 | 0.0001 | 0.000104394 | 0.00010473
6 x Plate | PLT10*95 | +52.406 | +52.546 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p68 | 0.0288627 | 0.0132978 | 0.0001 | 0.0001228 | 0.000123131
6 x Plate | PLT10*95 | +52.406 | +52.527 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 120.6 | p70 | 0.0247941 | 0.0114578 | 0.0001 | 0.000104394 | 0.00010473
6 x Plate | PLT10*200 | +52.524 | +52.558 | 1 | 99 | 4.4 | 0 | 27.6 | 0.1 | 200 | 10 | 286 | p5 | 0.1241 | 0.0571904 | 0.0001 | 0.000571904 | 0.000571904
6 x Plate | PLT10*140 | +52.396 | +52.406 | 1 | 99 | 4.4 | 0.1 | 28 | 0.1 | 140 | 10 | 410 | p4 | 0.1258 | 0.0574 | 0.0001 | 0.000574 | 0.000574
Plate | FL8*60 | +52.252 | +52.267 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90 | p520 | 0.0131879 | 0.00539467 | 0.000064 | 0.0000431574 | 0.0000431574
Plate | FL8*150 | +52.252 | +52.272 | 2 | 99 | 1.2 | 0 | 35.3 | 0 | 135 | 8 | 135 | p463 | 0.0450588 | 0.018225 | 0.000064 | 0.000161996 | 0.000161996
Plate | FL8*150 | +51.423 | +51.444 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p461 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
Plate | FL8*150 | +56.010 | +56.031 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p461 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
Plate | FL8*80 | +56.970 | +56.991 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
Plate | FL8*150 | +56.182 | +56.203 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p461 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
Plate | FL8*80 | +57.375 | +57.396 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p474 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
Plate | FL8*80 | +56.382 | +56.403 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p474 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
Plate | PLT8*160 | +54.611 | +54.632 | 2 | 99 | 2 | 0 | 34.8 | 0.1 | 160 | 8 | 190 | p546 | 0.0664 | 0.0304 | 0.000064 | 0.0002432 | 0.0002432
Plate | FL8*80 | +55.720 | +55.741 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p474 | 0.0294545 | 0.0128066 | 0.000064 | 0.000102453 | 0.000102453
Plate | FL8*50 | +55.308 | +55.336 | 2 | 99 | 0.7 | 0 | 38 | 0 | 50 | 8 | 250 | p423 | 0.0298 | 0.0125 | 0.000064 | 0.0001 | 0.0001
Plate | FL8*130 | +54.446 | +54.465 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p547 | 0.05452 | 0.0247 | 0.000064 | 0.0001976 | 0.0001976
Plate | PLT8*190 | +54.272 | +54.301 | 2 | 99 | 3 | 0 | 34.2 | 0.1 | 190 | 8 | 249.7 | p498 | 0.101966 | 0.0474646 | 0.000064 | 0.000379717 | 0.000379717
Plate | FL8*80 | +55.390 | +55.411 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p474 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
Plate | FL8*80 | +55.472 | +55.494 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p474 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
Plate | FL8*80 | +55.555 | +55.576 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p474 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
Plate | FL8*60 | +53.831 | +53.846 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90.2 | p520 | 0.0132 | 0.00540998 | 0.000064 | 0.0000431998 | 0.0000431998
Plate | FL8*80 | +54.727 | +54.749 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p474 | 0.0294545 | 0.0128066 | 0.000064 | 0.000102453 | 0.000102453
Plate | FL8*80 | +54.645 | +54.666 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p474 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
Plate | FL8*80 | +53.735 | +53.756 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p474 | 0.0294545 | 0.0128066 | 0.000064 | 0.000102453 | 0.000102453
Plate | PLT10*95 | +51.413 | +51.553 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p73 | 0.0288431 | 0.0132892 | 0.0001 | 0.000122711 | 0.000135859
3 x Plate | PLT10*95 | +55.384 | +55.524 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p73 | 0.0288627 | 0.0132978 | 0.0001 | 0.0001228 | 0.000123131
12 x Plate | PLT10*95 | +55.384 | +55.514 | 1 | 99 | 0.9 | 0 | 30.1 | 0 | 95 | 10 | 130.5 | p69 | 0.0268725 | 0.0123977 | 0.0001 | 0.000113796 | 0.00011413
6 x Plate | PLT10*95 | +55.384 | +55.505 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 120.6 | p72 | 0.0247941 | 0.0114578 | 0.0001 | 0.000104394 | 0.00010473
6 x Plate | PLT10*95 | +55.384 | +55.524 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p68 | 0.0288627 | 0.0132978 | 0.0001 | 0.0001228 | 0.000123131
6 x Plate | PLT10*95 | +55.384 | +55.505 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 120.6 | p70 | 0.0247941 | 0.0114578 | 0.0001 | 0.000104394 | 0.00010473
6 x Plate | PLT10*200 | +55.502 | +55.536 | 1 | 99 | 4.4 | 0 | 27.6 | 0.1 | 200 | 10 | 286 | p5 | 0.1241 | 0.0571904 | 0.0001 | 0.000571904 | 0.000571904
6 x Plate | PLT10*140 | +55.374 | +55.384 | 1 | 99 | 4.4 | 0.1 | 28 | 0.1 | 140 | 10 | 410 | p4 | 0.1258 | 0.0574 | 0.0001 | 0.000574 | 0.000574
3 x Plate | PLT10*95 | +55.384 | +55.524 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p71 | 0.0288627 | 0.0132978 | 0.0001 | 0.0001228 | 0.000123131
2 x Plate | PLT10*95 | +54.391 | +54.531 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p73 | 0.0289042 | 0.0132978 | 0.0001 | 0.000122971 | 0.000124298
12 x Plate | PLT10*95 | +54.391 | +54.521 | 1 | 99 | 0.9 | 0 | 30.1 | 0 | 95 | 10 | 130.5 | p69 | 0.0268725 | 0.0123977 | 0.0001 | 0.000113796 | 0.00011413
5 x Plate | PLT10*95 | +54.391 | +54.512 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 120.6 | p72 | 0.0247941 | 0.0114578 | 0.0001 | 0.000104394 | 0.00010473
7 x Plate | PLT10*95 | +54.391 | +54.512 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 120.6 | p70 | 0.0247941 | 0.0114578 | 0.0001 | 0.000104394 | 0.00010473
6 x Plate | PLT10*200 | +54.509 | +54.543 | 1 | 99 | 4.4 | 0 | 27.6 | 0.1 | 200 | 10 | 286 | p5 | 0.124101 | 0.0571908 | 0.0001 | 0.000571908 | 0.000571908
6 x Plate | PLT10*140 | +54.381 | +54.391 | 1 | 99 | 4.4 | 0.1 | 28 | 0.1 | 140 | 10 | 410 | p4 | 0.1258 | 0.0574 | 0.0001 | 0.000574 | 0.000574
4 x Plate | PLT10*95 | +54.391 | +54.531 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p68 | 0.0288627 | 0.0132978 | 0.0001 | 0.0001228 | 0.000123131
4 x Plate | PLT10*95 | +54.391 | +54.531 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p73 | 0.0288627 | 0.0132978 | 0.0001 | 0.0001228 | 0.000123131
2 x Plate | PLT10*95 | +53.399 | +53.539 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p73 | 0.0289159 | 0.0132978 | 0.0001 | 0.000123019 | 0.000124641
12 x Plate | PLT10*95 | +53.399 | +53.529 | 1 | 99 | 0.9 | 0 | 30.1 | 0 | 95 | 10 | 130.5 | p69 | 0.0268725 | 0.0123977 | 0.0001 | 0.000113796 | 0.00011413
5 x Plate | PLT10*95 | +53.399 | +53.520 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 120.6 | p72 | 0.0247941 | 0.0114578 | 0.0001 | 0.000104394 | 0.00010473
7 x Plate | PLT10*95 | +53.399 | +53.520 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 120.6 | p70 | 0.0247941 | 0.0114578 | 0.0001 | 0.000104394 | 0.00010473
6 x Plate | PLT10*200 | +53.517 | +53.551 | 1 | 99 | 4.4 | 0 | 27.6 | 0.1 | 200 | 10 | 286 | p5 | 0.1241 | 0.0571904 | 0.0001 | 0.000571904 | 0.000571904
6 x Plate | PLT10*140 | +53.389 | +53.399 | 1 | 99 | 4.4 | 0.1 | 28 | 0.1 | 140 | 10 | 410 | p4 | 0.1258 | 0.0574 | 0.0001 | 0.000574 | 0.000574
3 x Plate | PLT10*95 | +53.399 | +53.539 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p68 | 0.0288694 | 0.0133028 | 0.0001 | 0.000122828 | 0.000123181
3 x Plate | PLT10*95 | +53.399 | +53.539 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p71 | 0.0288694 | 0.0133028 | 0.0001 | 0.000122828 | 0.000123181
3 x Plate | PLT10*95 | +53.399 | +53.539 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p68 | 0.0288627 | 0.0132978 | 0.0001 | 0.0001228 | 0.000123131
Plate | PLT10*95 | +53.399 | +53.539 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p71 | 0.0288627 | 0.0132978 | 0.0001 | 0.0001228 | 0.000123131
Plate | PLT10*95 | +51.413 | +51.553 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p71 | 0.0288627 | 0.0132978 | 0.0001 | 0.0001228 | 0.000123131
12 x Plate | PLT10*95 | +51.413 | +51.543 | 1 | 99 | 0.9 | 0 | 30.1 | 0 | 95 | 10 | 130.5 | p69 | 0.0268725 | 0.0123977 | 0.0001 | 0.000113796 | 0.00011413
5 x Plate | PLT10*95 | +51.413 | +51.534 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 120.6 | p72 | 0.0247941 | 0.0114578 | 0.0001 | 0.000104394 | 0.00010473
2 x Plate | PLT10*95 | +51.413 | +51.553 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p68 | 0.0288627 | 0.0132978 | 0.0001 | 0.0001228 | 0.000123131
7 x Plate | PLT10*95 | +51.413 | +51.534 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 120.6 | p70 | 0.0247941 | 0.0114578 | 0.0001 | 0.000104394 | 0.00010473
6 x Plate | PLT10*200 | +51.531 | +51.565 | 1 | 99 | 4.4 | 0 | 27.6 | 0.1 | 200 | 10 | 286 | p5 | 0.1241 | 0.0571904 | 0.0001 | 0.000571904 | 0.000571904
6 x Plate | PLT10*140 | +51.403 | +51.413 | 1 | 99 | 4.4 | 0.1 | 28 | 0.1 | 140 | 10 | 410 | p4 | 0.1258 | 0.0574 | 0.0001 | 0.000574 | 0.000574
Plate | PLT10*95 | +51.413 | +51.553 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p73 | 0.0288627 | 0.0132978 | 0.0001 | 0.0001228 | 0.000123131
2 x Plate | PLT10*95 | +51.413 | +51.553 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p68 | 0.0288657 | 0.0133028 | 0.0001 | 0.000122809 | 0.000123156
2 x Plate | PLT10*95 | +51.413 | +51.553 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p73 | 0.028862 | 0.0133028 | 0.0001 | 0.000122802 | 0.000123131
11 x Plate | PLT10*95 | +56.335 | +56.473 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 137.9 | p71 | 0.0284361 | 0.0130987 | 0.0001 | 0.000120875 | 0.000124306
5 x Plate | PLT10*95 | +56.335 | +56.465 | 1 | 99 | 0.9 | 0 | 30.1 | 0 | 95 | 10 | 130.3 | p69 | 0.0268435 | 0.0123786 | 0.0001 | 0.00011367 | 0.000124262
11 x Plate | PLT10*95 | +56.335 | +56.457 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 122.4 | p72 | 0.0251793 | 0.0116254 | 0.0001 | 0.000106142 | 0.000124262
5 x Plate | PLT10*95 | +56.335 | +56.465 | 1 | 99 | 0.9 | 0 | 30.1 | 0 | 95 | 10 | 130.3 | p69 | 0.0268433 | 0.0123786 | 0.0001 | 0.00011367 | 0.000124262
6 x Plate | PLT10*200 | +56.455 | +56.484 | 1 | 99 | 4.4 | 0 | 27.6 | 0.1 | 200 | 10 | 285.6 | p5 | 0.123956 | 0.0571219 | 0.0001 | 0.000571219 | 0.000571219
6 x Plate | PLT10*140 | +56.325 | +56.335 | 1 | 99 | 4.4 | 0.1 | 28 | 0.1 | 140 | 10 | 410 | p4 | 0.1258 | 0.0574 | 0.0001 | 0.000574 | 0.000574
Plate | PLT10*95 | +56.335 | +56.473 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 137.9 | p68 | 0.0284361 | 0.0130987 | 0.0001 | 0.000120875 | 0.000124306
Plate | PLT10*95 | +56.335 | +56.457 | 1 | 99 | 0.7 | 0 | 30.2 | 0 | 95 | 10 | 122.4 | p70 | 0.0251793 | 0.0116254 | 0.0001 | 0.000106142 | 0.000124262
Plate | PLT10*95 | +56.335 | +56.465 | 1 | 99 | 0.9 | 0 | 30.1 | 0 | 95 | 10 | 130.3 | p69 | 0.0268433 | 0.0123787 | 0.0001 | 0.000113669 | 0.000119661
Plate | PLT10*95 | +56.335 | +56.465 | 1 | 99 | 0.9 | 0 | 30.1 | 0 | 95 | 10 | 130.3 | p69 | 0.0268433 | 0.0123786 | 0.0001 | 0.00011367 | 0.000119661
2 x Plate | PLT10*95 | +51.413 | +51.553 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p68 | 0.0288694 | 0.0133028 | 0.0001 | 0.000122828 | 0.000123181
2 x Plate | FL12*150 | +55.267 | +55.377 | 1 | 99 | 3.5 | 0 | 23.9 | 0.1 | 150 | 12 | 244 | -38AKp57 | 0.082656 | 0.082656 | 0.0018 | 0.0004392 | 0.0004392
2 x Plate | FL12*150 | +55.258 | +55.368 | 1 | 99 | 3.5 | 0 | 23.9 | 0.1 | 150 | 12 | 244 | -38AKp57 | 0.082656 | 0.082656 | 0.0018 | 0.0004392 | 0.0004392
Plate | PLT12*290.6 | +54.796 | +55.087 | 1 | 99 | 16.5 | 0 | 22.4 | 0.3 | 290.6 | 12 | 657.6 | p105 | 0.36931 | 0.191085 | 0.000144 | 0.00209023 | 0.00209023
Plate | PLT10*175 | +55.095 | +55.105 | 1 | 99 | 3.3 | 0 | 28 | 0.1 | 175 | 10 | 240 | -38AKp17 | 0.0923 | 0.0923 | 0.0024 | 0.00042 | 0.00042
Plate | PLT12*234.7 | +50.262 | +50.583 | 1 | 99 | 5.3 | 0 | 23.5 | 0.1 | 234.7 | 12 | 320.5 | -38AKp53 | 0.126319 | 0.0752291 | 0.000144 | 0.000689077 | 0.000689077
2 x Plate | FL20*300 | +50.242 | +50.262 | 1 | 99 | 14.1 | 0.1 | 14.4 | 0.2 | 300 | 20 | 300 | -38AKp60 | 0.204 | 0.204 | 0.006 | 0.0018 | 0.0018
Plate | PLT12*234.7 | +50.262 | +50.583 | 1 | 99 | 5.3 | 0 | 23.5 | 0.1 | 234.7 | 12 | 320.5 | -38AKp22 | 0.12632 | 0.0752295 | 0.000144 | 0.00068908 | 0.00068908
2 x Plate | PLT10*171.6 | +55.118 | +55.359 | 1 | 99 | 2.1 | 0 | 28.7 | 0.1 | 171.6 | 10 | 265 | p3 | 0.0608546 | 0.0454451 | 0.0001 | 0.000269058 | 0.000269058
2 x Plate | PLT10*121.8 | +56.423 | +56.603 | 1 | 99 | 1.1 | 0 | 30.2 | 0 | 121.8 | 10 | 180 | p2 | 0.0336723 | 0.021924 | 0.0001 | 0.00014222 | 0.00014222
Plate | PLT10*160 | +56.603 | +56.613 | 1 | 99 | 5 | 0.1 | 27.8 | 0.1 | 160 | 10 | 396 | p6 | 0.13784 | 0.06336 | 0.0001 | 0.0006336 | 0.0006336
Plate | PLT12*160 | +56.613 | +56.625 | 1 | 99 | 5.9 | 0.1 | 23.5 | 0.1 | 160 | 12 | 396 | p104 | 0.140064 | 0.06336 | 0.000144 | 0.00076032 | 0.00076032
2 x Plate | PLT10*95 | +54.391 | +54.531 | 1 | 99 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p68 | 0.0288694 | 0.0133028 | 0.0001 | 0.000122828 | 0.000123181
Plate | PLT10*209.9 | +50.944 | +51.154 | 9 | 99 | 6.9 | 0 | 27.2 | 0.2 | 209.9 | 10 | 437.2 | -38AMp33 | 0.189424 | 0.0917712 | 0.0001 | 0.00088572 | 0.00088572
2 x Plate | PLT10*200.6 | +50.254 | +50.455 | 1 | 99 | 2.6 | 0 | 28.2 | 0.1 | 200.6 | 10 | 200.7 | p63 | 0.0733264 | 0.0402535 | 0.0001 | 0.000331021 | 0.000331021
2 x Plate | PLT10*200.6 | +50.254 | +50.455 | 1 | 99 | 2.6 | 0 | 28.2 | 0.1 | 200.6 | 10 | 200.7 | p63 | 0.0733266 | 0.0402535 | 0.0001 | 0.000331022 | 0.000331022
12 x Plate | FL12*200 | +50.242 | +50.254 | 1 | 99 | 5.1 | 0.1 | 23.5 | 0.1 | 200 | 12 | 270 | -38AKp55 | 0.11928 | 0.11928 | 0.0024 | 0.000648 | 0.000648
2 x Plate | PLT12*230.3 | +50.242 | +50.254 | 1 | 99 | 5.9 | 0.1 | 23.2 | 0.1 | 230.3 | 12 | 270 | -38AKp84 | 0.136386 | 0.136386 | 0.00276396 | 0.000746269 | 0.000746269
2 x Plate | FL12*150 | +50.242 | +50.254 | 1 | 99 | 3.2 | 0 | 23.9 | 0.1 | 150 | 12 | 230 | -38AKp56 | 0.07812 | 0.07812 | 0.00276 | 0.000414 | 0.000414
2 x Plate | PLT10*155.6 | +52.010 | +52.166 | 1 | 99 | 12.1 | 0 | 27.5 | 0.3 | 155.6 | 10 | 1008.3 | -38AKp10 | 0.330184 | 0.156887 | 0.0001 | 0.00153751 | 0.00153751
2 x Plate | PLT10*170 | +52.989 | +53.159 | 1 | 99 | 9.8 | 0 | 27.2 | 0.3 | 170 | 10 | 755.9 | -38AKp9 | 0.267179 | 0.128499 | 0.0001 | 0.00124685 | 0.00124685
2 x Plate | PLT10*178.2 | +53.973 | +54.151 | 1 | 99 | 8.3 | 0 | 27.2 | 0.2 | 178.2 | 10 | 617.9 | -38AKp8 | 0.227327 | 0.110115 | 0.0001 | 0.00106074 | 0.00106074
4 x Plate | FL10*150 | +52.676 | +52.825 | 1 | 99 | 1.7 | 0 | 28.9 | 0.1 | 150 | 10 | 190 | p52 | 0.050298 | 0.0284996 | 0.0001 | 0.000220997 | 0.000220997
2 x Plate | PLT10*182.5 | +54.962 | +55.144 | 1 | 99 | 7.1 | 0 | 27.2 | 0.2 | 182.5 | 10 | 528 | -38AKp7 | 0.198158 | 0.0963456 | 0.0001 | 0.000923433 | 0.000923433
2 x Plate | PLT10*184.3 | +55.911 | +56.095 | 1 | 99 | 6.4 | 0 | 27.5 | 0.2 | 184.3 | 10 | 466.4 | -38AKp6 | 0.176556 | 0.0859686 | 0.0001 | 0.000821268 | 0.000821268
4 x Plate | FL10*150 | +53.151 | +53.301 | 1 | 99 | 1.7 | 0 | 28.9 | 0.1 | 150 | 10 | 190 | p52 | 0.0502979 | 0.0284996 | 0.0001 | 0.000220997 | 0.000220997
2 x Plate | PLT10*190.4 | +55.905 | +56.095 | 1 | 99 | 3.1 | 0 | 28.2 | 0.1 | 190.4 | 10 | 329.4 | p54 | 0.0878542 | 0.0626991 | 0.0001 | 0.000395099 | 0.000395099
2 x Plate | PLT10*190.2 | +55.905 | +56.095 | 1 | 99 | 3.1 | 0 | 28.2 | 0.1 | 190.2 | 10 | 329.4 | p54 | 0.0877679 | 0.0626336 | 0.0001 | 0.00039468 | 0.00039468
2 x Plate | FL10*90 | +56.101 | +56.319 | 1 | 99 | 1.4 | 0 | 29.5 | 0 | 90 | 10 | 218 | p1 | 0.0454 | 0.01962 | 0.0001 | 0.0001962 | 0.0001962
2 x Plate | FL10*90 | +55.150 | +55.368 | 1 | 99 | 1.4 | 0 | 29.5 | 0 | 90 | 10 | 218 | p1 | 0.0454 | 0.01962 | 0.0001 | 0.0001962 | 0.0001962
2 x Plate | FL10*90 | +54.157 | +54.375 | 1 | 99 | 1.4 | 0 | 29.5 | 0 | 90 | 10 | 218 | p1 | 0.0454 | 0.01962 | 0.0001 | 0.0001962 | 0.0001962
2 x Plate | FL10*90 | +53.165 | +53.383 | 1 | 99 | 1.4 | 0 | 29.5 | 0 | 90 | 10 | 218 | p1 | 0.0454 | 0.01962 | 0.0001 | 0.0001962 | 0.0001962
2 x Plate | FL10*90 | +52.172 | +52.390 | 1 | 99 | 1.4 | 0 | 29.5 | 0 | 90 | 10 | 218 | p1 | 0.0454 | 0.01962 | 0.0001 | 0.0001962 | 0.0001962

# IfcDiscreteAccessory: Rail (12)
In: Undefined
Description: D16; Material: STEEL/S355JR
Tekla Common - Phase: 4; Class: 12
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 34.5 m2; Net surface area: 0.3 m2; Height: 16 mm; Width: 16 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.000181019 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
6 x Rail | +58.317 | +58.333 | 8.8 | 6230 | m730 | 0.305529 | 0.00112775
6 x Rail | +58.070 | +58.086 | 10.1 | 7130 | m729 | 0.349614 | 0.00129067

# IfcDiscreteAccessory: Rod (230)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Weight (kg) | Area per tons (m2) | Height (mm) = Width (mm) | Length (mm) | Bottom elevation | Top elevation | Phase | Class | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x Rod | D12 | 0.2 | 47 | 12 | 291.4 | +51.231 | +51.393 | 25 | 2 | m928 | 0.0108771 | 0.000101823 | 0.0000295288
4 x Rod | D12 | 0.2 | 47 | 12 | 291.4 | +50.631 | +50.793 | 25 | 2 | m928 | 0.0108771 | 0.000101823 | 0.0000295288
58 x Rod | D12 | 0.2 | 47 | 12 | 291.4 | +57.739 | +57.901 | 9 | 99 | m928 | 0.0108771 | 0.000101823 | 0.0000295288
6 x Rod | D16 | 0.2 | 36.2 | 16 | 150 | +52.310 | +52.461 | 6 | 99 | m731 | 0.00770956 | 0.000181019 | 0.0000271529
6 x Rod | D16 | 0.2 | 36.2 | 16 | 150 | +52.329 | +52.479 | 6 | 99 | m731 | 0.00770956 | 0.000181019 | 0.0000271529
6 x Rod | D16 | 0.2 | 36.2 | 16 | 150 | +52.227 | +52.378 | 6 | 99 | m731 | 0.00770956 | 0.000181019 | 0.0000271529
6 x Rod | D16 | 0.2 | 36.2 | 16 | 150 | +52.246 | +52.397 | 6 | 99 | m731 | 0.00770956 | 0.000181019 | 0.0000271529
6 x Rod | D16 | 0.2 | 36.2 | 16 | 150 | +52.104 | +52.255 | 6 | 99 | m731 | 0.00770956 | 0.000181019 | 0.0000271529
6 x Rod | D16 | 0.2 | 36.2 | 16 | 150 | +52.123 | +52.273 | 6 | 99 | m731 | 0.00770956 | 0.000181019 | 0.0000271529
6 x Rod | D16 | 0.2 | 36.2 | 16 | 150 | +51.980 | +52.131 | 6 | 99 | m731 | 0.00770956 | 0.000181019 | 0.0000271529
6 x Rod | D16 | 0.2 | 36.2 | 16 | 150 | +51.999 | +52.150 | 6 | 99 | m731 | 0.00770956 | 0.000181019 | 0.0000271529
6 x Rod | D16 | 0.2 | 36.2 | 16 | 150 | +51.733 | +51.884 | 6 | 99 | m731 | 0.00770956 | 0.000181019 | 0.0000271529
6 x Rod | D16 | 0.2 | 36.2 | 16 | 150 | +51.752 | +51.903 | 6 | 99 | m731 | 0.00770956 | 0.000181019 | 0.0000271529
6 x Rod | D16 | 0.2 | 36.2 | 16 | 150 | +51.857 | +52.007 | 6 | 99 | m731 | 0.00770956 | 0.000181019 | 0.0000271529
6 x Rod | D16 | 0.2 | 36.2 | 16 | 150 | +51.875 | +52.026 | 6 | 99 | m731 | 0.00770956 | 0.000181019 | 0.0000271529
3 x Rod | ROD20 | 1.1 | 28.1 | 20 | 510 | +51.391 | +51.412 | 6 | 14 | m565 | 0.0317927 | 0.000282843 | 0.00014425
3 x Rod | ROD20 | 1.1 | 28.1 | 20 | 510 | +52.951 | +52.972 | 6 | 14 | m565 | 0.0317927 | 0.000282843 | 0.00014425
3 x Rod | ROD20 | 1.1 | 28.1 | 20 | 510 | +52.691 | +52.712 | 6 | 14 | m565 | 0.0317927 | 0.000282843 | 0.00014425
3 x Rod | ROD20 | 1.1 | 28.1 | 20 | 510 | +52.431 | +52.452 | 6 | 14 | m565 | 0.0317927 | 0.000282843 | 0.00014425
3 x Rod | ROD20 | 1.1 | 28.1 | 20 | 510 | +52.171 | +52.192 | 6 | 14 | m565 | 0.0317927 | 0.000282843 | 0.00014425
3 x Rod | ROD20 | 1.1 | 28.1 | 20 | 510 | +51.911 | +51.932 | 6 | 14 | m565 | 0.0317927 | 0.000282843 | 0.00014425
3 x Rod | ROD20 | 1.1 | 28.1 | 20 | 510 | +51.651 | +51.672 | 6 | 14 | m565 | 0.0317927 | 0.000282843 | 0.00014425
12 x Rod | D12 | 0.2 | 47 | 12 | 291.4 | +58.320 | +58.401 | 9 | 99 | m928 | 0.0108771 | 0.000101823 | 0.0000295288
2 x Rod | D12 | 0.2 | 47 | 12 | 291.4 | +57.739 | +57.901 | 3 | 99 | m928 | 0.0108771 | 0.000101823 | 0.0000295288
6 x Rod | D12 | 0.2 | 47 | 12 | 291.4 | +57.253 | +57.415 | 12 | 99 | m928 | 0.0108771 | 0.000101823 | 0.0000295288
42 x Rod | D12 | 0.2 | 47 | 12 | 291.4 | +57.254 | +57.416 | 12 | 99 | m928 | 0.0108771 | 0.000101823 | 0.0000295288
6 x Rod | D10 | 0.2 | 56.1 | 10 | 291.4 | +57.350 | +57.510 | 5 | 99 | m715 | 0.00903595 | 0.0000707107 | 0.0000205061
3 x Rod | D10 | 0.2 | 56.1 | 10 | 291.4 | +58.111 | +58.191 | 5 | 99 | m715 | 0.00903595 | 0.0000707107 | 0.0000205061

# IfcDiscreteAccessory: Skirt Plate (30)
In: Undefined
Description: PL8*408; Material: STEEL/S355JR
Tekla Common - Phase: 6; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 408 mm; Width: 8 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.003264 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
6 x Skirt Plate | +52.690 | +53.219 | 38 | 32.6 | 1.3 | 1484 | p287 | 1.24122 | 0.00484378
6 x Skirt Plate | +52.293 | +52.848 | 46.4 | 32.6 | 1.4 | 1810 | p286 | 1.51245 | 0.00590784
6 x Skirt Plate | +52.814 | +53.302 | 25.2 | 32.7 | 0.9 | 984 | p285 | 0.825216 | 0.00321178
6 x Skirt Plate | +52.567 | +53.096 | 38 | 32.6 | 1.3 | 1484 | p287 | 1.24122 | 0.00484378
6 x Skirt Plate | +52.443 | +52.972 | 38 | 32.6 | 1.3 | 1484 | p287 | 1.24122 | 0.00484378

# IfcDiscreteAccessory: Socket (90)
In: Undefined
Description: D32; Material: STEEL/S355JR
Tekla Common - Phase: 6; Class: 13
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 23 m2; Net surface area: 0 m2; Height: 32 mm; Width: 32 mm; Length: 39.5 mm
Pset_PlateCommon - LoadBearing: yes; Reference: m894
BaseQuantities - NetArea: 0.00546177 m2; GrossArea: 0.00546177 m2; CrossSectionArea: 0.000768 m2; NetVolume: 0.000030336 m3; GrossVolume: 0.000030336 m3
Name | Bottom elevation | Top elevation
6 x Socket | +53.018 | +53.050
6 x Socket | +52.977 | +53.009
6 x Socket | +52.936 | +52.968
6 x Socket | +52.895 | +52.927
6 x Socket | +52.854 | +52.886
6 x Socket | +52.812 | +52.844
6 x Socket | +52.771 | +52.803
6 x Socket | +52.730 | +52.762
6 x Socket | +52.689 | +52.721
6 x Socket | +52.648 | +52.679
6 x Socket | +52.606 | +52.638
6 x Socket | +52.565 | +52.597
6 x Socket | +52.524 | +52.556
6 x Socket | +52.483 | +52.515
6 x Socket | +52.442 | +52.473

# IfcDiscreteAccessory: Sole Plate (40)
In: Undefined
Material: STEEL/S355JR
Tekla Common - Class: 11
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x Sole Plate | FL12*130 | +55.185 | +55.765 | 12 | 7.1 | 0 | 23.6 | 0.2 | 130 | 12 | 580 | p159 | 0.16784 | 0.00156 | 0.0009048
6 x Sole Plate | FL20*200 | +57.171 | +57.871 | 5 | 22 | 0 | 14.4 | 0.3 | 200 | 20 | 700 | p668 | 0.316 | 0.004 | 0.0028
6 x Sole Plate | FL20*200 | +58.005 | +58.705 | 5 | 22 | 0 | 14.4 | 0.3 | 200 | 20 | 700 | p668 | 0.316 | 0.004 | 0.0028
6 x Sole Plate | FL20*200 | +56.930 | +56.950 | 12 | 22 | 0.1 | 14.4 | 0.3 | 200 | 20 | 700 | p667 | 0.316 | 0.004 | 0.0028
6 x Sole Plate | FL12*130 | +57.635 | +57.647 | 3 | 7.1 | 0.1 | 23.6 | 0.2 | 130 | 12 | 580 | p159 | 0.16784 | 0.00156 | 0.0009048
6 x Sole Plate | FL20*200 | +52.133 | +52.153 | 9 | 22 | 0.1 | 14.4 | 0.3 | 200 | 20 | 700 | p667 | 0.316 | 0.004 | 0.0028
6 x Sole Plate | FL12*130 | +50.582 | +51.162 | 9 | 7.1 | 0 | 23.6 | 0.2 | 130 | 12 | 580 | p159 | 0.16784 | 0.00156 | 0.0009048

# IfcDiscreteAccessory: Stringer (16)
In: Undefined
Description: PC180*70; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.3 m2; Height: 180 mm; Width: 70 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.0026879 m2
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
4 x Stringer | +57.090 | +57.270 | 3 | 99 | 5 | 0.1 | 236.9 | m197 | 0.146114 | 0.000399637 | 0.000636897
4 x Stringer | +57.090 | +57.270 | 3 | 99 | 5 | 0.1 | 236.9 | m196 | 0.146114 | 0.000399582 | 0.000636897
4 x Stringer | +50.837 | +51.017 | 2 | 3 | 11.4 | 0.3 | 538.8 | m176 | 0.332244 | 0.00133295 | 0.00144822
4 x Stringer | +50.837 | +51.017 | 2 | 3 | 11.4 | 0.3 | 538.8 | m175 | 0.332244 | 0.00133295 | 0.00144822

# IfcDiscreteAccessory: VB (1004)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
VB | L70*70*8 | +56.478 | +57.740 | 2 | 4 | 10.5 | 32.6 | 0.3 | 70 | 70 | 1259.5 | m351 | 0.342921 | 0.00106497 | 0.00132997 | 0.00134129
3 x VB | L70*70*8 | +56.974 | +58.297 | 2 | 4 | 11 | 32.6 | 0.3 | 70 | 70 | 1321.6 | m350 | 0.359849 | 0.00106497 | 0.00139553 | 0.00140751
3 x VB | L70*70*8 | +56.974 | +58.297 | 2 | 4 | 11 | 32.6 | 0.3 | 70 | 70 | 1321.6 | m349 | 0.359849 | 0.00106497 | 0.00139553 | 0.00140751
3 x VB | L50*50*4 | +57.078 | +58.123 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1339.7 | m792 | 0.259891 | 0.000389809 | 0.000499116 | 0.000522229
3 x VB | L50*50*4 | +57.119 | +58.125 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1009.7 | m784 | 0.195865 | 0.000389809 | 0.000386852 | 0.000393574
2 x VB | L50*50*4 | +57.121 | +58.164 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1338.4 | m793 | 0.259647 | 0.000389809 | 0.000498533 | 0.000521739
3 x VB | L50*50*4 | +57.160 | +58.166 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1009.9 | m784 | 0.195907 | 0.000389809 | 0.000386926 | 0.000393658
3 x VB | L50*50*4 | +57.162 | +58.202 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1336.8 | m793 | 0.259325 | 0.000389809 | 0.000497969 | 0.000521092
3 x VB | L50*50*4 | +57.198 | +58.204 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1010.1 | m784 | 0.195944 | 0.000389809 | 0.000386995 | 0.000393733
3 x VB | L50*50*4 | +57.200 | +58.236 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1333.3 | m794 | 0.258651 | 0.000389809 | 0.000496732 | 0.000519739
3 x VB | L50*50*4 | +57.233 | +58.267 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1331.7 | m794 | 0.258329 | 0.000389809 | 0.000496157 | 0.00051909
3 x VB | L50*50*4 | +57.260 | +58.268 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1013.1 | m785 | 0.196533 | 0.000389809 | 0.000387997 | 0.000394917
3 x VB | L50*50*4 | +57.231 | +58.238 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1010.1 | m784 | 0.195955 | 0.000389809 | 0.000387016 | 0.000393756
3 x VB | L70*70*8 | +57.281 | +58.270 | 2 | 4 | 11.4 | 32.6 | 0.3 | 70 | 70 | 1367.2 | m346 | 0.372262 | 0.00106497 | 0.00138152 | 0.00145606
3 x VB | L50*50*4 | +57.075 | +58.082 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1009.1 | m782 | 0.19576 | 0.000389809 | 0.00038686 | 0.000393363
3 x VB | L50*50*4 | +57.074 | +58.036 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1385.1 | m795 | 0.268694 | 0.000389809 | 0.000515642 | 0.000539917
3 x VB | L50*50*4 | +57.028 | +58.035 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1008.8 | m782 | 0.195704 | 0.000389809 | 0.000386836 | 0.000393252
3 x VB | L50*50*4 | +57.026 | +57.984 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1382.2 | m796 | 0.268131 | 0.000389809 | 0.000514552 | 0.000538786
3 x VB | L50*50*4 | +56.976 | +57.983 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1008.6 | m782 | 0.195655 | 0.000389809 | 0.000386803 | 0.000393152
3 x VB | L50*50*4 | +56.975 | +57.931 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1380.9 | m796 | 0.267873 | 0.000389809 | 0.000514066 | 0.000538268
3 x VB | L50*50*4 | +56.923 | +57.929 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1008.3 | m782 | 0.195606 | 0.000389809 | 0.000386746 | 0.000393053
3 x VB | L50*50*4 | +56.921 | +57.873 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1377.4 | m797 | 0.267202 | 0.000389809 | 0.000512816 | 0.000536921
3 x VB | L50*50*4 | +56.863 | +57.812 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1375.4 | m798 | 0.26681 | 0.000389809 | 0.000512164 | 0.000536132
3 x VB | L50*50*4 | +56.804 | +57.810 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1008.1 | m782 | 0.195554 | 0.000389809 | 0.000386729 | 0.000392949
3 x VB | L50*50*4 | +56.865 | +57.871 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007.6 | m782 | 0.195469 | 0.000389809 | 0.000386543 | 0.000392779
3 x VB | L70*70*8 | +56.749 | +57.806 | 2 | 4 | 10.8 | 32.6 | 0.3 | 70 | 70 | 1304.5 | m345 | 0.355188 | 0.00106497 | 0.0013128 | 0.00138928
VB | L70*70*8 | +56.487 | +57.754 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.9 | m335 | 0.344398 | 0.00106497 | 0.00133572 | 0.00134707
3 x VB | L50*50*4 | +57.078 | +58.123 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1339.7 | m799 | 0.259891 | 0.000389809 | 0.000499116 | 0.000522229
3 x VB | L50*50*4 | +57.119 | +58.125 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1009.7 | m786 | 0.195865 | 0.000389809 | 0.000386852 | 0.000393574
2 x VB | L50*50*4 | +57.121 | +58.164 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1338.4 | m800 | 0.259647 | 0.000389809 | 0.000498533 | 0.000521739
3 x VB | L50*50*4 | +57.160 | +58.166 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1009.9 | m786 | 0.195907 | 0.000389809 | 0.000386926 | 0.000393658
3 x VB | L50*50*4 | +57.162 | +58.202 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1336.8 | m800 | 0.259325 | 0.000389809 | 0.000497969 | 0.000521092
3 x VB | L50*50*4 | +57.198 | +58.204 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1010.1 | m786 | 0.195944 | 0.000389809 | 0.000386995 | 0.000393733
3 x VB | L50*50*4 | +57.200 | +58.236 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1333.3 | m801 | 0.258651 | 0.000389809 | 0.000496732 | 0.000519739
3 x VB | L50*50*4 | +57.233 | +58.267 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1331.7 | m801 | 0.258329 | 0.000389809 | 0.000496157 | 0.00051909
3 x VB | L50*50*4 | +57.260 | +58.268 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1013.1 | m787 | 0.196533 | 0.000389809 | 0.000387997 | 0.000394917
3 x VB | L50*50*4 | +57.231 | +58.238 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1010.1 | m786 | 0.195955 | 0.000389809 | 0.000387016 | 0.000393756
3 x VB | L70*70*8 | +57.281 | +58.270 | 2 | 4 | 11.4 | 32.6 | 0.3 | 70 | 70 | 1367.2 | m344 | 0.372262 | 0.00106497 | 0.00138152 | 0.00145606
3 x VB | L50*50*4 | +57.075 | +58.082 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1009.1 | m783 | 0.19576 | 0.000389809 | 0.00038686 | 0.000393363
3 x VB | L50*50*4 | +57.074 | +58.036 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1385.1 | m802 | 0.268694 | 0.000389809 | 0.000515642 | 0.000539917
3 x VB | L50*50*4 | +57.028 | +58.035 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1008.8 | m783 | 0.195704 | 0.000389809 | 0.000386836 | 0.000393252
3 x VB | L50*50*4 | +57.026 | +57.984 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1382.2 | m803 | 0.268131 | 0.000389809 | 0.000514552 | 0.000538786
3 x VB | L50*50*4 | +56.976 | +57.983 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1008.6 | m783 | 0.195655 | 0.000389809 | 0.000386803 | 0.000393152
3 x VB | L50*50*4 | +56.975 | +57.931 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1380.9 | m803 | 0.267873 | 0.000389809 | 0.000514066 | 0.000538268
3 x VB | L50*50*4 | +56.923 | +57.929 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1008.3 | m783 | 0.195606 | 0.000389809 | 0.000386746 | 0.000393053
3 x VB | L50*50*4 | +56.921 | +57.873 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1377.4 | m804 | 0.267202 | 0.000389809 | 0.000512816 | 0.000536921
3 x VB | L50*50*4 | +56.863 | +57.812 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1375.4 | m805 | 0.26681 | 0.000389809 | 0.000512164 | 0.000536132
3 x VB | L50*50*4 | +56.804 | +57.810 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1008.1 | m783 | 0.195554 | 0.000389809 | 0.000386729 | 0.000392949
3 x VB | L50*50*4 | +56.865 | +57.871 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007.6 | m783 | 0.195469 | 0.000389809 | 0.000386543 | 0.000392779
3 x VB | L70*70*8 | +56.749 | +57.806 | 2 | 4 | 10.8 | 32.6 | 0.3 | 70 | 70 | 1304.5 | m343 | 0.355188 | 0.00106497 | 0.0013128 | 0.00138928
2 x VB | L70*70*8 | +56.487 | +57.754 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.9 | m352 | 0.344398 | 0.00106497 | 0.00133572 | 0.00134707
2 x VB | L70*70*8 | +56.732 | +57.678 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1333 | m342 | 0.362955 | 0.00106497 | 0.00134563 | 0.00141965
3 x VB | L50*50*4 | +56.670 | +57.674 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1003.6 | m788 | 0.194692 | 0.000389809 | 0.000385388 | 0.000391218
3 x VB | L50*50*4 | +56.601 | +57.606 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1004.1 | m788 | 0.194788 | 0.000389809 | 0.000385578 | 0.000391411
3 x VB | L50*50*4 | +56.524 | +57.533 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1008 | m786 | 0.19554 | 0.000389809 | 0.000387053 | 0.000392921
3 x VB | L50*50*4 | +56.442 | +57.450 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195355 | 0.000389809 | 0.000386692 | 0.00039255
3 x VB | L50*50*4 | +56.606 | +57.669 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1351.5 | m806 | 0.262179 | 0.000389809 | 0.000503416 | 0.000526828
3 x VB | L50*50*4 | +56.530 | +57.600 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1357 | m807 | 0.263245 | 0.000389809 | 0.000505399 | 0.000528968
3 x VB | L50*50*4 | +56.448 | +57.528 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1364 | m808 | 0.264598 | 0.000389809 | 0.000507315 | 0.000531688
3 x VB | L50*50*4 | +56.364 | +57.444 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1364.2 | m790 | 0.264633 | 0.000389809 | 0.000508015 | 0.000531758
3 x VB | L70*70*8 | +56.732 | +57.678 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1333 | m333 | 0.362954 | 0.00106497 | 0.00134554 | 0.00141965
3 x VB | L50*50*4 | +56.670 | +57.674 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1003.6 | m789 | 0.194692 | 0.000389809 | 0.000385388 | 0.000391218
3 x VB | L50*50*4 | +56.601 | +57.606 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1004.1 | m789 | 0.194788 | 0.000389809 | 0.000385578 | 0.000391411
3 x VB | L50*50*4 | +56.524 | +57.533 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1008 | m784 | 0.19554 | 0.000389809 | 0.000387053 | 0.000392921
3 x VB | L50*50*4 | +56.442 | +57.450 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195355 | 0.000389809 | 0.000386692 | 0.00039255
3 x VB | L50*50*4 | +56.606 | +57.669 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1351.5 | m809 | 0.262179 | 0.000389809 | 0.000503416 | 0.000526828
3 x VB | L50*50*4 | +56.530 | +57.600 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1357 | m810 | 0.263245 | 0.000389809 | 0.000505399 | 0.000528968
3 x VB | L50*50*4 | +56.448 | +57.528 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1364 | m811 | 0.264598 | 0.000389809 | 0.000507315 | 0.000531688
3 x VB | L50*50*4 | +56.364 | +57.444 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1364.2 | m791 | 0.264633 | 0.000389809 | 0.000508004 | 0.000531758
2 x VB | L70*70*8 | +56.478 | +57.740 | 2 | 4 | 10.5 | 32.6 | 0.3 | 70 | 70 | 1259.5 | m353 | 0.342914 | 0.00106497 | 0.00132995 | 0.00134127
2 x VB | L70*70*8 | +51.244 | +52.304 | 2 | 4 | 10.3 | 32.6 | 0.3 | 70 | 70 | 1220 | m332 | 0.332177 | 0.00106497 | 0.0012086 | 0.00129927
2 x VB | L70*70*8 | +51.812 | +52.761 | 2 | 4 | 10.3 | 32.6 | 0.3 | 70 | 70 | 1214.9 | m331 | 0.330772 | 0.00106497 | 0.0011937 | 0.00129378
VB | L70*70*8 | +50.978 | +52.246 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1267.3 | m348 | 0.345048 | 0.00106497 | 0.00133816 | 0.00134961
3 x VB | L50*50*4 | +51.524 | +52.454 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507819 | 0.000531563
3 x VB | L50*50*4 | +51.360 | +52.302 | 2 | 4 | 3.6 | 63.4 | 0.2 | 50 | 50 | 1184.2 | m781 | 0.229733 | 0.000389809 | 0.0004306 | 0.000461629
VB | L50*50*4 | +51.441 | +52.372 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m777 | 0.264535 | 0.000389809 | 0.000507822 | 0.000531562
3 x VB | L50*50*4 | +51.302 | +52.310 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195348 | 0.000389809 | 0.000386685 | 0.000392535
3 x VB | L50*50*4 | +51.361 | +52.369 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195348 | 0.000389809 | 0.000386686 | 0.000392535
3 x VB | L50*50*4 | +51.444 | +52.452 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195348 | 0.000389809 | 0.000386687 | 0.000392536
3 x VB | L50*50*4 | +51.532 | +52.611 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507818 | 0.000531563
3 x VB | L50*50*4 | +51.526 | +52.534 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +51.697 | +52.743 | 2 | 4 | 3.6 | 63.4 | 0.2 | 50 | 50 | 1184 | m780 | 0.229684 | 0.000389809 | 0.000430398 | 0.000461532
3 x VB | L50*50*4 | +51.614 | +52.693 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264535 | 0.000389809 | 0.00050782 | 0.000531562
3 x VB | L70*70*8 | +51.555 | +52.822 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1266.3 | m347 | 0.344778 | 0.00106497 | 0.0013372 | 0.00134856
3 x VB | L50*50*4 | +51.750 | +52.758 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195348 | 0.000389809 | 0.000386685 | 0.000392535
3 x VB | L50*50*4 | +51.691 | +52.699 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195348 | 0.000389809 | 0.000386686 | 0.000392535
3 x VB | L50*50*4 | +51.609 | +52.616 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195348 | 0.000389809 | 0.000386687 | 0.000392536
2 x VB | L70*70*8 | +51.244 | +52.304 | 2 | 4 | 10.3 | 32.6 | 0.3 | 70 | 70 | 1220 | m330 | 0.332177 | 0.00106497 | 0.0012086 | 0.00129927
3 x VB | L50*50*4 | +51.524 | +52.454 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507819 | 0.000531563
3 x VB | L50*50*4 | +51.360 | +52.302 | 2 | 4 | 3.6 | 63.4 | 0.2 | 50 | 50 | 1184.2 | m779 | 0.229733 | 0.000389809 | 0.0004306 | 0.000461629
VB | L50*50*4 | +51.441 | +52.372 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m776 | 0.264535 | 0.000389809 | 0.000507822 | 0.000531562
3 x VB | L50*50*4 | +51.302 | +52.310 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195348 | 0.000389809 | 0.000386685 | 0.000392535
3 x VB | L50*50*4 | +51.361 | +52.369 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195348 | 0.000389809 | 0.000386686 | 0.000392535
3 x VB | L50*50*4 | +51.444 | +52.452 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195348 | 0.000389809 | 0.000386687 | 0.000392536
2 x VB | L70*70*8 | +51.812 | +52.761 | 2 | 4 | 10.3 | 32.6 | 0.3 | 70 | 70 | 1214.9 | m329 | 0.330772 | 0.00106497 | 0.0011937 | 0.00129378
3 x VB | L50*50*4 | +51.532 | +52.611 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507818 | 0.000531563
3 x VB | L50*50*4 | +51.526 | +52.534 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +51.697 | +52.743 | 2 | 4 | 3.6 | 63.4 | 0.2 | 50 | 50 | 1184 | m778 | 0.229684 | 0.000389809 | 0.000430398 | 0.000461532
3 x VB | L50*50*4 | +51.614 | +52.693 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264535 | 0.000389809 | 0.00050782 | 0.000531562
3 x VB | L70*70*8 | +51.555 | +52.822 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1266.3 | m348 | 0.344778 | 0.00106497 | 0.0013372 | 0.00134856
3 x VB | L50*50*4 | +51.750 | +52.758 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195348 | 0.000389809 | 0.000386685 | 0.000392535
3 x VB | L50*50*4 | +51.691 | +52.699 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195348 | 0.000389809 | 0.000386686 | 0.000392535
3 x VB | L50*50*4 | +51.609 | +52.616 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195348 | 0.000389809 | 0.000386687 | 0.000392536
VB | L70*70*8 | +50.978 | +52.246 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1267.3 | m347 | 0.345048 | 0.00106497 | 0.00133816 | 0.00134961
3 x VB | L50*50*4 | +56.035 | +56.965 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1364 | m791 | 0.264579 | 0.000389809 | 0.000507874 | 0.000531649
3 x VB | L50*50*4 | +55.953 | +56.883 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m791 | 0.264478 | 0.000389809 | 0.00050786 | 0.000531447
3 x VB | L50*50*4 | +55.873 | +56.881 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007.1 | m783 | 0.195377 | 0.000389809 | 0.000386743 | 0.000392593
3 x VB | L50*50*4 | +55.955 | +56.963 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +56.290 | +57.370 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264517 | 0.000389809 | 0.000507821 | 0.000531525
3 x VB | L50*50*4 | +56.367 | +57.375 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +56.283 | +57.213 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264531 | 0.000389809 | 0.000507776 | 0.000531553
3 x VB | L50*50*4 | +56.285 | +57.293 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +56.200 | +57.130 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264541 | 0.000389809 | 0.000507837 | 0.000531572
3 x VB | L50*50*4 | +56.203 | +57.210 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +56.118 | +57.048 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507785 | 0.000531563
3 x VB | L70*70*8 | +55.800 | +56.875 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1328.6 | m341 | 0.361749 | 0.00106497 | 0.00133848 | 0.00141494
3 x VB | L50*50*4 | +56.120 | +57.128 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +56.038 | +57.045 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
VB | L70*70*8 | +55.537 | +56.802 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.4 | m335 | 0.344274 | 0.00106497 | 0.00133525 | 0.00134659
3 x VB | L50*50*4 | +56.035 | +56.965 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1364 | m790 | 0.264579 | 0.000389809 | 0.000507874 | 0.000531649
3 x VB | L50*50*4 | +55.953 | +56.883 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m790 | 0.264478 | 0.000389809 | 0.00050786 | 0.000531447
3 x VB | L50*50*4 | +55.873 | +56.881 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007.1 | m782 | 0.195377 | 0.000389809 | 0.000386743 | 0.000392593
3 x VB | L50*50*4 | +55.955 | +56.963 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +56.290 | +57.370 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264517 | 0.000389809 | 0.000507821 | 0.000531525
3 x VB | L50*50*4 | +56.367 | +57.375 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +56.283 | +57.213 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264531 | 0.000389809 | 0.000507776 | 0.000531553
3 x VB | L50*50*4 | +56.285 | +57.293 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +56.200 | +57.130 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264541 | 0.000389809 | 0.000507837 | 0.000531572
3 x VB | L50*50*4 | +56.203 | +57.210 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +56.118 | +57.048 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507785 | 0.000531563
3 x VB | L70*70*8 | +55.800 | +56.875 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1328.6 | m340 | 0.361749 | 0.00106497 | 0.00133848 | 0.00141494
3 x VB | L50*50*4 | +56.120 | +57.128 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +56.038 | +57.045 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
2 x VB | L70*70*8 | +55.537 | +56.802 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.4 | m352 | 0.344274 | 0.00106497 | 0.00133525 | 0.00134659
3 x VB | L70*70*8 | +55.780 | +56.716 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1323.6 | m339 | 0.36037 | 0.00106497 | 0.00132647 | 0.00140954
VB | L70*70*8 | +54.808 | +55.883 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1329.5 | m328 | 0.361986 | 0.00106497 | 0.00133931 | 0.00141587
3 x VB | L50*50*4 | +55.545 | +56.625 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m775 | 0.264536 | 0.000389809 | 0.000508007 | 0.000531563
3 x VB | L50*50*4 | +55.628 | +56.707 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +55.043 | +55.973 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m791 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +54.961 | +55.891 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507863 | 0.000531564
3 x VB | L50*50*4 | +55.705 | +56.712 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +55.622 | +56.630 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
