Properties of the parts of a building model (IFC2X3), part 12 of 16

# IfcElementAssembly (3904)
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Steel Assembly | RIGID_FRAME | 11.9 | +57.280 | +58.407 | 15-16/C-D | A421 | 228.45
Steel Assembly | RIGID_FRAME | 11.9 | +57.280 | +58.407 | 15-16/A-B | A423 | 228.45
Steel Assembly | RIGID_FRAME | 11.9 | +57.280 | +58.407 | 15-16/B-C | A423 | 228.45
Steel Assembly | RIGID_FRAME | 11.9 | +57.280 | +58.407 | 15-16/C-D | A424 | 228.45
Steel Assembly | RIGID_FRAME | 14.7 | +57.270 | +58.407 | 15/C-D | A79 | 90
Steel Assembly | RIGID_FRAME | 14.7 | +57.270 | +58.407 | 15/B-C | A79 | 90
Steel Assembly | RIGID_FRAME | 14.7 | +57.270 | +58.407 | 15/A-B | A79 | 90
Steel Assembly | RIGID_FRAME | 14.7 | +57.270 | +58.407 | 15/B-C | A80 | 375.046
Steel Assembly | RIGID_FRAME | 14.7 | +57.270 | +58.407 | 15/C-D | A80 | 375.046
Steel Assembly | RIGID_FRAME | 14.7 | +57.270 | +58.407 | 15/D-E | A80 | 375.046
Steel Assembly | RIGID_FRAME | 15.1 | +56.911 | +58.071 | 19/D-E | A475 | 1160
Steel Assembly | RIGID_FRAME | 15.1 | +56.911 | +58.071 | 19/C-D | A476 | 1160
Steel Assembly | RIGID_FRAME | 15.1 | +56.911 | +58.071 | 19/C-D | A475 | 1160
Steel Assembly | RIGID_FRAME | 15.1 | +56.911 | +58.071 | 19/B-C | A476 | 1160
Steel Assembly | RIGID_FRAME | 15.1 | +56.911 | +58.071 | 19/B-C | A475 | 1160
Steel Assembly | RIGID_FRAME | 15.1 | +56.911 | +58.071 | 19/A-B | A476 | 1160
Steel Assembly | RIGID_FRAME | 79.7 | +58.164 | +58.418 | 16-17/A-C | A659 | 1800
2 x Steel Assembly | RIGID_FRAME | 79.7 | +58.164 | +58.418 | 17-18/A-C | A659 | 1800
Steel Assembly | RIGID_FRAME | 79.7 | +58.164 | +58.418 | 18-19/A-C | A659 | 1800
Steel Assembly | RIGID_FRAME | 82.4 | +58.164 | +58.509 | 18-19/A-C | A660 | 1800
Steel Assembly | RIGID_FRAME | 82.4 | +58.164 | +58.509 | 18-19/B-D | A662 | 1800
Steel Assembly | RIGID_FRAME | 79.7 | +58.164 | +58.418 | 18-19/B-D | A661 | 1800
2 x Steel Assembly | RIGID_FRAME | 79.7 | +58.164 | +58.418 | 17-18/B-D | A661 | 1800
Steel Assembly | RIGID_FRAME | 79.7 | +58.164 | +58.418 | 16-17/B-D | A661 | 1800
Steel Assembly | RIGID_FRAME | 79.7 | +58.164 | +58.418 | 16-17/C-E | A661 | 1800
2 x Steel Assembly | RIGID_FRAME | 79.7 | +58.164 | +58.418 | 17-18/C-E | A661 | 1800
Steel Assembly | RIGID_FRAME | 82.4 | +58.164 | +58.509 | 18-19/C-E | A662 | 1800
Steel Assembly | RIGID_FRAME | 79.7 | +58.164 | +58.418 | 18-19/C-E | A661 | 1800
3 x Steel Assembly | RIGID_FRAME | 562.3 |  |  |  | A84 | 2020
Steel Assembly | RIGID_FRAME | 16.3 | +57.270 | +58.335 | 13-14/D-E | A428 | 327.616
Steel Assembly | RIGID_FRAME | 16.3 | +57.270 | +58.335 | 13-14/C-D | A82 | 90
Steel Assembly | RIGID_FRAME | 16.3 | +57.270 | +58.335 | 13-14/C-D | A428 | 327.616
Steel Assembly | RIGID_FRAME | 16.3 | +57.270 | +58.335 | 13-14/B-C | A82 | 90
Steel Assembly | RIGID_FRAME | 16.3 | +57.270 | +58.335 | 13-14/B-C | A428 | 327.616
Steel Assembly | RIGID_FRAME | 16.3 | +57.270 | +58.335 | 13-14/A-B | A82 | 90
Steel Assembly | RIGID_FRAME | 68.1 | +57.067 | +57.400 | 16-18/D-E | A59 | 275
Steel Assembly | RIGID_FRAME | 66.7 | +57.067 | +57.400 | 16-18/B-C | A74 | 250
Steel Assembly | RIGID_FRAME | 66.7 | +57.067 | +57.400 | 16-18/B-C | A72 | 250
Steel Assembly | RIGID_FRAME | 68.8 | +57.067 | +57.400 | 16-18/A-B | A58 | 305
2 x Steel Assembly | RIGID_FRAME | 0.9 | +51.611 | +51.835 | 1-2/C-D | A797 | 3
2 x Steel Assembly | RIGID_FRAME | 0.9 | +51.611 | +51.835 | 1-2/B-C | A797 | 3
2 x Steel Assembly | RIGID_FRAME | 0.9 | +50.760 | +50.984 | 1-2/C-D | A797 | 3
2 x Steel Assembly | RIGID_FRAME | 0.9 | +50.760 | +50.984 | 1-2/B-C | A797 | 3
Steel Assembly | RIGID_FRAME | 0.9 | +51.611 | +51.835 | 1-2/D-E | A797 | 3
Steel Assembly | RIGID_FRAME | 0.9 | +50.760 | +50.984 | 1-2/D-E | A797 | 3
Steel Assembly | RIGID_FRAME | 970.1 | +54.532 | +56.812 | 10-11/A-B | A253 | 1682
Steel Assembly | RIGID_FRAME | 970.8 | +52.547 | +54.828 | 8-9/A-B | A254 | 1682
Steel Assembly | RIGID_FRAME | 46.9 | +50.242 | +51.403 | 7/C | A22 | 230
Steel Assembly | RIGID_FRAME | 32.1 | +50.242 | +50.815 | 6/C | A21 | 230
Steel Assembly | RIGID_FRAME | 8.4 | +57.090 | +57.160 | 16-17/D-E | A214 | 70
Steel Assembly | RIGID_FRAME | 75.8 |  |  |  | A90 | 546.01
Steel Assembly | RIGID_FRAME | 6.3 | +57.090 | +57.160 | 13-14/D-E | A209 | 70
Steel Assembly | RIGID_FRAME | 27.5 | +57.130 | +57.270 | 14/D-E | A55 | 480.869
Steel Assembly | RIGID_FRAME | 4.6 | +57.090 | +57.160 | 13-14/D-E | A217 | 70
Steel Assembly | RIGID_FRAME | 66.7 |  |  |  | A91 | 494.009
Steel Assembly | RIGID_FRAME | 6.1 | +57.090 | +57.160 | 13-14/D-E | A213 | 70
Steel Assembly | RIGID_FRAME | 27.5 | +57.130 | +57.270 | 13-14/D-E | A56 | 466.993
Steel Assembly | RIGID_FRAME | 4.5 | +57.090 | +57.160 | 13-14/D-E | A215 | 70
Steel Assembly | RIGID_FRAME | 8.4 | +57.090 | +57.160 | 17-18/A-B | A206 | 70
Steel Assembly | RIGID_FRAME | 29.6 | +57.110 | +57.270 | 17/A-B | A50 | 495.296
Steel Assembly | RIGID_FRAME | 4.6 | +57.090 | +57.160 | 15/A-B | A218 | 70
Steel Assembly | RIGID_FRAME | 129 |  |  |  | A89 | 549.733
Steel Assembly | RIGID_FRAME | 6.3 | +57.090 | +57.160 | 14-15/A-B | A209 | 70
Steel Assembly | RIGID_FRAME | 27.5 | +57.130 | +57.270 | 14/A-B | A55 | 480.869
Steel Assembly | RIGID_FRAME | 4.6 | +57.090 | +57.160 | 13-14/A-B | A217 | 70
Steel Assembly | RIGID_FRAME | 6.3 | +57.090 | +57.160 | 13-14/A-B | A209 | 70
Steel Assembly | RIGID_FRAME | 27.5 | +57.130 | +57.270 | 13-14/A-B | A54 | 467.96
Steel Assembly | RIGID_FRAME | 23.8 | +57.450 | +57.590 | 15-16/D-E | A227 | 140
Steel Assembly | RIGID_FRAME | 23.8 | +57.450 | +57.590 | 15-16/C-D | A227 | 140
Steel Assembly | RIGID_FRAME | 0.9 | +57.450 | +57.520 | 15/B-C | A226 | 70
Steel Assembly | RIGID_FRAME | 0.9 | +57.450 | +57.520 | 15/C-D | A230 | 70
Steel Assembly | RIGID_FRAME | 0.9 | +57.450 | +57.520 | 15/B-C | A230 | 70
Steel Assembly | RIGID_FRAME | 0.9 | +57.450 | +57.520 | 15/A-B | A230 | 70
Steel Assembly | RIGID_FRAME | 22.3 | +57.450 | +57.590 | 15-16/B-C | A228 | 140
Steel Assembly | RIGID_FRAME | 22.3 | +57.450 | +57.590 | 15-16/A-B | A234 | 140
Steel Assembly | RIGID_FRAME | 22.3 | +57.450 | +57.590 | 15-16/B-C | A234 | 140
Steel Assembly | RIGID_FRAME | 22.3 | +57.450 | +57.590 | 15-16/C-D | A234 | 140
Steel Assembly | RIGID_FRAME | 29.6 | +58.080 | +58.220 | 15-16/D-E | A281 | 140
Steel Assembly | RIGID_FRAME | 29.6 | +58.080 | +58.220 | 15-16/C-D | A231 | 140
Steel Assembly | RIGID_FRAME | 29.6 | +58.080 | +58.220 | 15-16/C-D | A229 | 140
Steel Assembly | RIGID_FRAME | 29.6 | +58.080 | +58.220 | 15-16/B-C | A233 | 140
Steel Assembly | RIGID_FRAME | 29.6 | +58.080 | +58.220 | 15-16/B-C | A229 | 140
Steel Assembly | RIGID_FRAME | 29.6 | +58.080 | +58.220 | 15-16/A-B | A232 | 140
Steel Assembly | RIGID_FRAME | 969.6 | +51.554 | +53.835 | 7-8/A-B | A249 | 1682
Steel Assembly | RIGID_FRAME | 9.3 | +58.280 | +58.401 | 15-16/B-C | A478 | 121
Steel Assembly | RIGID_FRAME | 9.3 | +58.280 | +58.401 | 15-16/C-D | A479 | 121
Steel Assembly | RIGID_FRAME | 9.1 | +58.280 | +58.401 | 15-16/C-D | A480 | 121
Steel Assembly | RIGID_FRAME | 9.3 | +58.280 | +58.401 | 15-16/B-C | A479 | 121
Steel Assembly | RIGID_FRAME | 970.1 | +54.532 | +56.812 | 10-11/B-C | A251 | 1682
Steel Assembly | RIGID_FRAME | 100.9 | +57.970 | +58.086 | 16-19/C-D | A88 | 240
Steel Assembly | RIGID_FRAME | 100.9 | +57.970 | +58.086 | 16-19/B-C | A88 | 240
Steel Assembly | RIGID_FRAME | 100.9 | +57.970 | +58.086 | 16-19/A-B | A88 | 240
Steel Assembly | RIGID_FRAME | 100.9 | +57.970 | +58.086 | 16-19/D-E | A69 | 240
Steel Assembly | RIGID_FRAME | 100.9 | +57.970 | +58.086 | 16-19/C-D | A87 | 240
Steel Assembly | RIGID_FRAME | 100.9 | +57.970 | +58.086 | 16-19/B-C | A87 | 240
Steel Assembly | RIGID_FRAME | 970.1 | +53.540 | +55.820 | 9-10/A-B | A241 | 1682
Steel Assembly | RIGID_FRAME | 969.9 | +53.540 | +55.820 | 9-10/B-C | A240 | 1682
Steel Assembly | RIGID_FRAME | 970.1 | +53.540 | +55.820 | 9-10/C-D | A239 | 1682
Steel Assembly | RIGID_FRAME | 295.4 | +55.905 | +56.325 | 12/A-E | A2 | 90
Steel Assembly | RIGID_FRAME | 295.4 | +55.905 | +56.325 | 12/A-E | A1 | 90
Steel Assembly | RIGID_FRAME | 296.7 | +54.955 | +55.374 | 11/A-E | A4 | 90
Steel Assembly | RIGID_FRAME | 296.7 | +54.955 | +55.374 | 11/A-E | A3 | 90
Steel Assembly | RIGID_FRAME | 297.6 | +53.973 | +54.381 | 10/A-E | A6 | 90
Steel Assembly | RIGID_FRAME | 297.6 | +53.973 | +54.381 | 10/A-E | A5 | 90
Steel Assembly | RIGID_FRAME | 301.8 | +52.981 | +53.389 | 9/A-E | A8 | 90
Steel Assembly | RIGID_FRAME | 301.8 | +52.981 | +53.389 | 9/A-E | A7 | 90
Steel Assembly | RIGID_FRAME | 106.2 | +57.112 | +57.214 | 12-13/A-E | A307 | 100
Steel Assembly | RIGID_FRAME | 106.2 | +57.041 | +57.143 | 12-13/A-E | A306 | 100
Steel Assembly | RIGID_FRAME | 106.2 | +56.957 | +57.059 | 12-13/A-E | A306 | 100.021
Steel Assembly | RIGID_FRAME | 106.2 | +56.858 | +56.960 | 12-13/A-E | A306 | 99.9996
Steel Assembly | RIGID_FRAME | 106.2 | +56.746 | +56.849 | 12-13/A-E | A306 | 99.9999
Steel Assembly | RIGID_FRAME | 106.2 | +56.483 | +56.586 | 11-12/A-E | A306 | 100.387
Steel Assembly | RIGID_FRAME | 106.2 | +56.330 | +56.433 | 11-12/A-E | A306 | 99.9996
Steel Assembly | RIGID_FRAME | 106.2 | +56.168 | +56.271 | 11-12/A-E | A306 | 100
Steel Assembly | RIGID_FRAME | 106.2 | +56.003 | +56.106 | 11-12/A-E | A306 | 100.061
Steel Assembly | RIGID_FRAME | 106.2 | +55.838 | +55.941 | 11-12/A-E | A306 | 100
Steel Assembly | RIGID_FRAME | 106.2 | +55.505 | +55.608 | 10-11/A-E | A25 | 100.061
Steel Assembly | RIGID_FRAME | 106.2 | +55.340 | +55.444 | 10-11/A-E | A25 | 100.061
Steel Assembly | RIGID_FRAME | 106.2 | +55.175 | +55.279 | 10-11/A-E | A25 | 100.061
Steel Assembly | RIGID_FRAME | 106.2 | +55.010 | +55.114 | 10-11/A-E | A25 | 100.062
Steel Assembly | RIGID_FRAME | 106.2 | +54.845 | +54.949 | 10-11/A-E | A25 | 100.062
Steel Assembly | RIGID_FRAME | 106.2 | +54.512 | +54.616 | 9-10/A-E | A25 | 100.061
Steel Assembly | RIGID_FRAME | 106.2 | +54.348 | +54.451 | 9-10/A-E | A25 | 100.061
Steel Assembly | RIGID_FRAME | 106.2 | +54.183 | +54.287 | 9-10/A-E | A25 | 100.061
Steel Assembly | RIGID_FRAME | 106.2 | +54.018 | +54.122 | 9-10/A-E | A25 | 100.062
Steel Assembly | RIGID_FRAME | 106.2 | +53.853 | +53.957 | 9-10/A-E | A25 | 100.062
Steel Assembly | RIGID_FRAME | 106.2 | +53.520 | +53.624 | 8-9/A-E | A25 | 100.061
Steel Assembly | RIGID_FRAME | 106.2 | +53.355 | +53.459 | 8-9/A-E | A26 | 100.061
Steel Assembly | RIGID_FRAME | 106.2 | +53.191 | +53.294 | 8-9/A-E | A25 | 100.062
Steel Assembly | RIGID_FRAME | 106.2 | +53.026 | +53.130 | 8-9/A-E | A25 | 100.062
Steel Assembly | RIGID_FRAME | 106.2 | +52.861 | +52.965 | 8-9/A-E | A25 | 100.062
Steel Assembly | RIGID_FRAME | 106.2 | +52.528 | +52.632 | 7-8/A-E | A25 | 100.061
Steel Assembly | RIGID_FRAME | 106.2 | +52.363 | +52.467 | 7-8/A-E | A25 | 100.061
Steel Assembly | RIGID_FRAME | 106.2 | +52.198 | +52.302 | 7-8/A-E | A25 | 100.061
Steel Assembly | RIGID_FRAME | 106.2 | +52.033 | +52.137 | 7-8/A-E | A25 | 100.062
Steel Assembly | RIGID_FRAME | 106.2 | +51.869 | +51.972 | 7-8/A-E | A25 | 100.062
Steel Assembly | RIGID_FRAME | 106.2 | +51.573 | +51.677 | 6-7/A-E | A25 | 100.061
Steel Assembly | RIGID_FRAME | 106.2 | +51.409 | +51.513 | 6-7/A-E | A25 | 100.061
Steel Assembly | RIGID_FRAME | 106.2 | +51.244 | +51.348 | 6-7/A-E | A27 | 100.062
Steel Assembly | RIGID_FRAME | 305 | +52.010 | +52.396 | 8/A-E | A10 | 90
Steel Assembly | RIGID_FRAME | 305 | +52.010 | +52.396 | 8/A-E | A9 | 90
2 x Steel Assembly | RIGID_FRAME | 8.6 | +56.735 | +56.885 | 17-18/B-C | A71 | 180
2 x Steel Assembly | RIGID_FRAME | 8.6 | +56.735 | +56.885 | 17-18/C-D | A71 | 180
Steel Assembly | RIGID_FRAME | 8.6 | +56.735 | +56.885 | 17-18/D-E | A71 | 180
Steel Assembly | RIGID_FRAME | 8.6 | +56.735 | +56.885 | 20-21/D-E | A71 | 180
2 x Steel Assembly | RIGID_FRAME | 8.6 | +56.735 | +56.885 | 20-21/C-D | A71 | 180
2 x Steel Assembly | RIGID_FRAME | 8.6 | +56.735 | +56.885 | 20-21/B-C | A71 | 180
Steel Assembly | RIGID_FRAME | 8.6 | +56.735 | +56.885 | 20-21/A-B | A71 | 180
Steel Assembly | RIGID_FRAME | 8.6 | +56.735 | +56.885 | 17-18/A-B | A71 | 180
Steel Assembly | RIGID_FRAME | 7.8 | +50.242 | +50.392 | 5/D-E | -38AM92 | 133.4
2 x Steel Assembly | RIGID_FRAME | 7.8 | +50.242 | +50.392 | 5/C-D | -38AM92 | 133.4
2 x Steel Assembly | RIGID_FRAME | 7.8 | +50.242 | +50.392 | 5/B-C | -38AM92 | 133.4
Steel Assembly | RIGID_FRAME | 7.8 | +50.242 | +50.392 | 5/A-B | -38AM92 | 133.4
Steel Assembly | RIGID_FRAME | 7.8 | +50.242 | +50.392 | 4/A-B | -38AM52 | 133.4
Steel Assembly | RIGID_FRAME | 7.8 | +50.242 | +50.392 | 4/B-C | -38AM51 | 133.4
Steel Assembly | RIGID_FRAME | 7.8 | +50.242 | +50.392 | 4/B-C | -38AM52 | 133.4
Steel Assembly | RIGID_FRAME | 7.8 | +50.242 | +50.392 | 4/C-D | -38AM51 | 133.4
Steel Assembly | RIGID_FRAME | 7.8 | +50.242 | +50.392 | 4/C-D | -38AM52 | 133.4
Steel Assembly | RIGID_FRAME | 7.8 | +50.242 | +50.392 | 4/D-E | -38AM51 | 133.4
Steel Assembly | RIGID_FRAME | 7.8 | +50.242 | +50.392 | 3/D-E | -38AM52 | 133.4
2 x Steel Assembly | RIGID_FRAME | 7.8 | +50.242 | +50.392 | 3/C-D | -38AM52 | 133.4
2 x Steel Assembly | RIGID_FRAME | 7.8 | +50.242 | +50.392 | 3/B-C | -38AM52 | 133.4
Steel Assembly | RIGID_FRAME | 7.8 | +50.242 | +50.392 | 3/A-B | -38AM52 | 133.4
Steel Assembly | RIGID_FRAME | 2197.9 | +50.242 | +52.544 | 1-2/A-B | A30 | 2309.96
Steel Assembly | RIGID_FRAME | 2197.9 | +50.242 | +52.544 | 1-2/B-C | A30 | 2309.96
Steel Assembly | RIGID_FRAME | 2198.3 | +50.242 | +52.544 | 1-2/C-D | A29 | 2309.96
Steel Assembly | RIGID_FRAME | 14.9 | +57.525 | +57.665 | 15/C-E | A235 | 70
Steel Assembly | RIGID_FRAME | 14.9 | +57.525 | +57.665 | 15/B-D | A235 | 70
Steel Assembly | RIGID_FRAME | 14.9 | +57.525 | +57.665 | 15/A-C | A235 | 70
Steel Assembly | RIGID_FRAME | 11 | +57.270 | +58.382 | 13-14/D-E | A81 | 160
Steel Assembly | RIGID_FRAME | 11 | +57.270 | +58.382 | 13-14/C-D | A83 | 90
Steel Assembly | RIGID_FRAME | 11 | +57.270 | +58.382 | 13-14/C-D | A81 | 160
Steel Assembly | RIGID_FRAME | 11 | +57.270 | +58.382 | 13-14/B-C | A83 | 90
Steel Assembly | RIGID_FRAME | 11 | +57.270 | +58.382 | 13-14/B-C | A81 | 160
Steel Assembly | RIGID_FRAME | 11 | +57.270 | +58.382 | 13-14/A-B | A83 | 90
Steel Assembly | RIGID_FRAME | 15.1 | +57.500 | +57.640 | 13-14/C-E | A426 | 70
Steel Assembly | RIGID_FRAME | 15.1 | +57.500 | +57.640 | 13-14/B-D | A427 | 70
Steel Assembly | RIGID_FRAME | 15.1 | +57.500 | +57.640 | 13-14/A-C | A426 | 70
Steel Assembly | RIGID_FRAME | 15.1 | +57.600 | +57.740 | 13-14/C-E | A426 | 70
Steel Assembly | RIGID_FRAME | 15.1 | +57.600 | +57.740 | 13-14/B-D | A426 | 70
Steel Assembly | RIGID_FRAME | 15.1 | +57.600 | +57.740 | 13-14/A-C | A426 | 70
Steel Assembly | RIGID_FRAME | 9.1 | +51.915 | +52.055 | 5-6/C-E | A723 | 50
Steel Assembly | RIGID_FRAME | 9.3 | +52.006 | +52.150 | 5-6/C-E | A722 | 50
Steel Assembly | RIGID_FRAME | 10.5 | +51.667 | +51.836 | 4-5/C-E | A721 | 50
Steel Assembly | RIGID_FRAME | 10.5 | +51.787 | +51.959 | 4-5/C-E | A721 | 50
Steel Assembly | RIGID_FRAME | 10.5 | +51.419 | +51.588 | 3-4/C-E | A721 | 50
Steel Assembly | RIGID_FRAME | 10.5 | +51.539 | +51.711 | 3-4/C-E | A721 | 50
Steel Assembly | RIGID_FRAME | 11.1 | +51.145 | +51.327 | 2-3/C-E | A720 | 50
Steel Assembly | RIGID_FRAME | 11.1 | +51.278 | +51.463 | 2-3/C-E | A719 | 50
Steel Assembly | RIGID_FRAME | 2.6 | +50.937 | +51.137 | 2/C-D | A808 | 8
Steel Assembly | RIGID_FRAME | 9.1 | +51.915 | +52.055 | 5-6/B-D | A723 | 50
Steel Assembly | RIGID_FRAME | 9.3 | +52.006 | +52.150 | 5-6/B-D | A722 | 50
Steel Assembly | RIGID_FRAME | 10.5 | +51.667 | +51.836 | 4-5/B-D | A721 | 50
Steel Assembly | RIGID_FRAME | 10.5 | +51.787 | +51.959 | 4-5/B-D | A721 | 50
Steel Assembly | RIGID_FRAME | 10.5 | +51.419 | +51.588 | 3-4/B-D | A721 | 50
Steel Assembly | RIGID_FRAME | 10.5 | +51.539 | +51.711 | 3-4/B-D | A721 | 50
Steel Assembly | RIGID_FRAME | 11.1 | +51.145 | +51.327 | 2-3/B-D | A720 | 50
Steel Assembly | RIGID_FRAME | 11.1 | +51.278 | +51.463 | 2-3/B-D | A719 | 50
Steel Assembly | RIGID_FRAME | 2.6 | +50.937 | +51.137 | 2/B-C | A808 | 8
Steel Assembly | RIGID_FRAME | 27 | +56.772 | +56.910 | 19-20/A-C | A109 | 120
Steel Assembly | RIGID_FRAME | 55.9 | +56.735 | +56.918 | 19-20/A-B | A746 | 183.014
Steel Assembly | RIGID_FRAME | 55.9 | +56.735 | +56.918 | 19-20/B-C | A745 | 183.014
Steel Assembly | RIGID_FRAME | 27 | +56.772 | +56.910 | 19-20/B-D | A109 | 120
Steel Assembly | RIGID_FRAME | 55.9 | +56.735 | +56.918 | 19-20/B-C | A746 | 183.014
Steel Assembly | RIGID_FRAME | 55.9 | +56.735 | +56.918 | 19-20/C-D | A745 | 183.014
Steel Assembly | RIGID_FRAME | 27 | +56.772 | +56.910 | 19-20/C-E | A109 | 120
Steel Assembly | RIGID_FRAME | 55.9 | +56.735 | +56.918 | 19-20/C-D | A746 | 183.014
Steel Assembly | RIGID_FRAME | 55.9 | +56.735 | +56.918 | 19-20/D-E | A747 | 183.014
Steel Assembly | RIGID_FRAME | 9.3 | +52.006 | +52.150 | 5-6/A-C | A722 | 50
Steel Assembly | RIGID_FRAME | 10.5 | +51.787 | +51.959 | 4-5/A-C | A721 | 50
Steel Assembly | RIGID_FRAME | 9.1 | +51.915 | +52.055 | 5-6/A-C | A723 | 50
Steel Assembly | RIGID_FRAME | 9.1 | +50.577 | +51.167 | 1/C-D | A749 | 62.0053
2 x Steel Assembly | RIGID_FRAME | 9.1 | +50.577 | +51.167 | 1/B-C | A749 | 62.0053
Steel Assembly | RIGID_FRAME | 0.9 | +50.760 | +50.984 | 1-2/A-B | A797 | 3
Steel Assembly | RIGID_FRAME | 0.9 | +51.611 | +51.835 | 1-2/A-B | A797 | 3
Steel Assembly | RIGID_FRAME | 10.5 | +51.419 | +51.588 | 3-4/A-C | A721 | 50
Steel Assembly | RIGID_FRAME | 10.5 | +51.667 | +51.836 | 4-5/A-C | A721 | 50
Steel Assembly | RIGID_FRAME | 10.5 | +51.539 | +51.711 | 3-4/A-C | A721 | 50
Steel Assembly | RIGID_FRAME | 8.4 | +57.320 | +58.360 | 15-16/D-E | A551 | 498
2 x Steel Assembly | RIGID_FRAME | 8.4 | +57.320 | +58.360 | 15-16/C-D | A551 | 498
2 x Steel Assembly | RIGID_FRAME | 8.4 | +57.320 | +58.360 | 15-16/B-C | A551 | 498
Steel Assembly | RIGID_FRAME | 8.4 | +57.320 | +58.360 | 15-16/A-B | A551 | 498
Steel Assembly | RIGID_FRAME | 11.1 | +51.278 | +51.463 | 2-3/A-C | A719 | 50
Steel Assembly | RIGID_FRAME | 11.1 | +51.145 | +51.327 | 2-3/A-C | A720 | 50
Steel Assembly | RIGID_FRAME | 2.6 | +50.937 | +51.137 | 2/A-B | A808 | 8
2 x Steel Assembly |  | 0.7 | +50.914 | +52.076 | 5/C-D | A446 | 170
Steel Assembly |  | 0 | +51.521 | +51.579 | 5/C-D | A575 | 58.7368
2 x Steel Assembly |  | 0 | +51.500 | +51.555 | 5/C-D | A579 | 247.815
Steel Assembly |  | 0 | +52.024 | +52.083 | 5/C-D | A580 | 58.863
Steel Assembly |  | 0 | +52.005 | +52.059 | 5/C-D | A581 | 248.169
Steel Assembly |  | 0 | +51.521 | +51.579 | 5/C-D | A576 | 58.7368
Steel Assembly |  | 0 | +52.024 | +52.083 | 5/C-D | A578 | 58.863
Steel Assembly |  | 0 | +52.005 | +52.059 | 5/C-D | A577 | 248.169
2 x Steel Assembly |  | 0.7 | +50.914 | +52.076 | 5/B-C | A446 | 170
Steel Assembly |  | 0 | +51.521 | +51.579 | 5/B-C | A575 | 58.7368
2 x Steel Assembly |  | 0 | +51.500 | +51.555 | 5/B-C | A579 | 247.815
Steel Assembly |  | 0 | +52.024 | +52.083 | 5/B-C | A580 | 58.863
Steel Assembly |  | 0 | +52.005 | +52.059 | 5/B-C | A581 | 248.169
Steel Assembly | RIGID_FRAME | 5.5 | +52.930 | +53.021 | 5/B | A695 | 78.8
Steel Assembly | RIGID_FRAME | 35 | +52.717 | +52.846 | 4-5/B | A694 | 743.8
Steel Assembly | RIGID_FRAME | 5.5 | +52.930 | +53.021 | 5/C | A695 | 78.8
Steel Assembly | RIGID_FRAME | 34.9 | +52.717 | +52.846 | 4-5/C | A692 | 743.8
Steel Assembly | RIGID_FRAME | 5.5 | +52.930 | +53.021 | 5/D | A695 | 78.8
Steel Assembly | RIGID_FRAME | 34.9 | +52.717 | +52.846 | 4-5/D | A693 | 743.8
Steel Assembly | RIGID_FRAME | 14.3 | +50.392 | +51.564 | 3/C-D | A31 | 127
Steel Assembly | RIGID_FRAME | 16.8 | +50.392 | +51.812 | 4/C-D | A33 | 127
Steel Assembly | RIGID_FRAME | 16.8 | +50.392 | +51.812 | 4/B-C | A33 | 127
Steel Assembly | RIGID_FRAME | 14.3 | +50.392 | +51.564 | 3/B-C | A31 | 127
Steel Assembly | RIGID_FRAME | 14.3 | +50.392 | +51.564 | 3/D-E | A32 | 127
Steel Assembly | RIGID_FRAME | 16.8 | +50.392 | +51.812 | 4/D-E | A28 | 127
Steel Assembly | RIGID_FRAME | 16.8 | +50.392 | +51.812 | 4/C-D | A28 | 127
Steel Assembly | RIGID_FRAME | 14.3 | +50.392 | +51.564 | 3/C-D | A32 | 127
Steel Assembly | RIGID_FRAME | 14.3 | +50.392 | +51.564 | 3/B-C | A32 | 127
Steel Assembly | RIGID_FRAME | 16.8 | +50.392 | +51.812 | 4/B-C | A28 | 127
Steel Assembly | RIGID_FRAME | 14.3 | +50.392 | +51.564 | 3/A-B | A31 | 127
Steel Assembly | RIGID_FRAME | 16.8 | +50.392 | +51.812 | 4/A-B | A33 | 127
Steel Assembly | RIGID_FRAME | 512.1 | +56.799 | +58.509 | 19-20/B-C | A64 | 2150.1
8 x Steel Assembly | RIGID_FRAME | 1.9 | +57.105 | +57.245 | 16-17/C-D | A679 | 90
2 x Steel Assembly | RIGID_FRAME | 11.1 | +57.311 | +58.297 | 14-15/C-D | A429 | 70
2 x Steel Assembly | RIGID_FRAME | 11.1 | +57.311 | +58.297 | 14-15/B-C | A429 | 70
Steel Assembly | RIGID_FRAME | 4.2 | +58.349 | +58.399 | 15/C-E | A684 | 50
Steel Assembly | RIGID_FRAME | 4.2 | +58.349 | +58.399 | 15/B-D | A684 | 50
2 x Steel Assembly | RIGID_FRAME | 6.3 | +57.511 | +58.228 | 13-14/C-D | A431 | 70
Steel Assembly | RIGID_FRAME | 6.3 | +57.511 | +58.228 | 13-14/D-E | A431 | 70
Steel Assembly | RIGID_FRAME | 11.1 | +57.311 | +58.297 | 14-15/D-E | A429 | 70
Steel Assembly | RIGID_FRAME | 4.2 | +58.324 | +58.374 | 13-14/C-E | A683 | 50
Steel Assembly | RIGID_FRAME | 4.2 | +58.278 | +58.328 | 13-14/C-E | A683 | 50
2 x Steel Assembly | RIGID_FRAME | 6.3 | +57.511 | +58.228 | 13-14/B-C | A431 | 70
Steel Assembly | RIGID_FRAME | 4.2 | +58.324 | +58.374 | 13-14/B-D | A683 | 50
Steel Assembly | RIGID_FRAME | 4.2 | +58.278 | +58.328 | 13-14/B-D | A683 | 50
Steel Assembly | RIGID_FRAME | 11.1 | +57.311 | +58.297 | 14-15/A-B | A429 | 70
Steel Assembly | RIGID_FRAME | 6.3 | +57.511 | +58.228 | 13-14/A-B | A431 | 70
2 x Steel Assembly |  | 0 | +51.996 | +52.039 | 5/D-E | A568 | 34
2 x Steel Assembly |  | 0 | +51.490 | +51.534 | 5/D-E | A567 | 34
2 x Steel Assembly |  | 0 | +51.057 | +51.413 | 4-5/D-E | A569 | 34
2 x Steel Assembly |  | 0 | +51.387 | +51.524 | 4-5/D-E | A558 | 117.021
2 x Steel Assembly |  | 0 | +51.996 | +52.039 | 5/C-D | A568 | 34
2 x Steel Assembly |  | 0 | +51.490 | +51.534 | 5/C-D | A567 | 34
2 x Steel Assembly |  | 0 | +51.057 | +51.413 | 4-5/C-D | A569 | 34
2 x Steel Assembly |  | 0 | +51.387 | +51.524 | 4-5/C-D | A558 | 117.021
2 x Steel Assembly |  | 0 | +51.996 | +52.039 | 5/B-C | A568 | 34
2 x Steel Assembly |  | 0 | +51.490 | +51.534 | 5/B-C | A567 | 34
2 x Steel Assembly |  | 0 | +51.057 | +51.413 | 4-5/B-C | A569 | 34
2 x Steel Assembly |  | 0 | +51.387 | +51.524 | 4-5/B-C | A558 | 117.021
2 x Steel Assembly |  | 0 | +51.996 | +52.039 | 5/A-B | A568 | 34
2 x Steel Assembly |  | 0 | +51.490 | +51.534 | 5/A-B | A567 | 34
2 x Steel Assembly |  | 0 | +51.057 | +51.413 | 4-5/A-B | A569 | 34
2 x Steel Assembly |  | 0 | +51.387 | +51.524 | 4-5/A-B | A558 | 117.027
Steel Assembly | RIGID_FRAME | 33.1 | +50.981 | +51.217 | 14/B | A836 | 236.287
Steel Assembly | RIGID_FRAME | 80.7 | +50.242 | +50.969 | 14/B | A161 | 310
Steel Assembly | RIGID_FRAME | 33.1 | +50.981 | +51.217 | 13-14/C | A836 | 236.287
Steel Assembly | RIGID_FRAME | 80.7 | +50.242 | +50.969 | 13-14/C | A161 | 310
Steel Assembly | RIGID_FRAME | 33.1 | +50.981 | +51.217 | 13-14/D | A836 | 236.287
Steel Assembly | RIGID_FRAME | 80.7 | +50.242 | +50.969 | 13-14/D | A161 | 310
DUMMY |  | 0.2 | +51.135 | +51.200 | 14/B | A718 | 120.402
DUMMY |  | 0.2 | +51.135 | +51.200 | 13-14/C | A718 | 120.402
DUMMY |  | 0.2 | +51.135 | +51.200 | 13-14/D | A718 | 120.402
Steel Assembly | RIGID_FRAME | 11.9 | +50.969 | +50.981 | 14/B | A744 | 12
Steel Assembly | RIGID_FRAME | 11.9 | +50.969 | +50.981 | 13-14/C | A744 | 12
Steel Assembly | RIGID_FRAME | 11.9 | +50.969 | +50.981 | 13-14/D | A744 | 12
2 x Steel Assembly |  | 0 | +51.017 | +52.055 | 5/A-B | A164 | 60
Steel Assembly | RIGID_FRAME | 24.3 | +56.735 | +57.400 | 17-18/D-E | A321 | 155
Steel Assembly | RIGID_FRAME | 24.3 | +56.735 | +57.400 | 17-18/A-B | A322 | 155
2 x Steel Assembly | RIGID_FRAME | 65.8 | +55.175 | +55.775 | 19/C-D | A748 | 342
Steel Assembly | RIGID_FRAME | 65.8 | +55.175 | +55.775 | 19/B-C | A748 | 342
Steel Assembly | RIGID_FRAME | 65.8 | +55.175 | +55.775 | 19/D-E | A748 | 342
Steel Assembly | RIGID_FRAME | 512.1 | +56.799 | +58.509 | 19-20/C-D | A64 | 2150.1
Steel Assembly | RIGID_FRAME | 36.5 | +50.242 | +51.017 | 4-5/D-E | A317 | 90
6 x Pipe |  | 2.1 |  |  |  | A717 | 10.01
Steel Assembly | RIGID_FRAME | 35.7 | +56.735 | +58.317 | 19/C-D | A65 | 90
Steel Assembly | RIGID_FRAME | 35.7 | +56.735 | +58.317 | 19/A-B | A65 | 90
Steel Assembly | RIGID_FRAME | 35.5 | +56.735 | +58.305 | 19/B-C | A66 | 90
Steel Assembly | RIGID_FRAME | 35.5 | +56.735 | +58.305 | 19/D-E | A66 | 90
Steel Assembly | RIGID_FRAME | 35.5 | +56.735 | +58.305 | 19/C-D | A66 | 90
Steel Assembly | RIGID_FRAME | 35.7 | +56.735 | +58.317 | 19/B-C | A65 | 90
Steel Assembly | RIGID_FRAME | 35.7 | +56.735 | +58.317 | 18-19/C-D | A67 | 90
Steel Assembly | RIGID_FRAME | 35.7 | +56.735 | +58.317 | 18-19/A-B | A67 | 90
Steel Assembly | RIGID_FRAME | 35.7 | +56.735 | +58.317 | 18-19/B-C | A68 | 90
Steel Assembly | RIGID_FRAME | 35.7 | +56.735 | +58.317 | 18-19/D-E | A68 | 90
Steel Assembly | RIGID_FRAME | 35.7 | +56.735 | +58.317 | 18-19/C-D | A68 | 90
Steel Assembly | RIGID_FRAME | 35.7 | +56.735 | +58.317 | 18-19/B-C | A67 | 90
Steel Assembly | RIGID_FRAME | 40 | +56.735 | +58.317 | 17-18/C-D | A101 | 309.424
Steel Assembly | RIGID_FRAME | 40 | +56.735 | +58.317 | 17-18/A-B | A101 | 309.424
Steel Assembly | RIGID_FRAME | 40 | +56.735 | +58.317 | 17-18/B-C | A102 | 309.424
Steel Assembly | RIGID_FRAME | 40 | +56.735 | +58.317 | 17-18/D-E | A102 | 309.424
Steel Assembly | RIGID_FRAME | 40 | +56.735 | +58.317 | 17-18/C-D | A102 | 309.424
Steel Assembly | RIGID_FRAME | 40 | +56.735 | +58.317 | 17-18/B-C | A101 | 309.424
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 16-17/C-D | A329 | 80
Steel Assembly | RIGID_FRAME | 24.5 | +57.270 | +58.317 | 16-17/A-B | A328 | 80
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 16-17/B-C | A330 | 80
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 16-17/D-E | A330 | 80
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 16-17/C-D | A330 | 80
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 16-17/B-C | A329 | 80
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 16/C-D | A329 | 80
Steel Assembly | RIGID_FRAME | 24.5 | +57.270 | +58.317 | 16/A-B | A328 | 80
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 16/B-C | A330 | 80
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 16/D-E | A330 | 80
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 16/C-D | A330 | 80
Steel Assembly | RIGID_FRAME | 24.3 | +57.270 | +58.317 | 16/B-C | A329 | 80
Steel Assembly | RIGID_FRAME | 4.8 | +56.613 | +56.688 | 11-12/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.546 | +56.620 | 11-12/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.434 | +56.509 | 11-12/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.316 | +56.391 | 11-12/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +56.070 | +56.146 | 11-12/D-E | A225 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.946 | +56.022 | 11-12/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.823 | +55.898 | 11-12/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 4.8 | +55.740 | +55.816 | 11-12/D-E | A224 | 70
Steel Assembly | RIGID_FRAME | 104.1 | +56.612 | +56.715 | 12/A-E | A303 | 50
Steel Assembly | RIGID_FRAME | 104.1 | +55.679 | +55.783 | 11/A-E | A303 | 50
Steel Assembly | RIGID_FRAME | 146.6 | +55.771 | +56.845 | 11-12/D-E | A371 | 75
Steel Assembly | RIGID_FRAME | 146.6 | +55.771 | +56.845 | 11-12/D-E | A370 | 75
Steel Assembly | RIGID_FRAME | 146.6 | +55.771 | +56.845 | 11-12/C-D | A369 | 75
Steel Assembly | RIGID_FRAME | 146.6 | +55.771 | +56.845 | 11-12/C-D | A368 | 75
Steel Assembly | RIGID_FRAME | 146.6 | +55.771 | +56.845 | 11-12/B-C | A369 | 75
Steel Assembly | RIGID_FRAME | 146.6 | +55.771 | +56.845 | 11-12/B-C | A368 | 75
Steel Assembly | RIGID_FRAME | 146.6 | +55.771 | +56.845 | 11-12/A-B | A367 | 75
Steel Assembly | RIGID_FRAME | 146.6 | +55.771 | +56.845 | 11-12/A-B | A366 | 75
Steel Assembly | RIGID_FRAME | 74 | +52.142 | +52.357 | 5-6/C-E | A793 | 2000
Steel Assembly | RIGID_FRAME | 74 | +52.142 | +52.357 | 5-6/B-D | A793 | 2000
Steel Assembly | RIGID_FRAME | 74 | +52.142 | +52.357 | 5-6/A-C | A794 | 2000
Steel Assembly | RIGID_FRAME | 53 | +55.095 | +56.613 | 13/C | A11 | 671.859
2 x Steel Assembly |  | 0.7 | +51.090 | +52.121 | 5-6/B-C | A167 | 170.042
2 x Steel Assembly |  | 0.7 | +51.214 | +52.244 | 6/B-C | A167 | 170.042
Steel Assembly |  | 0 | +51.521 | +51.579 | 5/B-C | A576 | 58.7368
Steel Assembly |  | 0 | +52.024 | +52.083 | 5/B-C | A578 | 58.863
2 x Steel Assembly |  | 0 | +51.697 | +52.245 | 6/B-C | A587 | 34
2 x Steel Assembly |  | 0 | +52.050 | +52.233 | 5-6/B-C | A571 | 34
2 x Steel Assembly |  | 0 | +51.546 | +51.731 | 5-6/B-C | A572 | 34
Steel Assembly |  | 0 | +52.005 | +52.059 | 5/B-C | A577 | 248.169
2 x Steel Assembly |  | 0.7 | +51.090 | +52.121 | 5-6/C-D | A167 | 170.042
2 x Steel Assembly |  | 0.7 | +51.214 | +52.244 | 6/C-D | A167 | 170.042
2 x Steel Assembly |  | 0 | +51.697 | +52.245 | 6/C-D | A587 | 34
2 x Steel Assembly |  | 0 | +52.050 | +52.233 | 5-6/C-D | A571 | 34
2 x Steel Assembly |  | 0 | +51.546 | +51.731 | 5-6/C-D | A572 | 34
Steel Assembly |  | 0.7 | +51.105 | +52.135 | 5-6/D-E | A167 | 170.043
Steel Assembly |  | 0.7 | +51.228 | +52.259 | 6/D-E | A167 | 170.008
Steel Assembly |  | 0 | +51.697 | +52.245 | 6/D-E | A587 | 34
Steel Assembly |  | 0 | +52.005 | +52.233 | 5-6/D-E | A573 | 34
Steel Assembly |  | 0 | +51.501 | +51.731 | 5-6/D-E | A574 | 34
Steel Assembly |  | 0 | +51.697 | +52.245 | 6/A-B | A587 | 34
Steel Assembly |  | 0.7 | +51.090 | +52.121 | 5-6/A-B | A167 | 170.042
Steel Assembly |  | 0.7 | +51.214 | +52.244 | 6/A-B | A167 | 170.042
Steel Assembly |  | 0 | +52.005 | +52.233 | 5-6/A-B | A573 | 34
Steel Assembly |  | 0 | +51.501 | +51.731 | 5-6/A-B | A574 | 34
Steel Assembly | RIGID_FRAME | 104.1 | +57.161 | +57.262 | 13/A-E | A308 | 50
Steel Assembly | RIGID_FRAME | 2354.3 | +50.242 | +52.443 | 17-18/B-C | A139 | 2410
Steel Assembly | RIGID_FRAME | 33.1 | +52.102 | +52.172 | 17-19/B-C | A276 | 70
Steel Assembly | RIGID_FRAME | 2352.6 | +50.242 | +52.432 | 19/A-B | A138 | 2410
Steel Assembly | RIGID_FRAME | 33.5 | +52.102 | +52.172 | 19-21/A-B | A280 | 70
2 x Steel Assembly | RIGID_FRAME | 24.3 | +52.102 | +52.172 | 19-20/C-D | A263 | 70
Steel Assembly | RIGID_FRAME | 2032 | +50.242 | +52.432 | 19/C-D | A136 | 2410
Steel Assembly | RIGID_FRAME | 24.3 | +52.102 | +52.172 | 19-20/B-C | A263 | 70
Steel Assembly | RIGID_FRAME | 2032 | +50.242 | +52.432 | 19/B-C | A136 | 2410
Steel Assembly | RIGID_FRAME | 2354.3 | +50.242 | +52.452 | 18/D-E | A137 | 2414.3
Steel Assembly | RIGID_FRAME | 33.1 | +52.102 | +52.172 | 16-19/C-D | A276 | 70
Steel Assembly | RIGID_FRAME | 20.4 | +50.242 | +52.592 | 18-19/D-E | A132 | 140.001
Steel Assembly | RIGID_FRAME | 20.4 | +50.242 | +52.592 | 18-19/C-D | A132 | 140.001
Steel Assembly | RIGID_FRAME | 20.4 | +50.242 | +52.592 | 20-21/B-C | A132 | 140.001
2 x Steel Assembly | RIGID_FRAME | 9.1 | +55.180 | +55.770 | 19-20/C-D | A750 | 62.0053
Steel Assembly | RIGID_FRAME | 9.1 | +55.180 | +55.770 | 19-20/D-E | A750 | 62.0053
2 x Steel Assembly | RIGID_FRAME | 34.9 | +50.877 | +51.627 | 18-19/C-D | A829 | 80.0017
Steel Assembly | RIGID_FRAME | 34.9 | +50.877 | +51.627 | 18-19/D-E | A829 | 80.0017
Steel Assembly | RIGID_FRAME | 34.9 | +50.877 | +51.627 | 18-19/B-C | A829 | 80.0017
Steel Assembly | RIGID_FRAME | 34.9 | +50.877 | +51.627 | 20/A-B | A829 | 80.0017
Steel Assembly | RIGID_FRAME | 34.9 | +50.877 | +51.627 | 20/B-C | A829 | 80.0017
Steel Assembly | RIGID_FRAME | 13.4 | +50.342 | +52.594 | 19-20/D-E | A494 | 750
3 x Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 19-20/D-E | A491 | 750
Steel Assembly | RIGID_FRAME | 13.4 | +50.342 | +52.594 | 19-20/C-D | A493 | 750
6 x Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 19-20/C-D | A491 | 750
Steel Assembly | RIGID_FRAME | 24.3 | +52.102 | +52.172 | 19-20/D-E | A263 | 70
Steel Assembly | RIGID_FRAME | 24.3 | +50.652 | +50.722 | 19-20/D-E | A263 | 70
2 x Steel Assembly | RIGID_FRAME | 24.3 | +50.652 | +50.722 | 19-20/C-D | A263 | 70
Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.594 | 19/D-E | A496 | 750.01
Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.594 | 19/C-D | A495 | 750
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 19-20/C-D | A492 | 750
Steel Assembly | RIGID_FRAME | 13.4 | +50.342 | +52.594 | 19-20/B-C | A493 | 750
6 x Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 19-20/B-C | A491 | 750
Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.594 | 19/C-D | A496 | 750.01
Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.594 | 19/B-C | A495 | 750
Steel Assembly | RIGID_FRAME | 24.3 | +50.652 | +50.722 | 19-20/B-C | A263 | 70
Steel Assembly |  | 0 | +56.768 | +56.972 | 20-21/D-E | A716 | 100
2 x Steel Assembly |  | 0 | +56.768 | +56.972 | 20-21/C-D | A716 | 100
2 x Steel Assembly |  | 0 | +56.768 | +56.972 | 20-21/B-C | A716 | 100
Steel Assembly |  | 0 | +56.768 | +56.972 | 20-21/A-B | A716 | 100
Steel Assembly |  | 0 | +56.768 | +56.972 | 19-20/D-E | A716 | 100
2 x Steel Assembly |  | 0 | +56.768 | +56.972 | 19-20/C-D | A716 | 100
2 x Steel Assembly |  | 0 | +56.768 | +56.972 | 19-20/B-C | A716 | 100
Steel Assembly |  | 0 | +56.768 | +56.972 | 19-20/A-B | A716 | 100
Steel Assembly | RIGID_FRAME | 22.3 | +52.032 | +52.122 | 16-17/C-E | A702 | 180.001
Steel Assembly | RIGID_FRAME | 11.7 | +50.342 | +52.242 | 16-17/C-D | A522 | 513
Steel Assembly | RIGID_FRAME | 22.3 | +52.032 | +52.122 | 17-18/B-D | A702 | 180.001
Steel Assembly | RIGID_FRAME | 11.7 | +50.342 | +52.242 | 17-18/B-C | A522 | 513
Steel Assembly | RIGID_FRAME | 23.3 | +52.032 | +52.122 | 14/A-C | A699 | 180
Steel Assembly | RIGID_FRAME | 12.6 | +50.342 | +52.242 | 14/B-C | A514 | 658
Steel Assembly | RIGID_FRAME | 11.9 | +50.342 | +52.242 | 14/B | A511 | 459
Steel Assembly | RIGID_FRAME | 8 | +51.114 | +52.242 | 14/B | A482 | 459
Steel Assembly | RIGID_FRAME | 11.7 | +50.342 | +52.242 | 14/A-B | A513 | 491
Steel Assembly | RIGID_FRAME | 12.2 | +50.342 | +52.242 | 14/A-B | A512 | 603
Steel Assembly | RIGID_FRAME | 23.3 | +52.032 | +52.122 | 13/C-E | A700 | 180
Steel Assembly | RIGID_FRAME | 11.7 | +50.342 | +52.242 | 13/D-E | A513 | 491
Steel Assembly | RIGID_FRAME | 11.9 | +50.342 | +52.242 | 13/D | A511 | 459
Steel Assembly | RIGID_FRAME | 8 | +51.114 | +52.242 | 13/D | A482 | 459
Steel Assembly | RIGID_FRAME | 11.7 | +50.342 | +52.242 | 13/C-D | A513 | 491
Steel Assembly | RIGID_FRAME | 12.2 | +50.342 | +52.242 | 13/C-D | A509 | 600
Steel Assembly | RIGID_FRAME | 23.3 | +52.032 | +52.122 | 13-14/B-D | A699 | 180
Steel Assembly | RIGID_FRAME | 12.6 | +50.342 | +52.242 | 13-14/C-D | A514 | 658
Steel Assembly | RIGID_FRAME | 11.9 | +50.342 | +52.242 | 13-14/C | A511 | 459
Steel Assembly | RIGID_FRAME | 8 | +51.114 | +52.242 | 13-14/C | A482 | 459
Steel Assembly | RIGID_FRAME | 11.7 | +50.342 | +52.242 | 13-14/B-C | A513 | 491
Steel Assembly | RIGID_FRAME | 12.2 | +50.342 | +52.242 | 13-14/B-C | A512 | 603
Steel Assembly | RIGID_FRAME | 24.5 | +52.047 | +52.222 | 13-14/D-E | A115 | 230.5
5 x Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.242 | 13-14/D-E | A507 | 750
Steel Assembly | RIGID_FRAME | 24.5 | +52.047 | +52.222 | 13-16/D-E | A114 | 230.5
Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.242 | 14/D-E | A507 | 750
Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.242 | 15/D-E | A507 | 750
2 x Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.242 | 15-16/D-E | A507 | 750
Steel Assembly | RIGID_FRAME | 24.5 | +52.047 | +52.222 | 15-17/D-E | A113 | 230.5
Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.242 | 16/D-E | A507 | 750
Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.242 | 16-17/D-E | A507 | 750
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.242 | 16-17/D-E | A515 | 636.001
Steel Assembly | RIGID_FRAME | 23.9 | +52.047 | +52.222 | 16-18/C-D | A116 | 230.5
Steel Assembly | RIGID_FRAME | 13.2 | +50.342 | +52.242 | 17-18/C-D | A518 | 650
Steel Assembly | RIGID_FRAME | 13.2 | +50.342 | +52.242 | 17-18/C-D | A519 | 650
Steel Assembly | RIGID_FRAME | 23.9 | +52.047 | +52.222 | 17-18/B-C | A112 | 230.5
Steel Assembly | RIGID_FRAME | 13.2 | +50.342 | +52.242 | 18/B-C | A518 | 650
Steel Assembly | RIGID_FRAME | 13.2 | +50.342 | +52.242 | 18/B-C | A519 | 650
Steel Assembly | RIGID_FRAME | 23.9 | +52.047 | +52.222 | 13-14/C-D | A112 | 230.5
Steel Assembly | RIGID_FRAME | 13.2 | +50.342 | +52.242 | 13-14/C-D | A518 | 650
Steel Assembly | RIGID_FRAME | 13.2 | +50.342 | +52.242 | 13-14/C-D | A517 | 635
Steel Assembly | RIGID_FRAME | 23.9 | +52.047 | +52.222 | 13-15/B-C | A112 | 230.5
Steel Assembly | RIGID_FRAME | 13.2 | +50.342 | +52.242 | 13-14/B-C | A518 | 650
Steel Assembly | RIGID_FRAME | 13.2 | +50.342 | +52.242 | 14/B-C | A517 | 635
Steel Assembly | RIGID_FRAME | 24.5 | +52.047 | +52.222 | 17-18/A-B | A115 | 230.5
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.242 | 18/A-B | A516 | 636.001
2 x Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.242 | 17-18/A-B | A507 | 750
2 x Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.242 | 17/A-B | A507 | 750
Steel Assembly | RIGID_FRAME | 24.5 | +52.047 | +52.222 | 16-17/A-B | A114 | 230.5
2 x Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.242 | 16-17/A-B | A507 | 750
2 x Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.242 | 16/A-B | A507 | 750
Steel Assembly | RIGID_FRAME | 24.5 | +52.047 | +52.222 | 14-16/A-B | A113 | 230.5
Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.242 | 15-16/A-B | A507 | 750
2 x Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.242 | 15/A-B | A507 | 750
Steel Assembly | RIGID_FRAME | 15.9 | +52.102 | +52.172 | 18-19/C-E | A272 | 70
Steel Assembly | RIGID_FRAME | 12.6 | +50.342 | +52.594 | 18-19/D-E | A505 | 596.011
Steel Assembly | RIGID_FRAME | 12.8 | +50.342 | +52.594 | 18-19/D-E | A497 | 600
Steel Assembly | RIGID_FRAME | 12.8 | +50.342 | +52.594 | 18-19/D | A497 | 600
Steel Assembly | RIGID_FRAME | 33.1 | +52.102 | +52.172 | 16-19/D-E | A274 | 70
Steel Assembly | RIGID_FRAME | 18.6 | +50.342 | +52.594 | 18/D-E | A499 | 1440
3 x Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 17-18/D-E | A491 | 750
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 17/D-E | A491 | 750
Steel Assembly | RIGID_FRAME | 18.6 | +50.342 | +52.594 | 18/C-D | A500 | 1440
4 x Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 17-18/C-D | A491 | 750
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 17/C-D | A491 | 750
Steel Assembly | RIGID_FRAME | 15.4 | +52.102 | +52.172 | 18-19/B-D | A270 | 70
Steel Assembly | RIGID_FRAME | 13.2 | +50.342 | +52.594 | 19/C-D | A506 | 596.011
Steel Assembly | RIGID_FRAME | 12.8 | +50.342 | +52.594 | 19/C-D | A497 | 600
Steel Assembly | RIGID_FRAME | 12.8 | +50.342 | +52.594 | 19/C | A497 | 600
Steel Assembly | RIGID_FRAME | 33.1 | +52.102 | +52.172 | 17-19/C-D | A274 | 70
Steel Assembly | RIGID_FRAME | 18.6 | +50.342 | +52.594 | 18-19/C-D | A502 | 1440
2 x Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 18-19/C-D | A491 | 750
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 18/C-D | A491 | 750
Steel Assembly | RIGID_FRAME | 18.6 | +50.342 | +52.594 | 18-19/B-C | A501 | 1440
2 x Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 18-19/B-C | A491 | 750
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 18/B-C | A491 | 750
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 17-18/B-C | A491 | 750
Steel Assembly | RIGID_FRAME | 15.9 | +52.102 | +52.172 | 20-21/A-C | A283 | 70
Steel Assembly | RIGID_FRAME | 12.6 | +50.342 | +52.594 | 20-21/B-C | A539 | 596.011
Steel Assembly | RIGID_FRAME | 12.8 | +50.342 | +52.594 | 20-21/B-C | A537 | 600
Steel Assembly | RIGID_FRAME | 12.8 | +50.342 | +52.594 | 20-21/B | A537 | 600
Steel Assembly | RIGID_FRAME | 33.5 | +52.102 | +52.172 | 19-21/B-C | A278 | 70
Steel Assembly | RIGID_FRAME | 18.6 | +50.342 | +52.594 | 20/B-C | A499 | 1440
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 19/B-C | A491 | 750
Steel Assembly | RIGID_FRAME | 18.6 | +50.342 | +52.594 | 20/A-B | A500 | 1440
3 x Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 19-20/A-B | A491 | 750
Steel Assembly | RIGID_FRAME | 5.8 | +50.342 | +51.114 | 14/B | A483 | 459
Steel Assembly | RIGID_FRAME | 5.8 | +50.342 | +51.114 | 13-14/C | A483 | 459
Steel Assembly | RIGID_FRAME | 5.8 | +50.342 | +51.114 | 13/D | A483 | 459
Steel Assembly | RIGID_FRAME | 30 | +51.804 | +51.884 | 17-18/D-E | A830 | 80.0016
Steel Assembly | RIGID_FRAME | 12.2 | +51.932 | +51.994 | 17-18/D-E | A751 | 62.0005
Steel Assembly | RIGID_FRAME | 30 | +51.804 | +51.884 | 17-18/C-D | A830 | 80.0016
2 x Steel Assembly | RIGID_FRAME | 12.2 | +51.932 | +51.994 | 17-18/C-D | A751 | 62.0005
Steel Assembly | RIGID_FRAME | 30 | +51.804 | +51.884 | 18-19/C-D | A830 | 80.0016
Steel Assembly | RIGID_FRAME | 30 | +51.804 | +51.884 | 18-19/B-C | A830 | 80.0016
Steel Assembly | RIGID_FRAME | 12.2 | +51.932 | +51.994 | 17-18/B-C | A751 | 62.0005
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 19/A-B | A491 | 750
Steel Assembly | RIGID_FRAME | 2.5 | +52.178 | +52.190 | 18/C-D | A741 | 12
Steel Assembly | RIGID_FRAME | 2.5 | +52.178 | +52.190 | 18-19/C-D | A741 | 12
Steel Assembly | RIGID_FRAME | 2.5 | +52.178 | +52.190 | 18-19/B-C | A741 | 12
Steel Assembly | RIGID_FRAME | 30 | +51.804 | +51.884 | 19-20/B-C | A830 | 80.0016
Steel Assembly | RIGID_FRAME | 12.2 | +51.932 | +51.994 | 19-20/B-C | A751 | 62.0005
Steel Assembly | RIGID_FRAME | 30 | +51.804 | +51.884 | 19-20/A-B | A830 | 80.0016
Steel Assembly | RIGID_FRAME | 12.2 | +51.932 | +51.994 | 19-20/A-B | A751 | 62.0005
Steel Assembly | RIGID_FRAME | 2.5 | +52.178 | +52.190 | 20/B-C | A741 | 12
Steel Assembly | RIGID_FRAME | 2.5 | +52.178 | +52.190 | 20/A-B | A741 | 12
Steel Assembly | RIGID_FRAME | 489.4 |  |  | 15-17/A-B | A417 | 2487.2
Steel Assembly | RIGID_FRAME | 489.4 |  |  | 13-16/C-D | A417 | 2487.2
Steel Assembly | RIGID_FRAME | 489.4 |  |  | 13-14/C-D | A417 | 2487.2
Steel Assembly | RIGID_FRAME | 35.1 | +50.319 | +52.226 | 18/A-B | A125 | 335
Steel Assembly | RIGID_FRAME | 31.7 | +50.319 | +52.226 | 17/A-B | A127 | 160
Steel Assembly | RIGID_FRAME | 31.7 | +50.319 | +52.226 | 16/A-B | A127 | 160
Steel Assembly | RIGID_FRAME | 35.2 | +50.319 | +52.232 | 14/A-B | A124 | 335
Steel Assembly | RIGID_FRAME | 35.1 | +50.319 | +52.226 | 18/B-C | A123 | 335
Steel Assembly | RIGID_FRAME | 31.7 | +50.319 | +52.226 | 17/B-C | A127 | 160
Steel Assembly | RIGID_FRAME | 31.7 | +50.319 | +52.226 | 16/B-C | A128 | 160
Steel Assembly | RIGID_FRAME | 35.2 | +50.319 | +52.232 | 14/B-C | A126 | 335
Steel Assembly | RIGID_FRAME | 35.1 | +50.319 | +52.226 | 17-18/B-C | A125 | 335
Steel Assembly | RIGID_FRAME | 31.7 | +50.319 | +52.226 | 16-17/B-C | A128 | 160
Steel Assembly | RIGID_FRAME | 31.7 | +50.319 | +52.226 | 15/B-C | A127 | 160
Steel Assembly | RIGID_FRAME | 35.2 | +50.319 | +52.232 | 13-14/B-C | A124 | 335
Steel Assembly | RIGID_FRAME | 35.1 | +50.319 | +52.226 | 17-18/C-D | A122 | 335
Steel Assembly | RIGID_FRAME | 31.7 | +50.319 | +52.226 | 16-17/C-D | A127 | 160
Steel Assembly | RIGID_FRAME | 31.7 | +50.319 | +52.226 | 15/C-D | A128 | 160
Steel Assembly | RIGID_FRAME | 35.2 | +50.319 | +52.232 | 13-14/C-D | A126 | 335
Steel Assembly | RIGID_FRAME | 35.1 | +50.319 | +52.226 | 16-17/C-D | A125 | 335
Steel Assembly | RIGID_FRAME | 31.7 | +50.319 | +52.226 | 15-16/C-D | A128 | 160
Steel Assembly | RIGID_FRAME | 31.7 | +50.319 | +52.226 | 13-14/C-D | A127 | 160
Steel Assembly | RIGID_FRAME | 35.2 | +50.319 | +52.232 | 13-14/C-D | A124 | 335
Steel Assembly | RIGID_FRAME | 35.1 | +50.319 | +52.226 | 16-17/D-E | A123 | 335
Steel Assembly | RIGID_FRAME | 31.7 | +50.319 | +52.226 | 15-16/D-E | A127 | 160
Steel Assembly | RIGID_FRAME | 31.7 | +50.319 | +52.226 | 13-14/D-E | A127 | 160
Steel Assembly | RIGID_FRAME | 35.2 | +50.319 | +52.232 | 13-14/D-E | A126 | 335
Steel Assembly | RIGID_FRAME | 13.2 | +50.804 | +51.524 | 14/D-E | A752 | 62.0012
Steel Assembly | RIGID_FRAME | 13.2 | +50.804 | +51.524 | 14/C-D | A752 | 62.0012
Steel Assembly | RIGID_FRAME | 13.2 | +50.804 | +51.524 | 15-16/C-D | A752 | 62.0012
Steel Assembly | RIGID_FRAME | 13.2 | +50.804 | +51.524 | 15-16/B-C | A752 | 62.0012
Steel Assembly | RIGID_FRAME | 370.8 | +50.242 | +51.260 | 13-17/D-E | A130 | 285
Steel Assembly | RIGID_FRAME | 369.8 | +50.242 | +51.260 | 13-17/C-D | A131 | 285
Steel Assembly | RIGID_FRAME | 370.8 | +50.242 | +51.260 | 13-18/C-D | A130 | 285
Steel Assembly | RIGID_FRAME | 370.8 | +50.242 | +51.260 | 13-18/B-C | A129 | 285
Steel Assembly | RIGID_FRAME | 13.2 | +50.804 | +51.524 | 16-17/B-C | A752 | 62.0012
Steel Assembly | RIGID_FRAME | 13.2 | +50.804 | +51.524 | 16-17/A-B | A752 | 62.0012
Steel Assembly | RIGID_FRAME | 370.8 | +50.242 | +51.260 | 14-18/B-C | A130 | 285
Steel Assembly | RIGID_FRAME | 370.8 | +50.242 | +51.260 | 14-18/A-B | A129 | 285
Steel Assembly | RIGID_FRAME | 233.9 | +50.242 | +51.057 | 13-14/C | A110 | 875
Steel Assembly | RIGID_FRAME | 233.9 | +50.242 | +51.057 | 13/D | A110 | 875
Steel Assembly | RIGID_FRAME | 233.9 | +50.242 | +51.057 | 13-14/B | A110 | 875
Steel Assembly | RIGID_FRAME | 27.3 | +52.001 | +52.275 | 19-20/A-C | A143 | 260
Steel Assembly | RIGID_FRAME | 28.1 | +51.469 | +51.715 | 20/A-C | A142 | 220
Steel Assembly | RIGID_FRAME | 26.4 | +52.138 | +52.334 | 17-18/C-E | A141 | 200
Steel Assembly | RIGID_FRAME | 28.1 | +51.469 | +51.715 | 18/C-E | A142 | 220
Steel Assembly | RIGID_FRAME | 19.5 | +51.396 | +51.816 | 19-20/B-C | A135 | 190
Steel Assembly | RIGID_FRAME | 30.5 | +51.405 | +51.605 | 19-20/A-C | A140 | 200
Steel Assembly | RIGID_FRAME | 19.5 | +51.396 | +51.816 | 17-18/D-E | A135 | 190
Steel Assembly | RIGID_FRAME | 19.5 | +51.396 | +51.816 | 17-18/C-D | A134 | 190
Steel Assembly | RIGID_FRAME | 30.5 | +51.405 | +51.605 | 17-18/C-E | A140 | 200
Steel Assembly | RIGID_FRAME | 19.5 | +51.396 | +51.816 | 17-18/C-D | A135 | 190
Steel Assembly | RIGID_FRAME | 26.4 | +52.138 | +52.352 | 18-19/B-D | A141 | 200
Steel Assembly | RIGID_FRAME | 28.1 | +51.469 | +51.715 | 18-19/B-D | A142 | 220
Steel Assembly | RIGID_FRAME | 30.5 | +51.406 | +51.606 | 17-18/B-D | A140 | 200
Steel Assembly | RIGID_FRAME | 7.6 | +51.187 | +51.327 | 13-14/A-B | A266 | 140
Steel Assembly | RIGID_FRAME | 7.6 | +51.187 | +51.327 | 13-14/B | A264 | 140
Steel Assembly | RIGID_FRAME | 7.6 | +51.187 | +51.327 | 13-14/B-C | A266 | 140
Steel Assembly | RIGID_FRAME | 7.6 | +51.187 | +51.327 | 13-14/C | A265 | 140
Steel Assembly | RIGID_FRAME | 7.6 | +51.187 | +51.327 | 12-13/C-D | A266 | 140
Steel Assembly | RIGID_FRAME | 7.6 | +51.187 | +51.327 | 12-13/D | A264 | 140
Steel Assembly | RIGID_FRAME | 20.4 | +50.242 | +52.592 | 18-19/C-D | A133 | 140.001
Steel Assembly | RIGID_FRAME | 32.3 | +50.652 | +50.722 | 16-19/D-E | A273 | 70
Steel Assembly | RIGID_FRAME | 32.3 | +50.652 | +50.722 | 16-19/C-D | A275 | 70
Steel Assembly | RIGID_FRAME | 20.4 | +50.242 | +52.592 | 18-19/B-C | A133 | 140.001
Steel Assembly | RIGID_FRAME | 32.3 | +50.652 | +50.722 | 17-19/C-D | A273 | 70
Steel Assembly | RIGID_FRAME | 32.3 | +50.652 | +50.722 | 17-19/B-C | A275 | 70
Steel Assembly | RIGID_FRAME | 20.4 | +50.242 | +52.592 | 20-21/A-B | A133 | 140.001
Steel Assembly | RIGID_FRAME | 32.7 | +50.652 | +50.722 | 19-21/B-C | A277 | 70
Steel Assembly | RIGID_FRAME | 32.7 | +50.652 | +50.722 | 19-21/A-B | A279 | 70
Steel Assembly | RIGID_FRAME | 19.5 | +51.396 | +51.816 | 17-18/B-C | A134 | 190
Steel Assembly | RIGID_FRAME | 19.5 | +51.396 | +51.816 | 19-20/A-B | A134 | 190
Steel Assembly | RIGID_FRAME | 3.7 | +50.980 | +51.280 | 14/C-D | A648 | 140
Steel Assembly | RIGID_FRAME | 3.7 | +50.980 | +51.280 | 14/D-E | A647 | 140
Steel Assembly | RIGID_FRAME | 3.7 | +50.980 | +51.280 | 15-16/B-C | A648 | 140
Steel Assembly | RIGID_FRAME | 3.7 | +50.980 | +51.280 | 15-16/C-D | A647 | 140
Steel Assembly | RIGID_FRAME | 3.7 | +50.980 | +51.280 | 16-17/A-B | A648 | 140
Steel Assembly | RIGID_FRAME | 3.7 | +50.980 | +51.280 | 16-17/B-C | A647 | 140
Steel Assembly | RIGID_FRAME | 22.1 | +50.402 | +50.492 | 16-17/C-E | A698 | 65
Steel Assembly | RIGID_FRAME | 22.1 | +50.402 | +50.492 | 13/C-E | A698 | 65
Steel Assembly | RIGID_FRAME | 22.1 | +50.402 | +50.492 | 17-18/B-D | A698 | 65
Steel Assembly | RIGID_FRAME | 22.1 | +50.402 | +50.492 | 13-14/B-D | A698 | 65
Steel Assembly | RIGID_FRAME | 22.1 | +50.402 | +50.492 | 18/A-C | A698 | 65
Steel Assembly | RIGID_FRAME | 22.1 | +50.402 | +50.492 | 14/A-C | A698 | 65
Steel Assembly | RIGID_FRAME | 22.1 | +52.032 | +52.122 | 18/A-C | A701 | 65
Steel Assembly | RIGID_FRAME | 23.3 | +50.420 | +50.595 | 13-14/C-D | A111 | 85
Steel Assembly | RIGID_FRAME | 23.3 | +50.420 | +50.595 | 13-16/D-E | A111 | 85
Steel Assembly | RIGID_FRAME | 23.3 | +50.420 | +50.595 | 13-14/D-E | A111 | 85
Steel Assembly | RIGID_FRAME | 23.3 | +50.420 | +50.595 | 15-17/D-E | A111 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +50.420 | +50.595 | 13-14/C-D | A117 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +52.047 | +52.222 | 13-14/C-D | A117 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +52.047 | +52.222 | 13-14/D-E | A118 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +50.420 | +50.595 | 13-14/D-E | A118 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +52.047 | +52.222 | 16-17/C-D | A119 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +50.420 | +50.595 | 16-17/C-D | A119 | 85
Steel Assembly | RIGID_FRAME | 61.1 | +50.480 | +50.652 | 16-17/C-E | A121 | 172
Steel Assembly | RIGID_FRAME | 3.2 | +50.420 | +50.595 | 16-17/D-E | A120 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +52.047 | +52.222 | 16-17/D-E | A120 | 85
Steel Assembly | RIGID_FRAME | 23.3 | +50.420 | +50.595 | 13-15/B-C | A111 | 85
Steel Assembly | RIGID_FRAME | 23.3 | +50.420 | +50.595 | 16-18/C-D | A111 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +52.047 | +52.222 | 13-14/B-C | A117 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +50.420 | +50.595 | 13-14/B-C | A117 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +50.420 | +50.595 | 13-14/C-D | A118 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +52.047 | +52.222 | 13-14/C-D | A118 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +52.047 | +52.222 | 17-18/B-C | A119 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +50.420 | +50.595 | 17-18/B-C | A119 | 85
Steel Assembly | RIGID_FRAME | 61.1 | +50.480 | +50.652 | 17-18/B-D | A121 | 172
Steel Assembly | RIGID_FRAME | 3.2 | +50.420 | +50.595 | 17-18/C-D | A120 | 85
Steel Assembly | RIGID_FRAME | 23.3 | +50.420 | +50.595 | 16-17/A-B | A111 | 85
Steel Assembly | RIGID_FRAME | 23.3 | +50.420 | +50.595 | 14-16/A-B | A111 | 85
Steel Assembly | RIGID_FRAME | 23.3 | +50.420 | +50.595 | 17-18/A-B | A111 | 85
Steel Assembly | RIGID_FRAME | 23.3 | +50.420 | +50.595 | 17-18/B-C | A111 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +50.420 | +50.595 | 14/A-B | A117 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +52.047 | +52.222 | 14/A-B | A117 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +50.420 | +50.595 | 14/B-C | A118 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +52.047 | +52.222 | 14/B-C | A118 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +52.047 | +52.222 | 18/A-B | A119 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +50.420 | +50.595 | 18/A-B | A119 | 85
Steel Assembly | RIGID_FRAME | 61.1 | +50.480 | +50.652 | 18/A-C | A121 | 172
Steel Assembly | RIGID_FRAME | 3.2 | +50.420 | +50.595 | 18/B-C | A120 | 85
Steel Assembly | RIGID_FRAME | 3.2 | +52.047 | +52.222 | 18/B-C | A120 | 85
Steel Assembly | RIGID_FRAME | 42.2 | +51.057 | +51.073 | 13-14/B-C | A754 | 16
Steel Assembly | RIGID_FRAME | 42.2 | +51.057 | +51.073 | 12-13/C-D | A754 | 16
Steel Assembly | RIGID_FRAME | 42.2 | +51.057 | +51.073 | 13-14/A-B | A754 | 16
Steel Assembly | RIGID_FRAME | 11.7 | +50.342 | +52.242 | 16-17/C-D | A521 | 513
Steel Assembly | RIGID_FRAME | 11.7 | +50.342 | +52.242 | 17-18/B-C | A521 | 513
Steel Assembly | RIGID_FRAME | 12.8 | +50.342 | +52.242 | 14/B-C | A508 | 750
Steel Assembly | RIGID_FRAME | 12.2 | +50.342 | +52.242 | 13/D-E | A510 | 600
Steel Assembly | RIGID_FRAME | 12.8 | +50.342 | +52.242 | 13-14/C-D | A508 | 750
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.242 | 13/D-E | A516 | 636.001
Steel Assembly | RIGID_FRAME | 13.2 | +50.342 | +52.242 | 16-17/C-D | A517 | 635
Steel Assembly | RIGID_FRAME | 13.2 | +50.342 | +52.242 | 17-18/B-C | A517 | 635
Steel Assembly | RIGID_FRAME | 13.2 | +50.342 | +52.242 | 13-14/C-D | A519 | 650
Steel Assembly | RIGID_FRAME | 13.2 | +50.342 | +52.242 | 13-14/B-C | A519 | 650
Steel Assembly | RIGID_FRAME | 12.6 | +50.342 | +52.594 | 18-19/C-D | A498 | 600
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 16-17/D-E | A504 | 700.01
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 16-17/C-D | A503 | 700
Steel Assembly | RIGID_FRAME | 12.6 | +50.342 | +52.594 | 19/B-C | A498 | 600
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 17-18/C-D | A504 | 700.01
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 17-18/B-C | A503 | 700
Steel Assembly | RIGID_FRAME | 12.6 | +50.342 | +52.594 | 20-21/A-B | A538 | 600
Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.594 | 19/B-C | A496 | 750.01
Steel Assembly | RIGID_FRAME | 4.8 | +51.057 | +51.367 | 13-14/A-B | A525 | 310
Steel Assembly | RIGID_FRAME | 5 | +51.057 | +51.367 | 13-14/A-B | A523 | 310
Steel Assembly | RIGID_FRAME | 5 | +51.057 | +51.367 | 13-14/B | A523 | 310
Steel Assembly | RIGID_FRAME | 4.8 | +51.057 | +51.367 | 13-14/B-C | A525 | 310
Steel Assembly | RIGID_FRAME | 5 | +51.057 | +51.367 | 13-14/B-C | A524 | 310
Steel Assembly | RIGID_FRAME | 5 | +51.057 | +51.367 | 13-14/C | A523 | 310
Steel Assembly | RIGID_FRAME | 4.8 | +51.057 | +51.367 | 12-13/C-D | A525 | 310
Steel Assembly | RIGID_FRAME | 5 | +51.057 | +51.367 | 12-13/C-D | A524 | 310
Steel Assembly | RIGID_FRAME | 5 | +51.057 | +51.367 | 12-13/D | A523 | 310
Steel Assembly | RIGID_FRAME | 13.9 | +50.342 | +52.594 | 19/A-B | A495 | 750
Steel Assembly | RIGID_FRAME | 12.6 | +50.342 | +52.242 | 16-17/D-E | A520 | 718
Steel Assembly | RIGID_FRAME | 12.6 | +50.342 | +52.242 | 17-18/C-D | A520 | 718
Steel Assembly | RIGID_FRAME | 12.6 | +50.342 | +52.242 | 18/B-C | A520 | 718
Steel Assembly | RIGID_FRAME | 12.6 | +50.342 | +52.242 | 18/A-B | A520 | 718
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.242 | 14/A-B | A515 | 636.001
Steel Assembly | RIGID_FRAME | 1.7 | +50.957 | +51.327 | 13-14/A-B | A712 | 50
Steel Assembly | RIGID_FRAME | 1.7 | +50.957 | +51.327 | 13-14/A-B | A713 | 50
Steel Assembly | RIGID_FRAME | 1.7 | +50.957 | +51.327 | 13-14/B | A713 | 50
Steel Assembly | RIGID_FRAME | 1.7 | +50.957 | +51.327 | 13-14/B | A712 | 50
Steel Assembly | RIGID_FRAME | 4.8 | +51.257 | +51.327 | 13-14/A-B | A268 | 70
Steel Assembly | RIGID_FRAME | 1.7 | +50.957 | +51.327 | 13-14/B-C | A712 | 50
Steel Assembly | RIGID_FRAME | 1.7 | +50.957 | +51.327 | 13-14/B-C | A713 | 50
Steel Assembly | RIGID_FRAME | 1.7 | +50.957 | +51.327 | 13-14/C | A713 | 50
Steel Assembly | RIGID_FRAME | 1.7 | +50.957 | +51.327 | 13-14/C | A712 | 50
Steel Assembly | RIGID_FRAME | 4.8 | +51.257 | +51.327 | 13-14/B-C | A268 | 70
Steel Assembly | RIGID_FRAME | 1.7 | +50.957 | +51.327 | 12-13/C-D | A712 | 50
Steel Assembly | RIGID_FRAME | 1.7 | +50.957 | +51.327 | 13/C-D | A713 | 50
Steel Assembly | RIGID_FRAME | 1.7 | +50.957 | +51.327 | 12-13/D | A713 | 50
Steel Assembly | RIGID_FRAME | 1.7 | +50.957 | +51.327 | 13/D | A712 | 50
Steel Assembly | RIGID_FRAME | 4.8 | +51.257 | +51.327 | 12-13/C-D | A268 | 70
DUMMY |  | 0 | +51.115 | +51.221 | 12-13/A-D | A801 | 106
DUMMY |  | 0 | +51.155 | +51.181 | 12-13/A-D | A711 | 26
DUMMY |  | 0 | +51.115 | +51.221 | 13-14/A-C | A800 | 106
DUMMY |  | 0 | +51.155 | +51.181 | 13-14/A-C | A710 | 26
DUMMY |  | 0 | +51.115 | +51.221 | 13-14/A-B | A799 | 106
DUMMY |  | 0 | +51.155 | +51.181 | 13-14/A-B | A709 | 26
Steel Assembly | RIGID_FRAME | 10.8 | +51.118 | +51.218 | 13-14/A-B | A707 | 75
Steel Assembly | RIGID_FRAME | 29.6 | +51.118 | +51.218 | 13-14/A-C | A706 | 75
Steel Assembly | RIGID_FRAME | 48.2 | +51.118 | +51.218 | 12-13/A-D | A705 | 75
Steel Assembly | RIGID_FRAME | 0.9 | +51.137 | +51.367 | 18-19/D-E | A802 | 3
2 x Steel Assembly | RIGID_FRAME | 0.9 | +51.137 | +51.367 | 18-19/C-D | A802 | 3
Steel Assembly | RIGID_FRAME | 0.9 | +51.137 | +51.367 | 18-19/B-C | A802 | 3
Steel Assembly | RIGID_FRAME | 0.9 | +51.137 | +51.367 | 20-21/B-C | A802 | 3
Steel Assembly | RIGID_FRAME | 0.9 | +51.137 | +51.367 | 20-21/A-B | A802 | 3
Steel Assembly | RIGID_FRAME | 15.4 | +50.652 | +50.722 | 18-19/C-E | A271 | 70
Steel Assembly | RIGID_FRAME | 14.9 | +50.652 | +50.722 | 18-19/B-D | A269 | 70
Steel Assembly | RIGID_FRAME | 15.4 | +50.652 | +50.722 | 20-21/A-C | A282 | 70
Steel Assembly |  | 0 | +50.837 | +51.667 | 18-19/C-E | A704 | 830
Steel Assembly |  | 0 | +51.375 | +52.199 | 17-18/C-E | A440 | 824
Steel Assembly |  | 0 | +51.506 | +52.158 | 17-18/C-E | A703 | 652
Steel Assembly |  | 0 | +50.837 | +51.667 | 18-19/B-D | A704 | 830
Steel Assembly |  | 0 | +51.375 | +52.199 | 18-19/B-D | A440 | 824
Steel Assembly |  | 0 | +51.506 | +52.158 | 17-18/B-D | A703 | 652
Steel Assembly |  | 0 | +50.837 | +51.667 | 20-21/A-C | A704 | 830
Steel Assembly |  | 0 | +51.375 | +52.199 | 19-20/A-C | A440 | 824
Steel Assembly |  | 0 | +51.505 | +52.159 | 19-20/A-C | A438 | 654
Steel Assembly | RIGID_FRAME | 1.9 | +52.132 | +52.222 | 17-18/C-D | A697 | 65
Steel Assembly |  | 0 | +50.839 | +51.489 | 13-14/C-E | A696 | 650
Steel Assembly |  | 0 | +50.839 | +51.489 | 15-16/B-D | A696 | 650
Steel Assembly |  | 0 | +50.839 | +51.489 | 16-17/A-C | A696 | 650
2 x Steel Assembly | RIGID_FRAME | 26.1 | +58.317 | +58.418 | 16-17/C-E | A664 | 210.001
2 x Steel Assembly | RIGID_FRAME | 26.1 | +58.317 | +58.418 | 16-17/B-D | A664 | 210.001
Steel Assembly | RIGID_FRAME | 26.1 | +58.317 | +58.418 | 16-17/A-C | A664 | 210
Steel Assembly | RIGID_FRAME | 26.1 | +58.317 | +58.418 | 16-17/A-C | A663 | 210
Steel Assembly | RIGID_FRAME | 115.6 | +58.217 | +58.333 | 16-19/C-D | A75 | 240
Steel Assembly | RIGID_FRAME | 115.6 | +58.217 | +58.333 | 16-19/B-C | A75 | 240
Steel Assembly | RIGID_FRAME | 115.6 | +58.217 | +58.333 | 16-19/A-B | A77 | 240
Steel Assembly | RIGID_FRAME | 9.3 | +58.280 | +58.401 | 15-16/A-B | A477 | 121
Steel Assembly | RIGID_FRAME | 115.6 | +58.217 | +58.333 | 16-19/D-E | A76 | 240
Steel Assembly | RIGID_FRAME | 115.6 | +58.217 | +58.333 | 16-19/C-D | A76 | 240
Steel Assembly | RIGID_FRAME | 115.6 | +58.217 | +58.333 | 16-19/B-C | A76 | 240
Steel Assembly | RIGID_FRAME | 8.2 | +57.320 | +58.360 | 16/D-E | A541 | 646
Steel Assembly | RIGID_FRAME | 8.2 | +57.320 | +58.360 | 15/D-E | A542 | 671
Steel Assembly | RIGID_FRAME | 8.2 | +57.320 | +58.360 | 16/C-D | A540 | 646
Steel Assembly | RIGID_FRAME | 8.2 | +57.320 | +58.360 | 15/C-D | A543 | 671
Steel Assembly | RIGID_FRAME | 0.9 | +57.865 | +58.089 | 15-16/D-E | A796 | 3
2 x Steel Assembly | RIGID_FRAME | 0.9 | +57.865 | +58.089 | 15-16/C-D | A796 | 3
Steel Assembly | RIGID_FRAME | 8.2 | +57.320 | +58.360 | 16/C-D | A541 | 646
Steel Assembly | RIGID_FRAME | 8.2 | +57.320 | +58.360 | 15/C-D | A542 | 671
Steel Assembly | RIGID_FRAME | 8.2 | +57.320 | +58.360 | 16/B-C | A540 | 646
Steel Assembly | RIGID_FRAME | 8.2 | +57.320 | +58.360 | 15/B-C | A543 | 671
2 x Steel Assembly | RIGID_FRAME | 0.9 | +57.865 | +58.089 | 15-16/B-C | A796 | 3
Steel Assembly | RIGID_FRAME | 8.2 | +57.320 | +58.360 | 16/B-C | A541 | 646
Steel Assembly | RIGID_FRAME | 8.2 | +57.320 | +58.360 | 15/B-C | A542 | 671
Steel Assembly | RIGID_FRAME | 0.9 | +57.865 | +58.089 | 15-16/A-B | A796 | 3
