Properties of the parts of a building model (IFC2X3), part 5 of 16

# IfcDiscreteAccessory: DUMMY (4163)
Name | Description | Material | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x DUMMY | UC254*254*73 | STEEL/S355JR | +50.262 | +52.432 | 22 | 2 | 158.6 | 0 | 20.3 | 3.3 | 254.2 | 254 | 2170 | m394 | 3.22331 | 3.22331 | 0.0093121 | 0.0198674 | 0.0202073
11 x DUMMY | UC254*254*73 | STEEL/S355JR | +50.262 | +52.432 | 22 | 2 | 158.6 | 0 | 20.3 | 3.3 | 254.2 | 254 | 2170 | m393 | 3.22331 | 3.22331 | 0.0093121 | 0.0198674 | 0.0202073
DUMMY | UC254*254*73 | STEEL/S355JR | +50.262 | +52.432 | 22 | 2 | 158.6 | 0 | 20.3 | 3.3 | 254.2 | 254 | 2170 | m395 | 3.22331 | 3.22331 | 0.0093121 | 0.0198674 | 0.0202073
DUMMY | PL12*152 | STEEL/S355JR | +52.026 | +52.178 | 22 | 2 | 8.8 | 0 | 23.6 | 0.2 | 152 | 12 | 660 | p171 | 0.209216 | 0.220128 | 0.001824 | 0.0011281 | 0.00120384
DUMMY | PL12*152 | STEEL/S355JR | +52.026 | +52.178 | 22 | 2 | 8.8 | 0 | 23.6 | 0.2 | 152 | 12 | 660 | p171 | 0.209208 | 0.220128 | 0.001824 | 0.00112804 | 0.00120384
12 x DUMMY | D4 | STEEL/S355JR | +51.162 | +51.166 | 22 | 2 | 0 | 0 |  | 0 | 3.5 | 4 | 70 | m927 | 0.000860785 | 0.000860785 | 0.0000103923 | 7.27461e-07 | 7.27461e-07
12 x DUMMY | PL50*70 | Undefined/Hard Rubber | +51.129 | +51.199 | 22 | 2 | 0 | 0 |  | 0 | 70 | 50 | 70 | p593 | 0.022546 | 0.0049 | 0.0025 | 0.000235615 | 0.000235615
12 x DUMMY | FL6*80 | STEEL/S355JR | +51.124 | +51.204 | 22 | 2 | 0.5 | 0 | 49.3 | 0 | 80 | 6 | 145 | p654 | 0.0239523 | 0.0116 | 0.000036 | 0.0000618369 | 0.0000690369
12 x DUMMY | D60 | STEEL/S355JR | +51.134 | +51.194 | 22 | 2 | 0.1 | 0 | 48.7 | 0 | 60 | 60 | 11 | m926 | 0.00653736 | 0.0075708 | 0.00275532 | 0.0000171085 | 0.0000303085
12 x DUMMY | D60 | STEEL/S355JR | +51.134 | +51.194 | 22 | 2 | 0.1 | 0 | 48.7 | 0 | 60 | 60 | 11 | m925 | 0.00653736 | 0.0075708 | 0.00275532 | 0.0000171085 | 0.0000303085
12 x DUMMY | D40 | STEEL/S355JR | +51.144 | +51.184 | 22 | 2 | 1.1 | 0 | 16.2 | 0 | 40 | 40 | 115 | m924 | 0.0174668 | 0.0166868 | 0.0012 | 0.000137325 | 0.000138
12 x DUMMY | D35 | Undefined/Vesconite | +51.162 | +51.166 | 22 | 2 | 0 | 0 |  | 0 | 3.5 | 4 | 30.9 | m710 | 0.000391585 | 0.0072727 | 0.00091875 | 3.21122e-07 | 0.0000459375
12 x DUMMY | PL10*76.4 | STEEL/S355JR | +51.094 | +51.234 | 22 | 2 | 0.7 | 0 | 30.6 | 0 | 76.4 | 10 | 140 | p260 | 0.02572 | 0.02572 | 0.0014 | 0.00010696 | 0.00010696
12 x DUMMY | PL10*140 | STEEL/S355JR | +51.094 | +51.234 | 22 | 2 | 3.9 | 0 | 28.5 | 0.1 | 140 | 10 | 370 | p261 | 0.112642 | 0.1138 | 0.0014 | 0.000506 | 0.000518
12 x DUMMY | PL10*140 | STEEL/S355JR | +51.094 | +51.234 | 22 | 2 | 3.9 | 0 | 28.5 | 0.1 | 140 | 10 | 370 | p262 | 0.112642 | 0.1138 | 0.0014 | 0.000506 | 0.000518
3 x DUMMY | FL16*300 | STEEL/S355JR | +51.014 | +51.314 | 22 | 2 | 16.5 | 0 | 18.1 | 0.3 | 300 | 16 | 450 | p679 | 0.29742 | 0.135 | 0.000256 | 0.00208771 | 0.00212827
26 x DUMMY | L50*50*5 | STEEL/S355JR | +50.555 | +50.605 | 22 | 2 | 0.7 | 0 | 51.5 | 0 | 50 | 50 | 147 | m947 | 0.0285167 | 0.0285167 | 0.000480255 | 0.000067825 | 0.0000705975
26 x DUMMY | L50*50*5 | STEEL/S355JR | +52.182 | +52.232 | 22 | 2 | 0.7 | 0 | 51.5 | 0 | 50 | 50 | 147 | m947 | 0.0285167 | 0.0285167 | 0.000480255 | 0.000067825 | 0.0000705975
26 x DUMMY | L50*50*5 | STEEL/S355JR | +50.555 | +50.605 | 22 | 2 | 0.7 | 0 | 51.5 | 0 | 50 | 50 | 147 | m948 | 0.0285167 | 0.0285167 | 0.000480255 | 0.000067825 | 0.0000705975
4 x DUMMY | FL5*40 | STEEL/S355JR | +51.272 | +51.312 | 22 | 2 | 0.9 | 0 | 57.8 | 0.1 | 40 | 5 | 556 | p574 | 0.0504401 | 0.0504401 | 0.0002 | 0.0001112 | 0.0001112
26 x DUMMY | L50*50*5 | STEEL/S355JR | +52.182 | +52.232 | 22 | 2 | 0.7 | 0 | 51.5 | 0 | 50 | 50 | 147 | m948 | 0.0285167 | 0.0285167 | 0.000480255 | 0.000067825 | 0.0000705975
4 x DUMMY | PL3*580 | Undefined/VEM 6320H | +50.370 | +52.214 | 22 | 2 | 0 | 0 |  | 2.2 | 580 | 3 | 1844 | p363 | 2.15359 | 1.06952 | 0.000009 | 0.00320856 | 0.00320856
4 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 630 | m536 | 0.0975553 | 0.0975553 | 0.000235669 | 0.00014553 | 0.000148471
4 x DUMMY | L40*40*3 | STEEL/S355JR | +52.202 | +52.242 | 22 | 2 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 630 | m536 | 0.0975554 | 0.0975554 | 0.000235669 | 0.00014553 | 0.000148472
6 x DUMMY | L60*60*6 | STEEL/S355JR | +51.972 | +52.032 | 22 | 2 | 0.3 | 0 | 43 | 0 | 60 | 60 | 55 | m650 | 0.0128223 | 0.0128223 | 0.000690446 | 0.00003762 | 0.0000379745
6 x DUMMY | L60*60*6 | STEEL/S355JR | +51.972 | +52.032 | 22 | 2 | 1.4 | 0 | 43 | 0.1 | 60 | 60 | 252.6 | m651 | 0.058901 | 0.058901 | 0.000690446 | 0.000172813 | 0.000174441
6 x DUMMY | L60*60*6 | STEEL/S355JR | +51.972 | +52.032 | 22 | 2 | 0.3 | 0 | 43 | 0 | 60 | 60 | 55 | m652 | 0.0128223 | 0.0128223 | 0.000690446 | 0.00003762 | 0.0000379745
6 x DUMMY | L60*60*6 | STEEL/S355JR | +51.972 | +52.032 | 22 | 2 | 1.4 | 0 | 43 | 0.1 | 60 | 60 | 252.6 | m653 | 0.058901 | 0.058901 | 0.000690446 | 0.000172813 | 0.000174441
24 x DUMMY | FL10*100 | STEEL/S355JR | +50.842 | +51.130 | 22 | 2 | 2 | 0 | 29.3 | 0.1 | 100 | 10 | 287.8 | p100 | 0.0563632 | 0.02878 | 0.0001 | 0.00024565 | 0.00024565
24 x DUMMY | PLT10*187.6 | STEEL/S355JR | +50.830 | +51.017 | 22 | 2 | 3 | 0 | 28 | 0.1 | 187.6 | 10 | 207.1 | p101 | 0.0834465 | 0.038852 | 0.0001 | 0.00037952 | 0.00037952
4 x DUMMY | FL5*40 | STEEL/S355JR | +51.272 | +51.312 | 22 | 2 | 0.7 | 0 | 57.9 | 0 | 40 | 5 | 433 | p577 | 0.03937 | 0.03937 | 0.0002 | 0.0000866 | 0.0000866
4 x DUMMY | PL3*457 | Undefined/VEM 6320H | +50.370 | +52.214 | 22 | 2 | 0 | 0 |  | 1.7 | 457 | 3 | 1844 | p367 | 1.69922 | 0.842708 | 0.000009 | 0.00252812 | 0.00252812
4 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 0.9 | 0 | 83.7 | 0.1 | 40 | 40 | 507 | m539 | 0.0785087 | 0.0785087 | 0.000235669 | 0.000117117 | 0.000119484
4 x DUMMY | L40*40*3 | STEEL/S355JR | +52.202 | +52.242 | 22 | 2 | 0.9 | 0 | 83.7 | 0.1 | 40 | 40 | 507 | m539 | 0.0785088 | 0.0785088 | 0.000235669 | 0.000117117 | 0.000119484
12 x DUMMY | L50*50*5 | STEEL/S355JR | +50.555 | +50.605 | 22 | 2 | 0.7 | 0 | 51.5 | 0 | 50 | 50 | 150 | m949 | 0.0290987 | 0.0290987 | 0.000480255 | 0.00006925 | 0.0000720382
12 x DUMMY | L50*50*5 | STEEL/S355JR | +52.182 | +52.232 | 22 | 2 | 0.7 | 0 | 51.5 | 0 | 50 | 50 | 150 | m949 | 0.0290987 | 0.0290987 | 0.000480255 | 0.00006925 | 0.0000720382
12 x DUMMY | L50*50*5 | STEEL/S355JR | +50.555 | +50.605 | 22 | 2 | 0.7 | 0 | 51.5 | 0 | 50 | 50 | 150 | m950 | 0.0290987 | 0.0290987 | 0.000480255 | 0.00006925 | 0.0000720382
12 x DUMMY | L50*50*5 | STEEL/S355JR | +52.182 | +52.232 | 22 | 2 | 0.7 | 0 | 51.5 | 0 | 50 | 50 | 150 | m950 | 0.0290987 | 0.0290987 | 0.000480255 | 0.00006925 | 0.0000720382
4 x DUMMY | FL5*40 | STEEL/S355JR | +51.272 | +51.312 | 22 | 2 | 0.9 | 0 | 57.8 | 0.1 | 40 | 5 | 555 | p574 | 0.05035 | 0.05035 | 0.0002 | 0.000111 | 0.000111
4 x DUMMY | PL3*579 | Undefined/VEM 6320H | +50.370 | +52.214 | 22 | 2 | 0 | 0 |  | 2.1 | 579 | 3 | 1844 | p363 | 2.14989 | 1.06768 | 0.000009 | 0.00320303 | 0.00320303
4 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 629 | m536 | 0.0974004 | 0.0974004 | 0.000235669 | 0.000145299 | 0.000148236
4 x DUMMY | L40*40*3 | STEEL/S355JR | +52.202 | +52.242 | 22 | 2 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 629 | m536 | 0.0974004 | 0.0974004 | 0.000235669 | 0.000145299 | 0.000148236
7 x DUMMY | FL5*40 | STEEL/S355JR | +51.272 | +51.312 | 22 | 2 | 0.9 | 0 | 57.8 | 0.1 | 40 | 5 | 570 | p576 | 0.0517 | 0.0517 | 0.0002 | 0.000114 | 0.000114
8 x DUMMY | PL3*594 | Undefined/VEM 6320H | +50.370 | +52.214 | 22 | 2 | 0 | 0 |  | 2.2 | 594 | 3 | 1844 | p366 | 2.2053 | 1.09534 | 0.000009 | 0.00328601 | 0.00328601
8 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 644 | m537 | 0.0997231 | 0.0997231 | 0.000235669 | 0.000148764 | 0.000151771
8 x DUMMY | L40*40*3 | STEEL/S355JR | +52.202 | +52.242 | 22 | 2 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 644 | m537 | 0.0997232 | 0.0997232 | 0.000235669 | 0.000148764 | 0.000151771
4 x DUMMY | FL5*40 | STEEL/S355JR | +51.272 | +51.312 | 22 | 2 | 0.9 | 0 | 57.7 | 0.1 | 40 | 5 | 638 | p575 | 0.05782 | 0.05782 | 0.0002 | 0.0001276 | 0.0001276
4 x DUMMY | PL3*662 | Undefined/VEM 6320H | +50.370 | +52.214 | 22 | 2 | 0 | 0 |  | 2.4 | 662 | 3 | 1844 | p365 | 2.45649 | 1.22073 | 0.000009 | 0.00366218 | 0.00366218
4 x DUMMY | L40*40*3 | STEEL/S355JR | +50.342 | +50.382 | 22 | 2 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 712 | m538 | 0.110253 | 0.110253 | 0.000235669 | 0.000164472 | 0.000167796
4 x DUMMY | L40*40*3 | STEEL/S355JR | +52.202 | +52.242 | 22 | 2 | 1.2 | 0 | 83.7 | 0.1 | 40 | 40 | 712 | m538 | 0.110253 | 0.110253 | 0.000235669 | 0.000164472 | 0.000167796
DUMMY | FL5*40 | STEEL/S355JR | +51.272 | +51.312 | 22 | 2 | 0.9 | 0 | 57.8 | 0.1 | 40 | 5 | 570 | p576 | 0.0517001 | 0.0517001 | 0.0002 | 0.000114 | 0.000114
6 x DUMMY | PL50*50 | STEEL/S355JR | +50.804 | +50.854 | 22 | 2 | 0.9 | 0 | 15.3 | 0 | 50 | 50 | 50 | p594 | 0.015 | 0.015 | 0.0025 | 0.000125 | 0.000125
6 x DUMMY | PL50*50 | STEEL/S355JR | +51.474 | +51.524 | 22 | 2 | 0.9 | 0 | 15.3 | 0 | 50 | 50 | 50 | p594 | 0.015 | 0.015 | 0.0025 | 0.000125 | 0.000125
6 x DUMMY | FL8*80 | STEEL/S355JR | +51.078 | +51.250 | 22 | 2 | 0.9 | 0 | 36.5 | 0 | 80 | 8 | 172.4 | p317 | 0.0316224 | 0.013792 | 0.000064 | 0.000110336 | 0.000110336
12 x DUMMY | FL20*100 | STEEL/S355JR | +50.980 | +51.000 | 22 | 2 | 2.2 | 0 | 17.1 | 0 | 100 | 20 | 140 | p671 | 0.0376 | 0.0376 | 0.0028 | 0.00028 | 0.00028
6 x DUMMY | PL8*125 | STEEL/S355JR | +51.064 | +51.264 | 22 | 2 | 1.6 | 0 | 35.2 | 0.1 | 125 | 8 | 200 | p318 | 0.0552 | 0.0552 | 0.001 | 0.0002 | 0.0002
6 x DUMMY | PL6*135 | STEEL/S355JR | +50.809 | +50.815 | 22 | 2 | 0.7 | 0 | 46.5 | 0 | 135 | 6 | 192 | p655 | 0.0393205 | 0.02592 | 0.000036 | 0.000107762 | 0.000107762
6 x DUMMY | PL6*135 | STEEL/S355JR | +51.513 | +51.519 | 22 | 2 | 0.7 | 0 | 46.5 | 0 | 135 | 6 | 192 | p655 | 0.0393205 | 0.02592 | 0.000036 | 0.000107762 | 0.000107762
3 x DUMMY | PLT6*192 | STEEL/S355JR | +51.161 | +51.167 | 22 | 2 | 2.1 | 0 | 44.8 | 0.1 | 192 | 6 | 235.9 | p236 | 0.0947155 | 0.0957204 | 0.001152 | 0.000269058 | 0.000271757
6 x DUMMY | PL12*297 | STEEL/S355JR | +50.794 | +51.534 | 22 | 2 | 17.3 | 0 | 22.6 | 0.3 | 297 | 12 | 740 | p173 | 0.390121 | 0.21978 | 0.000144 | 0.00220236 | 0.00220236
6 x DUMMY | PL8*236 | STEEL/S355JR | +50.794 | +51.534 | 22 | 2 | 10.3 | 0 | 33.3 | 0.3 | 236 | 8 | 740 | p319 | 0.343959 | 0.17464 | 0.000064 | 0.00131712 | 0.00131712
6 x DUMMY | PL6*162 | STEEL/S355JR | +51.240 | +51.246 | 22 | 2 | 2.3 | 0 | 44.9 | 0.1 | 162 | 6 | 301.1 | p656 | 0.103114 | 0.103114 | 0.000972 | 0.000292669 | 0.000292669
3 x DUMMY | PL6*163.2 | STEEL/S355JR | +51.082 | +51.088 | 22 | 2 | 2.3 | 0 | 44.9 | 0.1 | 163.2 | 6 | 301.1 | p656 | 0.103851 | 0.103851 | 0.0009792 | 0.000294837 | 0.000294837
3 x DUMMY | PL6*192 | STEEL/S355JR | +51.161 | +51.167 | 22 | 2 | 2.1 | 0 | 44.8 | 0.1 | 192 | 6 | 235.9 | p657 | 0.0947155 | 0.0957204 | 0.001152 | 0.000269058 | 0.000271757
3 x DUMMY | PL6*162 | STEEL/S355JR | +51.082 | +51.088 | 22 | 2 | 2.3 | 0 | 44.9 | 0.1 | 162 | 6 | 301.1 | p656 | 0.103114 | 0.103114 | 0.000972 | 0.000292669 | 0.000292669
6 x DUMMY | C152*76 | STEEL/S355JR | +51.088 | +51.240 | 22 | 2 | 40.2 | 0.2 | 32.6 | 1.3 | 152.4 | 76.2 | 2243.9 | m313 | 1.31104 | 1.31104 | 0.00228026 | 0.00492015 | 0.00511666
3 x DUMMY | C152*76 | STEEL/S355JR | +51.088 | +51.240 | 22 | 2 | 34.1 | 0.1 | 32.6 | 1.1 | 152.4 | 76.2 | 1904.2 | m315 | 1.11254 | 1.11254 | 0.00228026 | 0.00404924 | 0.00434196
3 x DUMMY | C152*76 | STEEL/S355JR | +51.088 | +51.240 | 22 | 2 | 34.7 | 0.1 | 32.6 | 1.1 | 152.4 | 76.2 | 1937.7 | m314 | 1.13214 | 1.13214 | 0.00228026 | 0.00412955 | 0.00441847
3 x DUMMY | C152*76 | STEEL/S355JR | +51.048 | +51.124 | 22 | 2 | 40.2 | 0.3 | 32.6 | 1.3 | 152.4 | 76.2 | 2243.9 | m309 | 1.31104 | 1.31104 | 0.00228026 | 0.00489949 | 0.00511666
3 x DUMMY | C152*76 | STEEL/S355JR | +51.204 | +51.280 | 22 | 2 | 40.2 | 0 | 32.6 | 1.3 | 152.4 | 76.2 | 2243.9 | m308 | 1.31104 | 1.31104 | 0.00228026 | 0.00489949 | 0.00511666
3 x DUMMY | L60*60*6 | STEEL/S355JR | +51.000 | +51.280 | 22 | 2 | 1.4 | 0 | 43 | 0.1 | 60 | 60 | 280.5 | m657 | 0.0653937 | 0.0653937 | 0.000690446 | 0.000191862 | 0.00019367
3 x DUMMY | L60*60*6 | STEEL/S355JR | +51.000 | +51.280 | 22 | 2 | 1.4 | 0 | 43 | 0.1 | 60 | 60 | 280.5 | m656 | 0.0653937 | 0.0653937 | 0.000690446 | 0.000191862 | 0.00019367
24 x DUMMY | FL10*100 | STEEL/S355JR | +50.469 | +50.569 | 22 | 2 | 0.5 | 0 | 32 | 0 | 100 | 10 | 100 | p103 | 0.0168599 | 0.01 | 0.0001 | 0.000067375 | 0.000067375
12 x DUMMY | PLT8*73.2 | STEEL/S355JR | +50.496 | +50.635 | 22 | 2 | 0.7 | 0 | 37.2 | 0 | 73.2 | 8 | 138.8 | p551 | 0.0216165 | 0.0101532 | 0.000064 | 0.0000740258 | 0.0000740258
6 x DUMMY | FL8*70 | STEEL/S355JR | +50.642 | +50.650 | 22 | 2 | 0.7 | 0 | 37.2 | 0 | 70 | 8 | 152.4 | p553 | 0.0248944 | 0.010668 | 0.000064 | 0.000085344 | 0.000085344
24 x DUMMY | IPE140 | STEEL/S355JR | +50.329 | +50.469 | 22 | 2 | 2.8 | 0 | 42.7 | 0.1 | 140 | 73 | 217.1 | m679 | 0.119531 | 0.119531 | 0.00164331 | 0.000347477 | 0.000356763
24 x DUMMY | PLT10*63.8 | STEEL/S355JR | +51.160 | +51.170 | 22 | 2 | 0.9 | 0 | 30.9 | 0 | 63.8 | 10 | 187.6 | p102 | 0.0268143 | 0.0119689 | 0.0001 | 0.000110689 | 0.000110689
24 x DUMMY | PLT8*63.8 | STEEL/S355JR | +50.830 | +51.017 | 22 | 2 | 0.7 | 0 | 37.2 | 0 | 63.8 | 8 | 187.6 | p552 | 0.025879 | 0.0119689 | 0.000064 | 0.000088551 | 0.000088551
3 x DUMMY | C152*76 | STEEL/S355JR | +51.088 | +51.240 | 22 | 2 | 58.4 | 0.2 | 32.6 | 1.9 | 152.4 | 76.2 | 3260 | m312 | 1.90471 | 1.90471 | 0.00228026 | 0.00714813 | 0.00743363
12 x DUMMY | UB203*133*25 | STEEL/S355JR | +51.025 | +51.260 | 22 | 2 | 5.9 | 0 | 36.5 | 0.2 | 203.2 | 133.4 | 235 | m12 | 0.215155 | 0.215155 | 0.00319745 | 0.000740335 | 0.000751401
18 x DUMMY | UB203*133*25 | STEEL/S355JR | +50.254 | +50.822 | 22 | 2 | 14.3 | 0 | 36.5 | 0.5 | 203.2 | 133.4 | 567.8 | m14 | 0.519851 | 0.519851 | 0.00319745 | 0.00178877 | 0.00181551
6 x DUMMY | UB203*133*25 | STEEL/S355JR | +50.254 | +50.822 | 22 | 2 | 14.3 | 0 | 36.5 | 0.5 | 203.2 | 133.4 | 567.8 | m15 | 0.519851 | 0.519851 | 0.00319745 | 0.00178877 | 0.00181551
6 x DUMMY | L50*50*8 | STEEL/S355JR | +50.301 | +50.857 | 22 | 2 | 3.5 | 0 | 33.3 | 0.1 | 50 | 50 | 588.8 | m720 | 0.114212 | 0.114212 | 0.000741401 | 0.00042442 | 0.000436501
6 x DUMMY | L50*50*8 | STEEL/S355JR | +50.301 | +50.857 | 22 | 2 | 3.5 | 0 | 33.3 | 0.1 | 50 | 50 | 588.8 | m721 | 0.114212 | 0.114212 | 0.000741401 | 0.00042442 | 0.000436501
12 x DUMMY | L50*50*8 | STEEL/S355JR | +50.358 | +50.930 | 22 | 2 | 3.7 | 0 | 33.3 | 0.1 | 50 | 50 | 627.7 | m722 | 0.121776 | 0.121776 | 0.000741401 | 0.000462016 | 0.000465406
6 x DUMMY | PC200*75 | STEEL/S355JR | +50.292 | +50.492 | 22 | 2 | 21.3 | 0.1 | 27.8 | 0.6 | 200 | 75 | 875 | m467 | 0.590812 | 0.590812 | 0.00309554 | 0.00265913 | 0.0027086
6 x DUMMY | PC200*75 | STEEL/S355JR | +50.857 | +51.057 | 22 | 2 | 17 | 0.1 | 27.8 | 0.5 | 200 | 75 | 700 | m469 | 0.47265 | 0.47265 | 0.00309554 | 0.0021273 | 0.00216688
6 x DUMMY | PC200*75 | STEEL/S355JR | +50.857 | +51.057 | 22 | 2 | 21.3 | 0.1 | 27.8 | 0.6 | 200 | 75 | 875 | m467 | 0.590812 | 0.590812 | 0.00309554 | 0.00265913 | 0.0027086
3 x DUMMY | PC200*75 | STEEL/S355JR | +50.252 | +51.057 | 22 | 2 | 19.6 | 0 | 27.8 | 0.6 | 200 | 75 | 805 | m468 | 0.543547 | 0.543547 | 0.00309554 | 0.0024464 | 0.00249191
6 x DUMMY | PC200*75 | STEEL/S355JR | +50.252 | +51.057 | 22 | 2 | 19.6 | 0 | 27.8 | 0.6 | 200 | 75 | 805 | m468 | 0.543548 | 0.543548 | 0.00309554 | 0.0024464 | 0.00249191
4 x DUMMY | PL6*228.6 | STEEL/S355JR | +51.137 | +51.367 | 22 | 2 | 1.1 | 0 | 48.9 | 0.1 | 228.6 | 6 | 228.6 | p658 | 0.0536779 | 0.0522368 | 0.000036 | 0.000139751 | 0.000241001
2 x DUMMY | PL6*228.6 | STEEL/S355JR | +51.137 | +51.367 | 25 | 2 | 1.1 | 0 | 48.9 | 0.1 | 228.6 | 6 | 228.6 | p658 | 0.0536779 | 0.0522368 | 0.000036 | 0.000139751 | 0.000241001
6 x DUMMY | FL20*200 | STEEL/S355JR | +51.864 | +51.884 | 22 | 2 | 22 | 0.1 | 14.4 | 0.3 | 200 | 20 | 700 | p670 | 0.316 | 0.316 | 0.004 | 0.0028 | 0.0028
6 x DUMMY | PL12*160 | STEEL/S355JR | +51.982 | +51.994 | 22 | 2 | 10.3 | 0.1 | 23.2 | 0.2 | 160 | 12 | 680 | p174 | 0.23776 | 0.23776 | 0.00192 | 0.0013056 | 0.0013056
6 x DUMMY | PL12*170 | STEEL/S355JR | +50.809 | +51.519 | 22 | 2 | 11.4 | 0 | 23.1 | 0.3 | 170 | 12 | 710.2 | p175 | 0.262593 | 0.262593 | 0.00204 | 0.00144881 | 0.00144881
3 x DUMMY | PLT16*480 | STEEL/S355JR | +51.057 | +51.073 | 22 | 2 | 42.2 | 0.3 | 16.8 | 0.6 | 480 | 16 | 700 | A754 | 0.70976 | 0.70976 | 0.00768 | 0.005376 | 0.005376
6 x DUMMY | PLT8*127 | STEEL/S355JR | +50.450 | +50.458 | 9 | 2 | 1.6 | 0 | 35.1 | 0.1 | 127 | 8 | 200 | A806 | 0.056032 | 0.056032 | 0.0016 | 0.0002032 | 0.0002032
16 x DUMMY | FL8*100 | STEEL/S355JR | +57.170 | +57.270 | 3 | 2 | 1.2 | 0 | 35.7 | 0 | 100 | 8 | 195.1 | A807 | 0.0437389 | 0.0437389 | 0.0008 | 0.00015607 | 0.00015607
4 x DUMMY | FL10*100 | STEEL/S355JR | +50.242 | +50.252 | 11 | 2 | 1.6 | 0 | 29.3 | 0 | 100 | 10 | 200 | DUMMY1146 | 0.046 | 0.046 | 0.001 | 0.0002 | 0.0002
2 x DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +57.725 | +57.759 | 11 | 2 | 0 | 0 |  | 0 | 34 | 2.5 | 157.1 | DUMMY1202 | 0.016724 | 0.016724 | 0.00023625 | 0.0000366869 | 0.0000366869
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +57.225 | +57.259 | 11 | 2 | 0 | 0 |  | 0 | 34 | 2.5 | 157.1 | DUMMY1202 | 0.0167253 | 0.0167253 | 0.00023625 | 0.0000366898 | 0.0000366898
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +57.225 | +57.259 | 11 | 2 | 0 | 0 |  | 0 | 34 | 2.5 | 157.1 | DUMMY1202 | 0.0167231 | 0.0167231 | 0.00023625 | 0.0000366848 | 0.0000366848
3 x DUMMY | PLT8*756.8 | STEEL/S355JR | +51.014 | +51.771 | 11 | 2 | 38.2 | 0 | 32.5 | 1.3 | 756.8 | 8 | 803.9 | DUMMY1292 | 1.24165 | 0.608341 | 0.000064 | 0.00486673 | 0.00486673
3 x DUMMY | FL20*250 | STEEL/S355JR | +50.234 | +50.254 | 11 | 2 | 9.8 | 0.1 | 14.8 | 0.1 | 250 | 20 | 250 | DUMMY1405 | 0.145 | 0.145 | 0.005 | 0.00125 | 0.00125
9 x DUMMY | FL20*250 | STEEL/S355JR | +50.242 | +50.262 | 11 | 2 | 9.8 | 0.1 | 14.8 | 0.1 | 250 | 20 | 250 | DUMMY1405 | 0.145 | 0.145 | 0.005 | 0.00125 | 0.00125
6 x DUMMY | FL10*150 | STEEL/S355JR | +53.558 | +53.667 | 11 | 2 | 1.2 | 0 | 29.5 | 0 | 109 | 10 | 109 | DUMMY1145 | 0.03788 | 0.03788 | 0.0015 | 0.0001635 | 0.0001635
15 x DUMMY | FL8*70 | MISCELLANEOUS/COMPONENT | +56.632 | +56.702 | 11 | 2 | 0 | 0 |  | 0 | 70 | 8 | 160 | DUMMY1291 | 0.02608 | 0.0112 | 0.000064 | 0.0000896 | 0.0000896
2 x DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +57.725 | +57.759 | 11 | 2 | 0 | 0 |  | 0 | 34 | 2.5 | 157.1 | DUMMY1202 | 0.0167246 | 0.0167246 | 0.00023625 | 0.0000366883 | 0.0000366883
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +57.225 | +57.259 | 11 | 2 | 0 | 0 |  | 0 | 34 | 2.5 | 157.1 | DUMMY1202 | 0.0167256 | 0.0167256 | 0.00023625 | 0.0000366904 | 0.0000366904
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +57.225 | +57.259 | 11 | 2 | 0 | 0 |  | 0 | 34 | 2.5 | 157.1 | DUMMY1202 | 0.0167237 | 0.0167237 | 0.00023625 | 0.0000366863 | 0.0000366863
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +54.680 | +54.714 | 11 | 2 | 0 | 0 |  | 0 | 34 | 2.5 | 157.1 | DUMMY1202 | 0.0167243 | 0.0167243 | 0.00023625 | 0.0000366876 | 0.0000366876
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +54.180 | +54.214 | 11 | 2 | 0 | 0 |  | 0 | 34 | 2.5 | 157.1 | DUMMY1202 | 0.0167243 | 0.0167243 | 0.00023625 | 0.0000366876 | 0.0000366876
8 x DUMMY | FL8*70 | MISCELLANEOUS/COMPONENT | +53.587 | +53.657 | 11 | 2 | 0 | 0 |  | 0 | 70 | 8 | 160 | DUMMY1291 | 0.02608 | 0.0112 | 0.000064 | 0.0000896 | 0.0000896
2 x DUMMY | FL10*100 | STEEL/S355JR | +50.242 | +50.252 | 11 | 2 | 1.6 | 0 | 29.3 | 0 | 100 | 10 | 200 | DUMMY1146 | 0.046 | 0.046 | 0.002 | 0.0002 | 0.0002
6 x DUMMY | FL20*200 | STEEL/S355JR | +50.242 | +50.262 | 11 | 2 | 7.8 | 0 | 15 | 0.1 | 200 | 20 | 250 | DUMMY1406 | 0.118 | 0.118 | 0.005 | 0.001 | 0.001
12 x DUMMY | FL20*150 | STEEL/S355JR | +56.743 | +56.893 | 11 | 2 | 3.9 | 0 | 15.9 | 0.1 | 150 | 20 | 170 | DUMMY1404 | 0.0638 | 0.0638 | 0.0034 | 0.00051 | 0.00051
DUMMY | PLT10*255.8 | STEEL/S355JR | +56.186 | +56.442 | 11 | 2 | 5.3 | 0 | 27.5 | 0.1 | 255.8 | 10 | 264.6 | DUMMY1144 | 0.145773 | 0.0676824 | 0.0001 | 0.000676824 | 0.000676824
DUMMY | PLT10*255.8 | STEEL/S355JR | +56.186 | +56.442 | 11 | 2 | 5.3 | 0 | 27.5 | 0.1 | 255.8 | 10 | 264.6 | DUMMY1144 | 0.145774 | 0.0676829 | 0.0001 | 0.000676829 | 0.000676829
DUMMY | FL10*90 | STEEL/S355JR | +52.787 | +53.137 | 11 | 2 | 3 | 0 | 28.9 | 0.1 | 90 | 10 | 415.1 | DUMMY1138 | 0.084819 | 0.0373586 | 0.0001 | 0.000373586 | 0.000373586
3 x DUMMY | PLT8*560 | STEEL/S355JR | +52.303 | +56.476 | 11 | 2 | 146.7 | 0 | 32.3 | 4.8 | 560 | 8 | 4173.9 | p411 | 4.75044 | 2.3374 | 0.000064 | 0.0186988 | 0.0187311
2 x DUMMY | PL3*544 | Undefined/Vitex W80HR | +50.350 | +51.087 | 11 | 2 | 0 | 0 |  | 0.9 | 544 | 3 | 737 | p338 | 0.809579 | 0.400946 | 0.000009 | 0.00120284 | 0.00120284
DUMMY | PL3*544 | Undefined/Vitex W80HR | +51.143 | +52.294 | 11 | 2 | 0 | 0 |  | 1.3 | 544 | 3 | 1151 | p334 | 1.23192 | 0.626173 | 0.000009 | 0.00183172 | 0.00187852
DUMMY | PL3*694 | Undefined/Vitex W80HR | +50.350 | +51.087 | 11 | 2 | 0 | 0 |  | 0.9 | 694 | 3 | 737 | p339 | 1.03154 | 0.511478 | 0.000009 | 0.00153444 | 0.00153444
DUMMY | PL3*694 | Undefined/Vitex W80HR | +51.143 | +52.294 | 11 | 2 | 0 | 0 |  | 1.6 | 694 | 3 | 1151 | p333 | 1.57806 | 0.798795 | 0.000009 | 0.00234958 | 0.00239638
3 x DUMMY | PL5*65 | STEEL/S355JR | +51.210 | +51.215 | 11 | 2 | 0.3 | 0 | 56.7 | 0 | 65 | 5 | 140 | p573 | 0.02025 | 0.02025 | 0.000325 | 0.0000455 | 0.0000455
12 x DUMMY | D12 | STEEL/S355JR | +52.945 | +53.014 | 11 | 2 | 0.2 | 0 | 47 | 0 | 12 | 12 | 291.4 | m929 | 0.0108771 | 0.0108771 | 0.000101823 | 0.0000295288 | 0.0000295288
6 x DUMMY | PL3*486.2 | STEEL/S355JR | +52.702 | +53.188 | 11 | 2 | 7.3 | 0 | 86.1 | 0.6 | 486.2 | 3 | 1280 | p331 | 0.631034 | 0.622371 | 0.000009 | 0.000933557 | 0.000933557
2 x DUMMY | PL3*964 | STEEL/S355JR | +51.062 | +52.702 | 11 | 2 | 37.2 | 0 | 85.3 | 3.2 | 964 | 3 | 1640 | p328 | 3.17755 | 1.58096 | 0.000009 | 0.00474289 | 0.00474289
6 x DUMMY | PLT10*95 | STEEL/S355JR | +52.157 | +52.297 | 11 | 2 | 0.9 | 0 | 29.9 | 0 | 95 | 10 | 140 | p40 | 0.0313 | 0.0133 | 0.0001 | 0.000133 | 0.000133
3 x DUMMY | L60*60*6 | STEEL/S355JR | +56.382 | +56.442 | 11 | 2 | 1.7 | 0 | 43 | 0.1 | 60 | 60 | 328.9 | m636 | 0.0767007 | 0.0767007 | 0.000690446 | 0.000225036 | 0.000227157
3 x DUMMY | L60*60*6 | STEEL/S355JR | +52.297 | +52.357 | 11 | 2 | 1.7 | 0 | 43 | 0.1 | 60 | 60 | 328.9 | m631 | 0.0767007 | 0.0767007 | 0.000690446 | 0.000225036 | 0.000227157
3 x DUMMY | L60*60*6 | STEEL/S355JR | +55.097 | +55.157 | 11 | 2 | 1.7 | 0 | 43 | 0.1 | 60 | 60 | 328.9 | m631 | 0.0767008 | 0.0767008 | 0.000690446 | 0.000225036 | 0.000227157
DUMMY | L60*60*6 | STEEL/S355JR | +52.297 | +52.357 | 11 | 2 | 2.3 | 0 | 43 | 0.1 | 60 | 60 | 423 | m642 | 0.0986122 | 0.0986122 | 0.000690446 | 0.000289323 | 0.00029205
DUMMY | L60*60*6 | STEEL/S355JR | +52.297 | +52.357 | 11 | 2 | 2.3 | 0 | 43 | 0.1 | 60 | 60 | 423 | m641 | 0.0986122 | 0.0986122 | 0.000690446 | 0.000289323 | 0.00029205
DUMMY | L60*60*6 | STEEL/S355JR | +53.697 | +53.757 | 11 | 2 | 2.2 | 0 | 43 | 0.1 | 60 | 60 | 399.5 | m640 | 0.0931438 | 0.0931438 | 0.000690446 | 0.000273279 | 0.000275855
DUMMY | L60*60*6 | STEEL/S355JR | +53.697 | +53.757 | 11 | 2 | 2.2 | 0 | 43 | 0.1 | 60 | 60 | 399.5 | m639 | 0.0931438 | 0.0931438 | 0.000690446 | 0.000273279 | 0.000275855
DUMMY | L60*60*6 | STEEL/S355JR | +56.382 | +56.442 | 11 | 2 | 1.7 | 0 | 43 | 0.1 | 60 | 60 | 337.8 | m638 | 0.0787529 | 0.0787529 | 0.000690446 | 0.000231057 | 0.000233235
DUMMY | L60*60*6 | STEEL/S355JR | +56.382 | +56.442 | 11 | 2 | 1.7 | 0 | 43 | 0.1 | 60 | 60 | 337.8 | m637 | 0.0787529 | 0.0787529 | 0.000690446 | 0.000231057 | 0.000233235
2 x DUMMY | L60*60*6 | STEEL/S355JR | +52.297 | +52.357 | 11 | 2 | 2.3 | 0 | 43 | 0.1 | 60 | 60 | 423 | m635 | 0.0986122 | 0.0986122 | 0.000690446 | 0.000289323 | 0.00029205
2 x DUMMY | L60*60*6 | STEEL/S355JR | +52.297 | +52.357 | 11 | 2 | 2.3 | 0 | 43 | 0.1 | 60 | 60 | 423 | m634 | 0.0986122 | 0.0986122 | 0.000690446 | 0.000289323 | 0.00029205
2 x DUMMY | L60*60*6 | STEEL/S355JR | +53.697 | +53.757 | 11 | 2 | 2.2 | 0 | 43 | 0.1 | 60 | 60 | 399.5 | m633 | 0.0931438 | 0.0931438 | 0.000690446 | 0.000273279 | 0.000275855
2 x DUMMY | L60*60*6 | STEEL/S355JR | +53.697 | +53.757 | 11 | 2 | 2.2 | 0 | 43 | 0.1 | 60 | 60 | 399.5 | m632 | 0.0931438 | 0.0931438 | 0.000690446 | 0.000273279 | 0.000275855
2 x DUMMY | L60*60*6 | STEEL/S355JR | +56.382 | +56.442 | 11 | 2 | 1.7 | 0 | 43 | 0.1 | 60 | 60 | 337.8 | m630 | 0.0787529 | 0.0787529 | 0.000690446 | 0.000231057 | 0.000233235
2 x DUMMY | L60*60*6 | STEEL/S355JR | +56.382 | +56.442 | 11 | 2 | 1.7 | 0 | 43 | 0.1 | 60 | 60 | 337.8 | m629 | 0.0787529 | 0.0787529 | 0.000690446 | 0.000231057 | 0.000233235
6 x DUMMY | FL5*20 | STEEL/S355JR | +56.010 | +56.030 | 11 | 2 | 0.1 | 0 | 66.9 | 0 | 20 | 5 | 80 | p554 | 0.0042 | 0.0042 | 0.0001 | 0.000008 | 0.000008
6 x DUMMY | FL5*20 | STEEL/S355JR | +55.510 | +55.530 | 11 | 2 | 0.1 | 0 | 66.9 | 0 | 20 | 5 | 80 | p554 | 0.0042 | 0.0042 | 0.0001 | 0.000008 | 0.000008
6 x DUMMY | FL5*20 | STEEL/S355JR | +54.717 | +54.737 | 11 | 2 | 0.1 | 0 | 66.9 | 0 | 20 | 5 | 80 | p554 | 0.0042 | 0.0042 | 0.0001 | 0.000008 | 0.000008
6 x DUMMY | FL5*20 | STEEL/S355JR | +54.217 | +54.237 | 11 | 2 | 0.1 | 0 | 66.9 | 0 | 20 | 5 | 80 | p554 | 0.0042 | 0.0042 | 0.0001 | 0.000008 | 0.000008
6 x DUMMY | FL5*20 | STEEL/S355JR | +53.717 | +53.737 | 11 | 2 | 0.1 | 0 | 66.9 | 0 | 20 | 5 | 80 | p554 | 0.0042 | 0.0042 | 0.0001 | 0.000008 | 0.000008
6 x DUMMY | FL5*20 | STEEL/S355JR | +53.217 | +53.237 | 11 | 2 | 0.1 | 0 | 66.9 | 0 | 20 | 5 | 80 | p554 | 0.0042 | 0.0042 | 0.0001 | 0.000008 | 0.000008
6 x DUMMY | FL5*20 | STEEL/S355JR | +52.717 | +52.737 | 11 | 2 | 0.1 | 0 | 66.9 | 0 | 20 | 5 | 80 | p554 | 0.0042 | 0.0042 | 0.0001 | 0.000008 | 0.000008
DUMMY | FL8*50 | STEEL/S355JR | +53.622 | +53.672 | 11 | 2 | 7.6 | 0 | 37.1 | 0.3 | 50 | 8 | 2447.6 | p408 | 0.28713 | 0.28713 | 0.0004 | 0.000985981 | 0.000985981
DUMMY | FL8*50 | STEEL/S355JR | +55.667 | +55.717 | 11 | 2 | 6.4 | 0 | 37.1 | 0.2 | 50 | 8 | 1989.6 | p406 | 0.232149 | 0.232149 | 0.0004 | 0.000796393 | 0.000796393
DUMMY | FL8*50 | STEEL/S355JR | +56.667 | +56.717 | 11 | 2 | 7.8 | 0 | 37.1 | 0.3 | 50 | 8 | 2464.6 | p407 | 0.289099 | 0.289099 | 0.0004 | 0.000992773 | 0.000992773
DUMMY | FL8*50 | STEEL/S355JR | +57.337 | +57.387 | 11 | 2 | 6.2 | 0 | 37.1 | 0.2 | 50 | 8 | 1932.2 | p405 | 0.224779 | 0.224779 | 0.0004 | 0.000771369 | 0.000771369
DUMMY | FL8*50 | STEEL/S355JR | +57.787 | +57.837 | 11 | 2 | 6.2 | 0 | 37.1 | 0.2 | 50 | 8 | 1932.2 | p405 | 0.224779 | 0.224779 | 0.0004 | 0.000771369 | 0.000771369
15 x DUMMY | UC152*152*23 | STEEL/S355JR | +56.616 | +56.726 | 11 | 2 | 2.4 | 0 | 38.7 | 0.1 | 91 | 152.4 | 110 | m262 | 0.0978067 | 0.0978067 | 0.00292994 | 0.000170494 | 0.000322293
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +57.225 | +57.259 | 11 | 2 | 0 | 0 |  | 0.2 | 34 | 34 | 1745.6 | m576 | 0.184583 | 0.184583 | 0.00023625 | 0.00041239 | 0.00041239
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +57.725 | +57.759 | 11 | 2 | 0 | 0 |  | 0.2 | 34 | 34 | 1745.6 | m576 | 0.184585 | 0.184585 | 0.00023625 | 0.000412392 | 0.000412392
2 x DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +54.180 | +54.214 | 11 | 2 | 0 | 0 |  | 0 | 34 | 2.5 | 157.1 | m567 | 0.0167243 | 0.0167243 | 0.00023625 | 0.0000366876 | 0.0000366876
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +54.180 | +54.214 | 11 | 2 | 0 | 0 |  | 0 | 34 | 34 | 94.6 | m571 | 0.0102395 | 0.0102395 | 0.00023625 | 0.000022338 | 0.000022338
2 x DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +54.680 | +54.714 | 11 | 2 | 0 | 0 |  | 0 | 34 | 2.5 | 157.1 | m567 | 0.0167243 | 0.0167243 | 0.00023625 | 0.0000366876 | 0.0000366876
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +54.180 | +54.214 | 11 | 2 | 0 | 0 |  | 0 | 34 | 34 | 144.6 | m573 | 0.0155226 | 0.0155226 | 0.00023625 | 0.0000341576 | 0.0000341576
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +54.180 | +54.214 | 11 | 2 | 0 | 0 |  | 0 | 34 | 2.5 | 161.7 | m566 | 0.0171997 | 0.0171997 | 0.00023625 | 0.0000377369 | 0.0000377369
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +54.680 | +54.714 | 11 | 2 | 0 | 0 |  | 0 | 34 | 2.5 | 161.7 | m566 | 0.0171997 | 0.0171997 | 0.00023625 | 0.0000377369 | 0.0000377369
DUMMY | ROD20 | STEEL/S355JR | +53.872 | +53.892 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +54.132 | +54.152 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +54.392 | +54.412 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +54.652 | +54.672 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +54.912 | +54.932 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +55.172 | +55.192 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +55.432 | +55.452 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +55.692 | +55.712 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +55.952 | +55.972 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +56.212 | +56.232 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +56.472 | +56.492 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
2 x DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +57.725 | +57.759 | 11 | 2 | 0 | 0 |  | 0.2 | 34 | 34 | 1579 | m575 | 0.166995 | 0.166995 | 0.00023625 | 0.000373039 | 0.000373039
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +57.225 | +57.259 | 11 | 2 | 0 | 0 |  | 0.2 | 34 | 34 | 1580 | m575 | 0.167102 | 0.167102 | 0.00023625 | 0.00037328 | 0.00037328
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +57.225 | +57.259 | 11 | 2 | 0 | 0 |  | 0.2 | 34 | 34 | 1579 | m575 | 0.166996 | 0.166996 | 0.00023625 | 0.000373043 | 0.000373043
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +57.725 | +57.759 | 11 | 2 | 0 | 0 |  | 0.3 | 34 | 34 | 3094.5 | m574 | 0.327028 | 0.327028 | 0.00023625 | 0.000731074 | 0.000731074
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +57.225 | +57.259 | 11 | 2 | 0 | 0 |  | 0.3 | 34 | 34 | 3094.5 | m574 | 0.327028 | 0.327028 | 0.00023625 | 0.000731075 | 0.000731075
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +54.680 | +54.714 | 11 | 2 | 0 | 0 |  | 0 | 34 | 34 | 144.6 | m573 | 0.0155226 | 0.0155226 | 0.00023625 | 0.0000341576 | 0.0000341576
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +54.680 | +54.714 | 11 | 2 | 0 | 0 |  | 0.1 | 34 | 34 | 954.5 | m572 | 0.101049 | 0.101049 | 0.00023625 | 0.000225501 | 0.000225501
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +54.180 | +54.214 | 11 | 2 | 0 | 0 |  | 0.1 | 34 | 34 | 954.5 | m572 | 0.101049 | 0.101049 | 0.00023625 | 0.000225501 | 0.000225501
2 x DUMMY | FL8*65 | STEEL/S355JR | +56.772 | +56.842 | 11 | 2 | 0.5 | 0 | 37.7 | 0 | 65 | 8 | 124 | p404 | 0.0203182 | 0.0203182 | 0.00052 | 0.0000686622 | 0.0000686622
2 x DUMMY | FL10*65 | STEEL/S355JR | +57.837 | +57.957 | 11 | 2 | 1.4 | 0 | 30.4 | 0 | 65 | 10 | 275 | p34 | 0.042219 | 0.042219 | 0.00065 | 0.000177166 | 0.000177166
2 x DUMMY | FL10*65 | STEEL/S355JR | +56.782 | +57.837 | 11 | 2 | 5.3 | 0 | 29.6 | 0.2 | 65 | 10 | 1055 | p39 | 0.15955 | 0.15955 | 0.00065 | 0.00068575 | 0.00068575
5 x DUMMY | FL8*50 | STEEL/S355JR | +55.667 | +57.835 | 11 | 2 | 6.9 | 0 | 37.1 | 0.3 | 50 | 8 | 2168.1 | p412 | 0.252304 | 0.252304 | 0.0004 | 0.000867256 | 0.000867256
2 x DUMMY | FL8*70 | STEEL/S355JR | +53.727 | +53.827 | 11 | 2 | 0.7 | 0 | 37.1 | 0 | 70 | 8 | 154.4 | p403 | 0.0264597 | 0.0264597 | 0.00056 | 0.0000909632 | 0.0000909632
2 x DUMMY | FL10*65 | STEEL/S355JR | +56.798 | +56.922 | 11 | 2 | 0.9 | 0 | 30.9 | 0 | 65 | 10 | 173.3 | p36 | 0.0267879 | 0.0267879 | 0.00065 | 0.000109983 | 0.000109983
2 x DUMMY | FL10*65 | STEEL/S355JR | +56.918 | +57.837 | 11 | 2 | 4.7 | 0 | 29.7 | 0.1 | 65 | 10 | 919.5 | p35 | 0.138967 | 0.138967 | 0.00065 | 0.000596326 | 0.000596326
DUMMY | ROD20 | STEEL/S355JR | +56.732 | +56.752 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
2 x DUMMY | FL10*65 | STEEL/S355JR | +53.737 | +56.802 | 11 | 2 | 15.6 | 0 | 29.5 | 0.5 | 65 | 10 | 3064.9 | p33 | 0.460784 | 0.460784 | 0.00065 | 0.00199087 | 0.00199087
DUMMY | CHS34*2.5 | MISCELLANEOUS/COMPONENT | +54.680 | +54.714 | 11 | 2 | 0 | 0 |  | 0 | 34 | 34 | 94.6 | m571 | 0.0102395 | 0.0102395 | 0.00023625 | 0.000022338 | 0.000022338
DUMMY | FL8*50 | STEEL/S355JR | +52.622 | +52.672 | 11 | 2 | 6.2 | 0 | 37.1 | 0.2 | 50 | 8 | 1988.3 | p402 | 0.23198 | 0.23198 | 0.0004 | 0.00079573 | 0.00079573
DUMMY | FL8*50 | STEEL/S355JR | +54.292 | +54.342 | 11 | 2 | 6.2 | 0 | 37.1 | 0.2 | 50 | 8 | 1934.7 | p401 | 0.225059 | 0.225059 | 0.0004 | 0.000772248 | 0.000772248
DUMMY | FL10*65 | STEEL/S355JR | +53.753 | +53.877 | 11 | 2 | 0.9 | 0 | 30.9 | 0 | 65 | 10 | 173.8 | p36 | 0.0268629 | 0.0268629 | 0.00065 | 0.000110309 | 0.000110309
42 x DUMMY | L50*50*5 | STEEL/S355JR | +52.277 | +52.327 | 11 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m935 | 0.00969956 | 0.00969956 | 0.000480255 | 0.00002375 | 0.0000240127
41 x DUMMY | L50*50*5 | STEEL/S355JR | +50.657 | +50.707 | 11 | 2 | 0.2 | 0 | 51.5 | 0 | 50 | 50 | 50 | m935 | 0.00969956 | 0.00969956 | 0.000480255 | 0.00002375 | 0.0000240127
18 x DUMMY | FL6*40 | STEEL/S355JR | +52.242 | +52.282 | 11 | 2 | 0.2 | 0 | 51.9 | 0 | 40 | 6 | 80 | p649 | 0.0078399 | 0.00319996 | 0.000036 | 0.0000191998 | 0.0000191998
36 x DUMMY | L40*40*6 | STEEL/S355JR | +52.242 | +52.282 | 11 | 2 | 0.1 | 0 | 44 | 0 | 40 | 40 | 40 | m559 | 0.00619398 | 0.00619398 | 0.000448408 | 0.00001776 | 0.0000179363
3 x DUMMY | L40*40*3 | STEEL/S355JR | +50.325 | +51.115 | 11 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 790 | m509 | 0.122331 | 0.122331 | 0.000235669 | 0.000175817 | 0.000186178
21 x DUMMY | D12 | STEEL/S355JR | +51.341 | +51.503 | 11 | 2 | 0.2 | 0 | 47 | 0 | 12 | 12 | 291.4 | m929 | 0.0108771 | 0.0108771 | 0.000101823 | 0.0000295288 | 0.0000295288
21 x DUMMY | D12 | STEEL/S355JR | +50.741 | +50.903 | 11 | 2 | 0.2 | 0 | 47 | 0 | 12 | 12 | 291.4 | m929 | 0.0108771 | 0.0108771 | 0.000101823 | 0.0000295288 | 0.0000295288
4 x DUMMY | L40*40*3 | STEEL/S355JR | +52.282 | +52.322 | 11 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 594 | m523 | 0.091977 | 0.091977 | 0.000235669 | 0.000137209 | 0.000139982
3 x DUMMY | FL5*40 | STEEL/S355JR | +51.302 | +51.342 | 11 | 2 | 0.7 | 0 | 57.8 | 0 | 40 | 5 | 520 | p571 | 0.0471979 | 0.0471979 | 0.0002 | 0.000103995 | 0.000103995
3 x DUMMY | PL3*544 | Undefined/Vitex W80HR | +50.350 | +52.294 | 11 | 2 | 0 | 0 |  | 2.1 | 544 | 3 | 1944 | p336 | 2.12991 | 1.05749 | 0.000009 | 0.00317247 | 0.00317247
4 x DUMMY | L40*40*3 | STEEL/S355JR | +50.322 | +50.362 | 11 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 594 | m523 | 0.091977 | 0.091977 | 0.000235669 | 0.000137209 | 0.000139982
18 x DUMMY | L40*40*3 | STEEL/S355JR | +50.325 | +52.319 | 11 | 2 | 3.7 | 0 | 83.7 | 0.3 | 40 | 40 | 1994 | m517 | 0.30877 | 0.30877 | 0.000235669 | 0.0004524 | 0.000469924
DUMMY | L40*40*3 | STEEL/S355JR | +51.075 | +51.115 | 11 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 600 | m477 | 0.0929061 | 0.0929061 | 0.000235669 | 0.000133462 | 0.000141396
DUMMY | L40*40*3 | STEEL/S355JR | +51.115 | +51.155 | 11 | 2 | 0.5 | 0 | 83.7 | 0 | 40 | 40 | 267 | m475 | 0.0413486 | 0.0413486 | 0.000235669 | 0.0000565496 | 0.0000629293
3 x DUMMY | L40*40*3 | STEEL/S355JR | +51.115 | +51.255 | 11 | 2 | 0.3 | 0 | 83.7 | 0 | 40 | 40 | 140 | m526 | 0.0216789 | 0.0216789 | 0.000235669 | 0.0000231 | 0.0000329936
3 x DUMMY | L40*40*3 | STEEL/S355JR | +51.115 | +51.255 | 11 | 2 | 0.3 | 0 | 83.7 | 0 | 40 | 40 | 140 | m527 | 0.0216789 | 0.0216789 | 0.000235669 | 0.0000231 | 0.0000329936
3 x DUMMY | L40*40*3 | STEEL/S355JR | +51.215 | +51.255 | 11 | 2 | 0.3 | 0 | 83.7 | 0 | 40 | 40 | 180 | m525 | 0.0278729 | 0.0278729 | 0.000235669 | 0.000028233 | 0.0000424204
DUMMY | L40*40*3 | STEEL/S355JR | +51.115 | +51.155 | 11 | 2 | 0.3 | 0 | 83.7 | 0 | 40 | 40 | 233 | m515 | 0.0360725 | 0.0360725 | 0.000235669 | 0.0000486789 | 0.0000548995
DUMMY | L40*40*3 | STEEL/S355JR | +51.075 | +51.115 | 11 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 600 | m476 | 0.0929136 | 0.0929136 | 0.000235669 | 0.000133473 | 0.000141407
DUMMY | L40*40*3 | STEEL/S355JR | +51.115 | +51.155 | 11 | 2 | 0.5 | 0 | 83.7 | 0 | 40 | 40 | 289 | m474 | 0.0447553 | 0.0447553 | 0.000235669 | 0.0000616316 | 0.000068114
DUMMY | L40*40*3 | STEEL/S355JR | +51.115 | +51.155 | 11 | 2 | 0.3 | 0 | 83.7 | 0 | 40 | 40 | 211 | m514 | 0.0326734 | 0.0326734 | 0.000235669 | 0.0000436081 | 0.0000497263
DUMMY | L40*40*3 | STEEL/S355JR | +51.075 | +51.115 | 11 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 750 | m471 | 0.116137 | 0.116137 | 0.000235669 | 0.000168117 | 0.000176752
DUMMY | L40*40*3 | STEEL/S355JR | +51.115 | +51.155 | 11 | 2 | 0.7 | 0 | 83.7 | 0 | 40 | 40 | 321 | m473 | 0.0497067 | 0.0497067 | 0.000235669 | 0.000069018 | 0.0000756497
DUMMY | L40*40*3 | STEEL/S355JR | +51.115 | +51.155 | 11 | 2 | 0.7 | 0 | 83.7 | 0 | 40 | 40 | 328.9 | m472 | 0.0509456 | 0.0509456 | 0.000235669 | 0.0000708661 | 0.0000775352
7 x DUMMY | L70*70*6 | STEEL/S355JR | +52.172 | +52.242 | 11 | 2 | 0.7 | 0 | 42.7 | 0 | 70 | 70 | 130 | m114 | 0.0353957 | 0.0353957 | 0.000812739 | 0.00010452 | 0.000105656
8 x DUMMY | L70*70*6 | STEEL/S355JR | +50.552 | +50.622 | 11 | 2 | 0.7 | 0 | 42.7 | 0 | 70 | 70 | 130 | m114 | 0.0353957 | 0.0353957 | 0.000812739 | 0.00010452 | 0.000105656
13 x DUMMY | FL5*40 | STEEL/S355JR | +51.302 | +51.342 | 11 | 2 | 1.1 | 0 | 57.7 | 0.1 | 40 | 5 | 670 | p570 | 0.0607001 | 0.0607001 | 0.0002 | 0.000134 | 0.000134
13 x DUMMY | PL3*694 | Undefined/Vitex W80HR | +50.350 | +52.294 | 11 | 2 | 0 | 0 |  | 2.7 | 694 | 3 | 1944 | p335 | 2.7141 | 1.34914 | 0.000009 | 0.00404741 | 0.00404741
14 x DUMMY | L40*40*3 | STEEL/S355JR | +50.322 | +50.362 | 11 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 744 | m522 | 0.115208 | 0.115208 | 0.000235669 | 0.000171864 | 0.000175338
14 x DUMMY | L40*40*3 | STEEL/S355JR | +52.282 | +52.322 | 11 | 2 | 1.4 | 0 | 83.7 | 0.1 | 40 | 40 | 744 | m522 | 0.115208 | 0.115208 | 0.000235669 | 0.000171864 | 0.000175338
DUMMY | FL5*40 | STEEL/S355JR | +51.302 | +51.342 | 11 | 2 | 0.7 | 0 | 57.8 | 0 | 40 | 5 | 530 | p572 | 0.0481 | 0.0481 | 0.0002 | 0.000106 | 0.000106
DUMMY | PL3*554 | Undefined/Vitex W80HR | +50.350 | +52.294 | 11 | 2 | 0 | 0 |  | 2.2 | 554 | 3 | 1944 | p337 | 2.16894 | 1.07698 | 0.000009 | 0.00323093 | 0.00323093
DUMMY | L40*40*3 | STEEL/S355JR | +50.322 | +50.362 | 11 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 604 | m524 | 0.0935292 | 0.0935292 | 0.000235669 | 0.000139524 | 0.000142344
DUMMY | L40*40*3 | STEEL/S355JR | +52.282 | +52.322 | 11 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 604 | m524 | 0.0935292 | 0.0935292 | 0.000235669 | 0.000139524 | 0.000142344
DUMMY | PL3*544 | Undefined/Vitex W80HR | +51.143 | +52.294 | 11 | 2 | 0 | 0 |  | 1.3 | 544 | 3 | 1151 | p332 | 1.23192 | 0.626173 | 0.000009 | 0.00183172 | 0.00187852
DUMMY | L40*40*3 | STEEL/S355JR | +50.322 | +50.362 | 11 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 594 | m523 | 0.0919845 | 0.0919845 | 0.000235669 | 0.00013722 | 0.000139993
DUMMY | L40*40*3 | STEEL/S355JR | +52.282 | +52.322 | 11 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 594 | m523 | 0.0919845 | 0.0919845 | 0.000235669 | 0.00013722 | 0.000139993
DUMMY | FL5*40 | STEEL/S355JR | +51.302 | +51.342 | 11 | 2 | 0.7 | 0 | 57.8 | 0 | 40 | 5 | 520 | p571 | 0.0472001 | 0.0472001 | 0.0002 | 0.000104 | 0.000104
DUMMY | PL3*544 | Undefined/Vitex W80HR | +50.350 | +52.294 | 11 | 2 | 0 | 0 |  | 2.1 | 544 | 3 | 1944 | p336 | 2.13 | 1.05754 | 0.000009 | 0.00317261 | 0.00317261
DUMMY | L40*40*3 | STEEL/S355JR | +50.322 | +50.362 | 11 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 594 | m523 | 0.0919808 | 0.0919808 | 0.000235669 | 0.000137214 | 0.000139987
DUMMY | L40*40*3 | STEEL/S355JR | +52.282 | +52.322 | 11 | 2 | 1.1 | 0 | 83.7 | 0.1 | 40 | 40 | 594 | m523 | 0.0919808 | 0.0919808 | 0.000235669 | 0.000137214 | 0.000139987
3 x DUMMY | L40*40*3 | STEEL/S355JR | +51.115 | +52.319 | 11 | 2 | 2.2 | 0 | 83.7 | 0.2 | 40 | 40 | 1204 | m508 | 0.186439 | 0.186439 | 0.000235669 | 0.00027145 | 0.000283745
DUMMY | PC300*100 | STEEL/S355JR | +56.442 | +56.742 | 11 | 2 | 16.1 | 0 | 21.5 | 0.3 | 300 | 100 | 355 | m419 | 0.344951 | 0.344951 | 0.0057707 | 0.00172132 | 0.00204859
2 x DUMMY | PC300*100 | STEEL/S355JR | +56.442 | +56.742 | 11 | 2 | 16.1 | 0 | 21.5 | 0.3 | 300 | 100 | 355 | m419 | 0.344953 | 0.344953 | 0.0057707 | 0.00172133 | 0.0020486
DUMMY | PC300*100 | STEEL/S355JR | +56.442 | +56.742 | 11 | 2 | 16.1 | 0 | 21.5 | 0.3 | 300 | 100 | 355 | m418 | 0.344951 | 0.344951 | 0.0057707 | 0.00172132 | 0.00204859
2 x DUMMY | C160*65 | STEEL/S355JR | +56.582 | +56.742 | 11 | 2 | 28.7 | 0.1 | 29.3 | 0.9 | 160 | 65 | 1520 | m450 | 0.837924 | 0.837924 | 0.00240764 | 0.00360701 | 0.00365962
DUMMY | UC152*152*23 | STEEL/S355JR | +56.616 | +56.726 | 11 | 2 | 2.4 | 0 | 38.7 | 0.1 | 91 | 152.4 | 110 | m260 | 0.0978067 | 0.0978067 | 0.00292994 | 0.000170494 | 0.000322293
8 x DUMMY | UC152*152*23 | STEEL/S355JR | +53.547 | +53.687 | 11 | 2 | 3.2 | 0 | 38.7 | 0.1 | 57.5 | 152.4 | 139 | m261 | 0.123592 | 0.123592 | 0.00292994 | 0.000187037 | 0.000407261
6 x DUMMY | PLT10*209.1 | STEEL/S355JR | +50.462 | +50.746 | 11 | 2 | 4.7 | 0 | 27.6 | 0.1 | 209.1 | 10 | 284.3 | p32 | 0.128772 | 0.0594519 | 0.0001 | 0.000594519 | 0.000594519
6 x DUMMY | PLT20*124 | STEEL/S355JR | +56.604 | +56.894 | 11 | 2 | 5.1 | 0 | 15.9 | 0.1 | 124 | 20 | 290 | p176 | 0.0799307 | 0.0359542 | 0.0004 | 0.000646401 | 0.000646401
3 x DUMMY | PLT10*124 | STEEL/S355JR | +55.578 | +55.926 | 11 | 2 | 3.6 | 0 | 28.2 | 0.1 | 124 | 10 | 422.2 | p28 | 0.101466 | 0.0523665 | 0.0001 | 0.000456525 | 0.000456525
3 x DUMMY | PLT10*104.7 | STEEL/S355JR | +54.174 | +54.526 | 11 | 2 | 3.2 | 0 | 28.6 | 0.1 | 104.7 | 10 | 415.7 | p30 | 0.0913912 | 0.043516 | 0.0001 | 0.000406659 | 0.000406659
3 x DUMMY | PLT10*131.4 | STEEL/S355JR | +52.776 | +53.123 | 11 | 2 | 3.7 | 0 | 28.2 | 0.1 | 131.4 | 10 | 424.7 | p29 | 0.105322 | 0.0558025 | 0.0001 | 0.000475572 | 0.000475572
3 x DUMMY | PLT10*124.3 | STEEL/S355JR | +55.578 | +55.926 | 11 | 2 | 3.6 | 0 | 28.2 | 0.1 | 124.3 | 10 | 422.2 | p28 | 0.10161 | 0.0524938 | 0.0001 | 0.000457236 | 0.000457236
3 x DUMMY | PLT10*118.4 | STEEL/S355JR | +54.187 | +54.537 | 11 | 2 | 3.5 | 0 | 28.5 | 0.1 | 118.3 | 10 | 420.2 | p27 | 0.0985107 | 0.0497559 | 0.0001 | 0.000441911 | 0.000441911
3 x DUMMY | PLT10*118.4 | STEEL/S355JR | +52.787 | +53.137 | 11 | 2 | 3.5 | 0 | 28.5 | 0.1 | 118.3 | 10 | 420.2 | p27 | 0.0985107 | 0.0497559 | 0.0001 | 0.000441911 | 0.000441911
3 x DUMMY | PLT10*256.1 | STEEL/S355JR | +56.186 | +56.442 | 11 | 2 | 5.3 | 0 | 27.5 | 0.1 | 256.1 | 10 | 264.5 | p31 | 0.145884 | 0.0677363 | 0.0001 | 0.000677363 | 0.000677363
6 x DUMMY | PLT10*255.8 | STEEL/S355JR | +56.186 | +56.442 | 11 | 2 | 5.3 | 0 | 27.5 | 0.1 | 255.8 | 10 | 264.6 | p31 | 0.145773 | 0.0676826 | 0.0001 | 0.000676826 | 0.000676826
3 x DUMMY | PLT10*255.8 | STEEL/S355JR | +56.186 | +56.442 | 11 | 2 | 5.3 | 0 | 27.5 | 0.1 | 255.8 | 10 | 264.6 | p31 | 0.145773 | 0.0676828 | 0.0001 | 0.000676828 | 0.000676828
3 x DUMMY | PLT10*247.5 | STEEL/S355JR | +51.964 | +52.506 | 11 | 2 | 10.3 | 0 | 27 | 0.3 | 247.5 | 10 | 541.3 | p20 | 0.277513 | 0.133972 | 0.0001 | 0.00131176 | 0.00131176
3 x DUMMY | PLT10*247.4 | STEEL/S355JR | +53.418 | +53.906 | 11 | 2 | 9.2 | 0 | 27 | 0.3 | 247.5 | 10 | 487.1 | p26 | 0.250268 | 0.120522 | 0.0001 | 0.00118078 | 0.00118078
3 x DUMMY | PLT10*247.4 | STEEL/S355JR | +53.418 | +53.906 | 11 | 2 | 9.2 | 0 | 27 | 0.3 | 247.5 | 10 | 487.1 | p26 | 0.250267 | 0.120522 | 0.0001 | 0.00118078 | 0.00118078
3 x DUMMY | PLT10*247.8 | STEEL/S355JR | +54.818 | +55.303 | 11 | 2 | 9.2 | 0 | 27 | 0.2 | 247.8 | 10 | 485 | p25 | 0.249548 | 0.120178 | 0.0001 | 0.00117735 | 0.00117735
3 x DUMMY | PLT10*247.8 | STEEL/S355JR | +54.818 | +55.303 | 11 | 2 | 9.2 | 0 | 27 | 0.2 | 247.8 | 10 | 485 | p24 | 0.249548 | 0.120178 | 0.0001 | 0.00117735 | 0.00117735
3 x DUMMY | PLT10*253.2 | STEEL/S355JR | +53.375 | +53.879 | 11 | 2 | 9.8 | 0 | 27 | 0.3 | 253.2 | 10 | 504.5 | p23 | 0.265122 | 0.127718 | 0.0001 | 0.00125274 | 0.00125274
3 x DUMMY | PLT10*259.2 | STEEL/S355JR | +53.376 | +53.878 | 11 | 2 | 10 | 0 | 27 | 0.3 | 259.2 | 10 | 502.6 | p22 | 0.27036 | 0.130289 | 0.0001 | 0.00127851 | 0.00127851
3 x DUMMY | PLT10*252.8 | STEEL/S355JR | +54.815 | +55.306 | 11 | 2 | 9.6 | 0 | 27 | 0.3 | 252.8 | 10 | 491 | p21 | 0.257629 | 0.124109 | 0.0001 | 0.00121666 | 0.00121666
3 x DUMMY | C152*76 | STEEL/S355JR | +53.697 | +53.773 | 11 | 2 | 3.1 | 0 | 32.6 | 0.1 | 152.4 | 76.2 | 172 | m289 | 0.100464 | 0.100464 | 0.00228026 | 0.000275335 | 0.000392089
3 x DUMMY | C152*76 | STEEL/S355JR | +53.697 | +53.773 | 11 | 2 | 3.1 | 0 | 32.6 | 0.1 | 152.4 | 76.2 | 172 | m289 | 0.100465 | 0.100465 | 0.00228026 | 0.000275115 | 0.00039209
6 x DUMMY | PLT10*63 | STEEL/S355JR | +53.773 | +53.931 | 11 | 2 | 0.7 | 0 | 30.9 | 0 | 63 | 10 | 158.2 | p18 | 0.02404 | 0.0099666 | 0.0001 | 0.000098666 | 0.000098666
12 x DUMMY | FL12*80 | STEEL/S355JR | +53.767 | +53.937 | 11 | 2 | 1.2 | 0 | 26 | 0 | 80 | 12 | 170 | p106 | 0.0332 | 0.0136 | 0.000144 | 0.0001632 | 0.0001632
6 x DUMMY | PLT8*170 | STEEL/S355JR | +50.887 | +51.057 | 11 | 2 | 2 | 0 | 34.7 | 0.1 | 170 | 8 | 188 | p410 | 0.069648 | 0.03196 | 0.000064 | 0.00025568 | 0.00025568
12 x DUMMY | FL12*80 | STEEL/S355JR | +50.887 | +51.057 | 11 | 2 | 1.2 | 0 | 26 | 0 | 80 | 12 | 170 | p106 | 0.0332 | 0.0136 | 0.000144 | 0.0001632 | 0.0001632
3 x DUMMY | PLT10*247.5 | STEEL/S355JR | +51.964 | +52.506 | 11 | 2 | 10.3 | 0 | 27 | 0.3 | 247.5 | 10 | 541.3 | p20 | 0.277512 | 0.133972 | 0.0001 | 0.00131176 | 0.00131176
3 x DUMMY | PLT10*245.9 | STEEL/S355JR | +52.227 | +52.498 | 11 | 2 | 5.1 | 0 | 27.5 | 0.1 | 245.9 | 10 | 270.9 | p17 | 0.140836 | 0.0666129 | 0.0001 | 0.000653942 | 0.000653942
3 x DUMMY | PLT10*243.2 | STEEL/S355JR | +52.227 | +52.502 | 11 | 2 | 5.1 | 0 | 27.5 | 0.1 | 243.2 | 10 | 275 | p16 | 0.141317 | 0.0668447 | 0.0001 | 0.000656226 | 0.000656226
3 x DUMMY | PLT10*252.5 | STEEL/S355JR | +54.807 | +55.308 | 11 | 2 | 9.6 | 0 | 27 | 0.3 | 252.5 | 10 | 500.7 | p19 | 0.262473 | 0.126438 | 0.0001 | 0.00123994 | 0.00123994
6 x DUMMY | PLT10*120 | STEEL/S355JR | +56.465 | +56.732 | 11 | 2 | 2.4 | 0 | 28.6 | 0.1 | 120 | 10 | 267 | p15 | 0.07182 | 0.03204 | 0.0001 | 0.0003204 | 0.0003204
3 x DUMMY | PC200*75 | STEEL/S355JR | +50.462 | +52.217 | 11 | 2 | 42.6 | 0 | 27.8 | 1.3 | 200 | 75 | 1755 | m459 | 1.185 | 1.185 | 0.00309554 | 0.00533344 | 0.00543267
4 x DUMMY | FL6*60 | STEEL/S355JR | +51.065 | +51.125 | 11 | 2 | 3.2 | 0 | 47 | 0.2 | 60 | 6 | 1174 | p185 | 0.152166 | 0.07044 | 0.000036 | 0.000412074 | 0.000412074
2 x DUMMY | FL8*65 | STEEL/S355JR | +53.697 | +53.767 | 11 | 2 | 0.5 | 0 | 37.7 | 0 | 65 | 8 | 124 | p400 | 0.0203182 | 0.0203182 | 0.00052 | 0.0000686622 | 0.0000686622
2 x DUMMY | FL10*65 | STEEL/S355JR | +54.792 | +54.912 | 11 | 2 | 1.4 | 0 | 30.4 | 0 | 65 | 10 | 275 | p34 | 0.042219 | 0.042219 | 0.00065 | 0.000177166 | 0.000177166
DUMMY | FL10*65 | STEEL/S355JR | +53.707 | +54.792 | 11 | 2 | 5.5 | 0 | 29.6 | 0.2 | 65 | 10 | 1085 | p38 | 0.16405 | 0.16405 | 0.00065 | 0.00070525 | 0.00070525
DUMMY | FL8*50 | STEEL/S355JR | +54.742 | +54.792 | 11 | 2 | 6.2 | 0 | 37.1 | 0.2 | 50 | 8 | 1934.7 | p401 | 0.225059 | 0.225059 | 0.0004 | 0.000772248 | 0.000772248
DUMMY | FL10*65 | STEEL/S355JR | +53.697 | +54.792 | 11 | 2 | 5.7 | 0 | 29.6 | 0.2 | 65 | 10 | 1095 | p37 | 0.16555 | 0.16555 | 0.00065 | 0.00071175 | 0.00071175
DUMMY | ROD20 | STEEL/S355JR | +50.507 | +50.527 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +50.772 | +50.792 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +51.037 | +51.057 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +51.302 | +51.322 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
5 x DUMMY | FL8*50 | STEEL/S355JR | +52.622 | +54.790 | 11 | 2 | 6.9 | 0 | 37.1 | 0.3 | 50 | 8 | 2168.1 | p412 | 0.252304 | 0.252304 | 0.0004 | 0.000867256 | 0.000867256
DUMMY | ROD20 | STEEL/S355JR | +51.567 | +51.587 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +51.832 | +51.852 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +52.097 | +52.117 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +52.362 | +52.382 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +52.627 | +52.647 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +52.892 | +52.912 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +53.157 | +53.177 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | ROD20 | STEEL/S355JR | +53.422 | +53.442 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
2 x DUMMY | FL8*70 | STEEL/S355JR | +50.242 | +50.342 | 11 | 2 | 0.7 | 0 | 37.1 | 0 | 70 | 8 | 154.4 | p399 | 0.0264597 | 0.0264597 | 0.00056 | 0.0000909632 | 0.0000909632
DUMMY | FL10*65 | STEEL/S355JR | +53.753 | +53.877 | 11 | 2 | 0.9 | 0 | 30.9 | 0 | 65 | 10 | 173.8 | p36 | 0.026863 | 0.026863 | 0.00065 | 0.000110309 | 0.000110309
2 x DUMMY | FL10*65 | STEEL/S355JR | +53.873 | +54.792 | 11 | 2 | 4.7 | 0 | 29.7 | 0.1 | 65 | 10 | 919.1 | p35 | 0.138914 | 0.138914 | 0.00065 | 0.000596097 | 0.000596097
DUMMY | ROD20 | STEEL/S355JR | +53.687 | +53.707 | 11 | 2 | 1.1 | 0 | 28.1 | 0 | 20 | 20 | 510 | m564 | 0.0317927 | 0.0317927 | 0.000282843 | 0.00014425 | 0.00014425
DUMMY | FL10*65 | STEEL/S355JR | +50.252 | +53.757 | 11 | 2 | 17.9 | 0 | 29.5 | 0.5 | 65 | 10 | 3505 | p14 | 0.526791 | 0.526791 | 0.00065 | 0.0022769 | 0.0022769
2 x DUMMY | PLT8*170 | STEEL/S355JR | +53.767 | +53.937 | 11 | 2 | 2 | 0 | 34.7 | 0.1 | 170 | 8 | 188 | p410 | 0.069648 | 0.03196 | 0.000064 | 0.00025568 | 0.00025568
3 x DUMMY | PC200*75 | STEEL/S355JR | +50.462 | +52.217 | 11 | 2 | 42.6 | 0 | 27.8 | 1.3 | 200 | 75 | 1755 | m460 | 1.185 | 1.185 | 0.00309554 | 0.00533344 | 0.00543267
3 x DUMMY | L80*80*6 | STEEL/S355JR | +50.572 | +51.243 | 11 | 2 | 5.7 | 0 | 42.4 | 0.2 | 80 | 80 | 759.9 | m138 | 0.236648 | 0.236648 | 0.000935032 | 0.000702157 | 0.000710541
3 x DUMMY | L80*80*6 | STEEL/S355JR | +51.543 | +52.123 | 11 | 2 | 4.8 | 0 | 42.4 | 0.2 | 80 | 80 | 662.9 | m139 | 0.206433 | 0.206433 | 0.000935032 | 0.000611338 | 0.000619818
3 x DUMMY | L80*80*6 | STEEL/S355JR | +51.543 | +52.123 | 11 | 2 | 4.8 | 0 | 42.4 | 0.2 | 80 | 80 | 662.9 | m133 | 0.206433 | 0.206433 | 0.000935032 | 0.000611338 | 0.000619818
3 x DUMMY | L80*80*6 | STEEL/S355JR | +50.572 | +51.243 | 11 | 2 | 5.7 | 0 | 42.4 | 0.2 | 80 | 80 | 759.9 | m138 | 0.236648 | 0.236648 | 0.000935032 | 0.000702157 | 0.00071054
3 x DUMMY | PLT6*1500 | STEEL/S355JR | +50.462 | +52.227 | 11 | 2 | 124.7 | 0 | 42.8 | 5.4 | 1500 | 6 | 1765 | p184 | 5.33418 | 2.6475 | 0.000036 | 0.015885 | 0.015885
2 x DUMMY | C160*65 | STEEL/S355JR | +53.537 | +53.697 | 11 | 2 | 6.2 | 0 | 29.3 | 0.2 | 160 | 65 | 326.5 | m446 | 0.179988 | 0.179988 | 0.00240764 | 0.000695306 | 0.000786096
3 x DUMMY | PLT8*560 | STEEL/S355JR | +52.303 | +56.478 | 11 | 2 | 146.9 | 0 | 32.3 | 4.8 | 560 | 8 | 4176.4 | p411 | 4.7532 | 2.33876 | 0.000064 | 0.0187097 | 0.0187311
3 x DUMMY | PC100*50 | STEEL/S355JR | +52.303 | +56.478 | 11 | 2 | 42.2 | 0 | 37.9 | 1.6 | 100 | 50 | 4176.2 | m158 | 1.5986 | 1.5986 | 0.00128662 | 0.00524387 | 0.00537317
3 x DUMMY | PC100*50 | STEEL/S355JR | +52.303 | +56.477 | 11 | 2 | 42.2 | 0 | 37.9 | 1.6 | 100 | 50 | 4173.9 | m158 | 1.59776 | 1.59776 | 0.00128662 | 0.00524254 | 0.00537037
12 x DUMMY | PLT10*200 | STEEL/S355JR | +56.442 | +56.742 | 11 | 2 | 4.7 | 0 | 27.6 | 0.1 | 200 | 10 | 300 | p13 | 0.13 | 0.06 | 0.0001 | 0.0006 | 0.0006
6 x DUMMY | PC100*50 | STEEL/S355JR | +52.652 | +52.702 | 11 | 2 | 4.8 | 0 | 37.9 | 0.2 | 100 | 50 | 490 | m157 | 0.187567 | 0.187567 | 0.00128662 | 0.00061544 | 0.000630445
6 x DUMMY | PC100*50 | STEEL/S355JR | +51.832 | +51.882 | 11 | 2 | 4.8 | 0 | 37.9 | 0.2 | 100 | 50 | 490 | m157 | 0.187567 | 0.187567 | 0.00128662 | 0.00061544 | 0.000630445
6 x DUMMY | PC100*50 | STEEL/S355JR | +52.652 | +52.702 | 11 | 2 | 4.8 | 0 | 37.9 | 0.2 | 100 | 50 | 490 | m157 | 0.187567 | 0.187567 | 0.00128662 | 0.000615439 | 0.000630445
6 x DUMMY | PC100*50 | STEEL/S355JR | +51.832 | +51.882 | 11 | 2 | 4.8 | 0 | 37.9 | 0.2 | 100 | 50 | 490 | m157 | 0.187567 | 0.187567 | 0.00128662 | 0.000615439 | 0.000630445
6 x DUMMY | PC100*50 | STEEL/S355JR | +52.652 | +52.702 | 11 | 2 | 11.8 | 0.1 | 37.9 | 0.5 | 100 | 50 | 1170 | m155 | 0.447864 | 0.447864 | 0.00128662 | 0.00146952 | 0.00150535
3 x DUMMY | PC100*50 | STEEL/S355JR | +51.832 | +51.882 | 11 | 2 | 11.8 | 0.1 | 37.9 | 0.5 | 100 | 50 | 1170 | m156 | 0.447864 | 0.447864 | 0.00128662 | 0.00146952 | 0.00150535
6 x DUMMY | PL3*1174 | STEEL/S355JR | +51.065 | +52.699 | 11 | 2 | 45.2 | 0 | 85.3 | 3.9 | 1174 | 3 | 1634 | p329 | 3.85348 | 1.91832 | 0.000009 | 0.00575495 | 0.00575495
2 x DUMMY | PLT3*964 | STEEL/S355JR | +51.062 | +51.065 | 11 | 2 | 26.8 | 1.1 | 85.3 | 2.3 | 964 | 3 | 1180 | p392 | 2.28791 | 1.13752 | 0.000009 | 0.00341256 | 0.00341256
12 x DUMMY | FL8*100 | STEEL/S355JR | +50.882 | +51.062 | 11 | 2 | 1.1 | 0 | 35.9 | 0 | 100 | 8 | 180 | p409 | 0.04048 | 0.018 | 0.000064 | 0.000144 | 0.000144
3 x DUMMY | PC200*75 | STEEL/S355JR | +50.882 | +53.942 | 11 | 2 | 74.4 | 0 | 27.8 | 2.1 | 200 | 75 | 3060 | m466 | 2.06616 | 2.06616 | 0.00309554 | 0.00929934 | 0.00947236
6 x DUMMY | PC180*70 | STEEL/S355JR | +53.762 | +53.942 | 11 | 2 | 30 | 0.1 | 29.3 | 0.9 | 180 | 70 | 1420 | m179 | 0.875634 | 0.875634 | 0.0026879 | 0.00373943 | 0.00381682
6 x DUMMY | PC180*70 | STEEL/S355JR | +50.882 | +51.062 | 11 | 2 | 30 | 0.1 | 29.3 | 0.9 | 180 | 70 | 1420 | m179 | 0.875634 | 0.875634 | 0.0026879 | 0.00373943 | 0.00381682
3 x DUMMY | L70*70*6 | STEEL/S355JR | +52.964 | +53.527 | 11 | 2 | 5 | 0 | 42.7 | 0.2 | 70 | 70 | 776.1 | m65 | 0.211319 | 0.211319 | 0.000812739 | 0.000624004 | 0.000630787
3 x DUMMY | L70*70*6 | STEEL/S355JR | +54.365 | +54.969 | 11 | 2 | 5.1 | 0 | 42.7 | 0.2 | 70 | 70 | 809.6 | m64 | 0.220437 | 0.220437 | 0.000812739 | 0.000650929 | 0.000658004
3 x DUMMY | L70*70*6 | STEEL/S355JR | +55.765 | +56.347 | 11 | 2 | 5 | 0 | 42.7 | 0.2 | 70 | 70 | 782.8 | m63 | 0.213125 | 0.213125 | 0.000812739 | 0.000629337 | 0.000636178
3 x DUMMY | L70*70*6 | STEEL/S355JR | +52.976 | +53.572 | 11 | 2 | 5.1 | 0 | 42.7 | 0.2 | 70 | 70 | 798.9 | m56 | 0.217523 | 0.217523 | 0.000812739 | 0.000642325 | 0.000649306
3 x DUMMY | L70*70*6 | STEEL/S355JR | +54.376 | +54.972 | 11 | 2 | 5.1 | 0 | 42.7 | 0.2 | 70 | 70 | 798.4 | m56 | 0.217388 | 0.217388 | 0.000812739 | 0.000641925 | 0.000648903
3 x DUMMY | L70*70*6 | STEEL/S355JR | +55.766 | +56.347 | 11 | 2 | 5 | 0 | 42.7 | 0.2 | 70 | 70 | 782.1 | m63 | 0.212932 | 0.212932 | 0.000812739 | 0.000628769 | 0.000635603
3 x DUMMY | PC200*75 | STEEL/S355JR | +50.462 | +52.227 | 11 | 2 | 42.9 | 0 | 27.8 | 1.3 | 200 | 75 | 1765 | m458 | 1.19175 | 1.19175 | 0.00309554 | 0.00536383 | 0.00546363
3 x DUMMY | PC200*75 | STEEL/S355JR | +50.462 | +52.227 | 11 | 2 | 42.9 | 0 | 27.8 | 1.3 | 200 | 75 | 1765 | m457 | 1.19175 | 1.19175 | 0.00309554 | 0.00536383 | 0.00546363
3 x DUMMY | L70*70*6 | STEEL/S355JR | +55.027 | +55.097 | 11 | 2 | 9.6 | 0.1 | 42.7 | 0.3 | 70 | 70 | 1514.7 | m62 | 0.412421 | 0.412421 | 0.000812739 | 0.00121784 | 0.00123108
3 x DUMMY | L70*70*6 | STEEL/S355JR | +55.027 | +55.097 | 11 | 2 | 9.4 | 0.1 | 42.7 | 0.3 | 70 | 70 | 1492 | m55 | 0.406233 | 0.406233 | 0.000812739 | 0.00119957 | 0.00121261
3 x DUMMY | L70*70*6 | STEEL/S355JR | +55.153 | +56.346 | 11 | 2 | 10.8 | 0 | 42.7 | 0.5 | 70 | 70 | 1685.4 | m61 | 0.458888 | 0.458888 | 0.000812739 | 0.00135505 | 0.00136978
3 x DUMMY | L70*70*6 | STEEL/S355JR | +55.155 | +55.738 | 11 | 2 | 5 | 0 | 42.7 | 0.2 | 70 | 70 | 785.5 | m60 | 0.213865 | 0.213865 | 0.000812739 | 0.000631522 | 0.000638386
3 x DUMMY | L70*70*6 | STEEL/S355JR | +53.724 | +54.962 | 11 | 2 | 10.8 | 0 | 42.7 | 0.5 | 70 | 70 | 1711.5 | m57 | 0.465996 | 0.465996 | 0.000812739 | 0.00137604 | 0.001391
3 x DUMMY | L70*70*6 | STEEL/S355JR | +53.724 | +54.337 | 11 | 2 | 5.1 | 0 | 42.7 | 0.2 | 70 | 70 | 798.8 | m56 | 0.217492 | 0.217492 | 0.000812739 | 0.000642233 | 0.000649214
3 x DUMMY | L70*70*6 | STEEL/S355JR | +52.345 | +53.527 | 11 | 2 | 10.8 | 0 | 42.7 | 0.5 | 70 | 70 | 1685.2 | m61 | 0.458832 | 0.458832 | 0.000812739 | 0.00135489 | 0.00136961
3 x DUMMY | L70*70*6 | STEEL/S355JR | +52.348 | +52.936 | 11 | 2 | 5 | 0 | 42.7 | 0.2 | 70 | 70 | 786.9 | m60 | 0.214264 | 0.214264 | 0.000812739 | 0.0006327 | 0.000639577
DUMMY | L70*70*6 | STEEL/S355JR | +52.227 | +52.297 | 11 | 2 | 9.6 | 0.1 | 42.7 | 0.3 | 70 | 70 | 1500 | m53 | 0.408411 | 0.408411 | 0.000812739 | 0.001206 | 0.00121911
3 x DUMMY | L70*70*6 | STEEL/S355JR | +55.150 | +56.347 | 11 | 2 | 10.8 | 0 | 42.7 | 0.5 | 70 | 70 | 1691.2 | m59 | 0.46047 | 0.46047 | 0.000812739 | 0.00135972 | 0.0013745
3 x DUMMY | L70*70*6 | STEEL/S355JR | +55.150 | +55.738 | 11 | 2 | 5.1 | 0 | 42.7 | 0.2 | 70 | 70 | 792.9 | m58 | 0.215892 | 0.215892 | 0.000812739 | 0.000637509 | 0.000644439
3 x DUMMY | L70*70*6 | STEEL/S355JR | +53.752 | +54.972 | 11 | 2 | 10.8 | 0 | 42.7 | 0.5 | 70 | 70 | 1712.4 | m57 | 0.466248 | 0.466248 | 0.000812739 | 0.00137679 | 0.00139175
3 x DUMMY | L70*70*6 | STEEL/S355JR | +53.752 | +54.348 | 11 | 2 | 5.1 | 0 | 42.7 | 0.2 | 70 | 70 | 798.9 | m56 | 0.217523 | 0.217523 | 0.000812739 | 0.000642325 | 0.000649307
3 x DUMMY | L70*70*6 | STEEL/S355JR | +52.352 | +53.572 | 11 | 2 | 10.8 | 0 | 42.7 | 0.5 | 70 | 70 | 1712.8 | m57 | 0.466359 | 0.466359 | 0.000812739 | 0.00137711 | 0.00139208
3 x DUMMY | L70*70*6 | STEEL/S355JR | +52.352 | +52.948 | 11 | 2 | 5.1 | 0 | 42.7 | 0.2 | 70 | 70 | 798.8 | m56 | 0.217499 | 0.217499 | 0.000812739 | 0.000642254 | 0.000649235
