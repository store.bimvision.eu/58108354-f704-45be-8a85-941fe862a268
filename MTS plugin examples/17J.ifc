Properties of the parts of a building model (IFC2X3), part 2 of 16

# IfcBeam: L70*70*6 (222)
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
HB | +57.090 | +57.160 | 3 | 5 | 8.3 | 0.1 | 0.3 | 1312.6 | A206 | 1312.59 | 0.357383 | 0.00104258 | 8.18424
HB | +57.090 | +57.160 | 3 | 5 | 8.5 | 0.1 | 0.3 | 1343.1 | A212 | 1343.07 | 0.365682 | 0.00107983 | 8.47663
HB | +57.090 | +57.160 | 3 | 5 | 4.7 | 0.1 | 0.2 | 716.3 | A208 | 716.28 | 0.195025 | 0.000575889 | 4.52073
DUMMY | +52.172 | +52.242 | 11 | 2 | 0.7 | 0 | 0 | 130 | A267 | 130 | 0.0353957 | 0.00010452 | 0.820482
6 x DUMMY | +55.027 | +55.097 | 11 | 2 | 9.6 | 0.1 | 0.3 | 1500 | A193 | 1500 | 0.408411 | 0.001206 | 9.4671
6 x DUMMY | +52.227 | +52.297 | 11 | 2 | 9.6 | 0.1 | 0.3 | 1500 | A193 | 1500 | 0.408411 | 0.001206 | 9.4671
3 x DUMMY | +50.462 | +50.532 | 11 | 2 | 7.8 | 0 | 0.3 | 1245 | A192 | 1245.03 | 0.33899 | 0.001001 | 7.85788
3 x DUMMY | +50.462 | +50.532 | 11 | 2 | 7.8 | 0 | 0.3 | 1245 | A192 | 1245.03 | 0.338989 | 0.001001 | 7.85788
4 x VB | +52.715 | +52.785 | 1 | 4 | 13 | 0.1 | 0.6 | 2031 | A190 | 2030.98 | 0.552984 | 0.00163291 | 12.8183
4 x VB | +53.191 | +53.261 | 1 | 4 | 13 | 0.1 | 0.6 | 2040.8 | A191 | 2040.83 | 0.555666 | 0.00164083 | 12.8805

# IfcBeam: L70*70*8 (39)
In: Undefined
Description: L70*70*8; Material: STEEL/S355JR
Tekla Common - Class: 3
Tekla Quantity - Volume: 0 m3; Area per tons: 32.6 m2; Height: 70 mm; Width: 70 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x Angle | +57.525 | +57.595 | 3 | 14 | 0.1 | 0.5 | 1678 | m363 | 1678 | 0.456876 | 0.00177197 | 13.9099
3 x Angle | +57.500 | +57.570 | 3 | 14 | 0.1 | 0.5 | 1678 | m363 | 1678 | 0.456876 | 0.00177197 | 13.9099
3 x Angle | +57.600 | +57.670 | 3 | 14 | 0.1 | 0.5 | 1678 | m363 | 1678 | 0.456876 | 0.00177197 | 13.9099
3 x Post | +57.280 | +58.407 | 3 | 9.4 | 0 | 0.3 | 1127 | m365 | 1127.01 | 0.306855 | 0.00119012 | 9.34243
3 x Post | +57.280 | +58.407 | 3 | 9.4 | 0 | 0.3 | 1127 | m364 | 1127.01 | 0.306855 | 0.00119012 | 9.34243
3 x Post | +57.280 | +58.382 | 3 | 9.2 | 0 | 0.3 | 1102.2 | m369 | 1102.16 | 0.30009 | 0.00116388 | 9.13646
3 x Post | +57.280 | +58.382 | 3 | 9.2 | 0 | 0.3 | 1102.2 | m368 | 1102.16 | 0.30009 | 0.00116388 | 9.13646
3 x Post | +57.280 | +58.335 | 3 | 8.8 | 0 | 0.3 | 1055.3 | m367 | 1055.34 | 0.287341 | 0.00111443 | 8.74829
3 x Post | +57.280 | +58.335 | 3 | 8.8 | 0 | 0.3 | 1055.3 | m366 | 1055.34 | 0.287341 | 0.00111443 | 8.74829
3 x Angle | +57.280 | +58.407 | 3 | 9.4 | 0 | 0.3 | 1127 | m319 | 1127.01 | 0.306855 | 0.00119012 | 9.34243
3 x Angle | +57.280 | +58.407 | 3 | 9.4 | 0 | 0.3 | 1127 | m318 | 1127.01 | 0.306855 | 0.00119012 | 9.34243
6 x Angle | +58.070 | +58.140 | 4 | 0.7 | 0 | 0 | 100 | A420 | 100 | 0.0272274 | 0.0001056 | 0.82896

# IfcBeam: L75*50*6 (6)
In: Undefined
Description: L75*50*6; Material: STEEL/S355JR
Tekla Common - Phase: 5; Class: 3
Tekla Quantity - Volume: 0 m3; Area per tons: 43.2 m2; Net surface area: 0.2 m2; Height: 75 mm; Width: 50 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Guard | +58.561 | +59.392 | 4.7 | 0 | 831.3 | m690 | 831.28 | 0.202825 | 0.000568794 | 4.46503
5 x Guard | +59.345 | +59.395 | 4.4 | 0.1 | 788 | m687 | 788.004 | 0.192266 | 0.000562635 | 4.41668

# IfcBeam: L80*80*6 (12)
In: Undefined
Description: L80*80*6; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 42.4 m2; Height: 80 mm; Width: 80 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
HB | +52.377 | +52.457 | 999 | 100 | 43.2 | 0.5 | 1.9 | 5879.9 | A296 | 5879.88 | 1.83109 | 0.00543301 | 42.6491
HB | +53.186 | +53.266 | 999 | 100 | 31.4 | 0.3 | 1.4 | 4278.1 | A297 | 4278.1 | 1.33227 | 0.00395297 | 31.0308
HB | +52.710 | +52.790 | 999 | 100 | 31.3 | 0.3 | 1.4 | 4269.6 | A298 | 4269.63 | 1.32963 | 0.00394514 | 30.9694
HB | +52.214 | +52.294 | 999 | 100 | 31.3 | 0.3 | 1.4 | 4257 | A299 | 4256.96 | 1.32568 | 0.00393343 | 30.8774
HB | +51.718 | +51.798 | 999 | 100 | 31.1 | 0.3 | 1.4 | 4236.9 | A300 | 4236.86 | 1.31942 | 0.00391485 | 30.7316
HB | +51.221 | +51.301 | 999 | 100 | 30.8 | 0.3 | 1.3 | 4199 | A301 | 4198.99 | 1.30763 | 0.00387987 | 30.4569
DUMMY | +52.242 | +52.322 | 11 | 2 | 52.7 | 0 | 2.3 | 7180 | m132 | 7180 | 2.23597 | 0.00663432 | 52.0794
2 x DUMMY | +52.242 | +52.322 | 11 | 2 | 26.4 | 0 | 1.3 | 3615 | m131 | 3615 | 1.12577 | 0.00334026 | 26.221
DUMMY | +50.622 | +50.702 | 11 | 2 | 52.7 | 0 | 2.3 | 7180 | A290 | 7180 | 2.23597 | 0.00663432 | 52.0794
2 x DUMMY | +50.622 | +50.702 | 11 | 2 | 26.4 | 0 | 1.3 | 3615 | A288 | 3615 | 1.12577 | 0.00334026 | 26.221

# IfcBeam: L80*80*8 (27)
In: Undefined
Description: L80*80*8; Material: STEEL/S355JR
Tekla Common - Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 32.3 m2; Height: 80 mm; Width: 80 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x Stringer | +58.247 | +58.417 | 3 | 73.3 | 2.4 | 7612 | m883 | 7611.98 | 2.37049 | 0.00925632 | 72.6621
3 x Stringer | +58.247 | +58.417 | 3 | 73.3 | 2.4 | 7612 | m882 | 7611.98 | 2.37049 | 0.00925632 | 72.6621
3 x Gantry | +56.736 | +57.762 | 2 | 115.7 | 3.8 | 12017.9 | m884 | 12017.9 | 3.74258 | 0.0146142 | 114.721
Gantry | +52.180 | +52.843 | 2 | 68.2 | 2.3 | 7082 | m879 | 7082 | 2.20545 | 0.00861171 | 67.6019
3 x Gantry | +57.687 | +58.317 | 2 | 115.8 | 3.9 | 12027.6 | m874 | 12027.6 | 3.7456 | 0.0146264 | 114.817
3 x Gantry | +55.744 | +56.812 | 2 | 115.7 | 3.8 | 11999 | m873 | 11999 | 3.73668 | 0.0145908 | 114.538
3 x Gantry | +54.752 | +55.820 | 2 | 115.7 | 3.8 | 11999 | m872 | 11999 | 3.73668 | 0.0145908 | 114.538
3 x Gantry | +53.759 | +54.828 | 2 | 115.7 | 3.8 | 11999 | m871 | 11999 | 3.73667 | 0.0145908 | 114.538
3 x Gantry | +52.767 | +53.835 | 2 | 115.7 | 3.8 | 11999 | m870 | 11999 | 3.73667 | 0.0145908 | 114.537
2 x Gantry | +52.180 | +52.843 | 2 | 68.2 | 2.3 | 7082 | m869 | 7082 | 2.20545 | 0.00861171 | 67.6019

# IfcBeam: L90*65*6 (56)
In: Undefined
Description: L90*65*6; Material: STEEL/S355JR
Tekla Common - Phase: 22; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 43 m2; Height: 90 mm; Width: 65 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x DUMMY | +50.505 | +50.595 | 2 | 0.1 | 289.7 | m898 | 289.65 | 0.0878024 | 0.000258947 | 2.03273
5 x DUMMY | +52.132 | +52.222 | 2 | 0.1 | 289.7 | m898 | 289.65 | 0.0878024 | 0.000258947 | 2.03273
6 x DUMMY | +50.505 | +50.595 | 2.1 | 0.1 | 297.7 | m897 | 297.65 | 0.0902274 | 0.000266099 | 2.08888
6 x DUMMY | +52.132 | +52.222 | 2.1 | 0.1 | 297.7 | m897 | 297.65 | 0.0902274 | 0.000266099 | 2.08888
10 x DUMMY | +50.505 | +50.595 | 21 | 0.9 | 2975.3 | m896 | 2975.3 | 0.901911 | 0.00265992 | 20.8804
10 x DUMMY | +52.132 | +52.222 | 21 | 0.9 | 2975.3 | m896 | 2975.3 | 0.901911 | 0.00265992 | 20.8804
DUMMY | +52.132 | +52.222 | 2 | 0.1 | 289.7 | A697 | 289.65 | 0.0878024 | 0.000258947 | 2.03273
6 x DUMMY | +50.402 | +50.492 | 22.1 | 0.9 | 3130 | A698 | 3130 | 0.948805 | 0.00279822 | 21.966
2 x DUMMY | +52.032 | +52.122 | 22.1 | 0.9 | 3130 | m900 | 3130 | 0.948805 | 0.00279822 | 21.966
3 x DUMMY | +52.032 | +52.122 | 22.1 | 0.9 | 3130 | m899 | 3130 | 0.948805 | 0.00279822 | 21.966
DUMMY | +52.032 | +52.122 | 22.1 | 0.9 | 3130 | A701 | 3130 | 0.948805 | 0.00279822 | 21.966

# IfcBeam: L90*90*10 (24)
In: Undefined
Description: L90*90*10; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +57.105; Top elevation: +57.245; Phase: 3; Class: 99
Tekla Quantity - Weight: 2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.2 m2; Net surface area: 0.1 m2; Height: 90 mm; Width: 90 mm; Length: 140 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A679
BaseQuantities - Length: 140 mm; OuterSurfaceArea: 0.049078 m2; NetVolume: 0.000238 m3; NetWeight: 1.8683 kg

# IfcBeam: L90*90*8 (60)
In: Undefined
Description: L90*90*8; Material: STEEL/S355JR
Tekla Common - Phase: 3; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 32.2 m2; Height: 90 mm; Width: 90 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
41 x Cleat | +57.135 | +57.250 | 1.2 | 0 | 115 | A680 | 0.0403141 | 0.00015824 | 1.24218
7 x Cleat | +57.135 | +57.250 | 1.2 | 0 | 115 | A681 | 0.0403141 | 0.00015824 | 1.24218
12 x Cleat | +57.095 | +57.235 | 1.4 | 0.1 | 140 | A682 | 0.049078 | 0.00019264 | 1.51222

# IfcBeam: PC100*50 (67)
In: Undefined
Description: PC100*50; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 37.9 m2; Height: 100 mm; Width: 50 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x Beam | +51.109 | +51.159 | 9 | 3 | 15.4 | 0.2 | 0.6 | 1514 | m166 | 0.579543 | 0.00190158 | 14.9274
3 x Stringer | +58.217 | +58.317 | 4 | 3 | 97.6 | 0.5 | 3.8 | 9660 | m162 | 3.69775 | 0.012133 | 95.2437
3 x Beam | +57.970 | +58.070 | 4 | 3 | 82.4 | 0.3 | 3.2 | 8160 | m161 | 3.12356 | 0.010249 | 80.4543
3 x Beam | +58.217 | +58.317 | 4 | 3 | 97.6 | 0.5 | 3.8 | 9660 | m159 | 3.69775 | 0.012133 | 95.2437
3 x Beam | +57.970 | +58.070 | 4 | 3 | 82.4 | 0.3 | 3.2 | 8160 | m160 | 3.12356 | 0.010249 | 80.4543
3 x DUMMY | +51.832 | +51.882 | 11 | 2 | 11.8 | 0.1 | 0.5 | 1170 | m156 | 0.447864 | 0.00146952 | 11.5357
Beam | +57.161 | +57.262 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A308 | 3.94579 | 0.0129468 | 101.633
Beam | +57.112 | +57.214 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m153 | 3.94579 | 0.0129468 | 101.633
Beam | +57.041 | +57.143 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +56.957 | +57.059 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +56.858 | +56.960 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +56.746 | +56.849 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +56.628 | +56.731 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A303 | 3.94579 | 0.0129468 | 101.633
Beam | +56.483 | +56.586 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +56.612 | +56.715 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A303 | 3.94579 | 0.0129468 | 101.633
Beam | +56.330 | +56.433 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +56.168 | +56.271 | 7008 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +55.838 | +55.941 | 7008 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +56.003 | +56.106 | 7008 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +55.679 | +55.783 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A303 | 3.94579 | 0.0129468 | 101.633
Beam | +51.102 | +51.206 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A305 | 3.94579 | 0.0129468 | 101.633
Beam | +51.710 | +51.814 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A303 | 3.94579 | 0.0129468 | 101.633
Beam | +52.682 | +52.785 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A303 | 3.94579 | 0.0129468 | 101.633
Beam | +52.528 | +52.632 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +52.363 | +52.467 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +52.198 | +52.302 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +52.033 | +52.137 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +51.869 | +51.972 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +54.687 | +54.791 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A303 | 3.94579 | 0.0129468 | 101.633
Beam | +55.658 | +55.762 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A303 | 3.94579 | 0.0129468 | 101.633
Beam | +55.505 | +55.608 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +55.340 | +55.444 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +55.175 | +55.279 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +55.010 | +55.114 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +54.845 | +54.949 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +53.695 | +53.799 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A303 | 3.94579 | 0.0129468 | 101.633
Beam | +54.666 | +54.770 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A304 | 3.94579 | 0.0129468 | 101.633
Beam | +54.512 | +54.616 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +54.348 | +54.451 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +54.183 | +54.287 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +54.018 | +54.122 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +53.853 | +53.957 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +52.703 | +52.806 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A303 | 3.94579 | 0.0129468 | 101.633
Beam | +53.674 | +53.778 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A303 | 3.94579 | 0.0129468 | 101.633
Beam | +53.520 | +53.624 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +53.355 | +53.459 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m152 | 3.94579 | 0.0129468 | 101.633
Beam | +53.191 | +53.294 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +53.026 | +53.130 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +52.861 | +52.965 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +50.917 | +51.017 | 2 | 3 | 106.1 | 0.5 | 4.2 | 10502 | A302 | 4.02005 | 0.0131905 | 103.546
Beam | +51.689 | +51.793 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A304 | 3.94579 | 0.0129468 | 101.633
Beam | +51.573 | +51.677 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +51.409 | +51.513 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +51.244 | +51.348 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | m151 | 3.94579 | 0.0129468 | 101.633
Beam | +51.123 | +51.227 | 2 | 3 | 104.1 | 0 | 3.9 | 10308 | A303 | 3.94579 | 0.0129468 | 101.633

# IfcBeam: PC180*70 (7)
In: Undefined
Description: PC180*70; Material: STEEL/S355JR
Tekla Common - Class: 3
Tekla Quantity - Volume: 0 m3; Area per tons: 29.3 m2; Height: 180 mm; Width: 70 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x Stringer | +51.111 | +52.249 | 6 | 245.6 | 0 | 7.3 | 11639.9 | m192 | 7.17767 | 0.0306523 | 240.621
2 x Stringer | +51.111 | +52.249 | 6 | 245.6 | 0 | 7.3 | 11639.9 | m191 | 7.17767 | 0.0306523 | 240.621
Stringer | +51.111 | +52.249 | 6 | 245.6 | 0 | 7.3 | 11639.9 | m190 | 7.17767 | 0.0306523 | 240.621
Beam | +56.625 | +56.805 | 1 | 254.4 | 0.8 | 7.6 | 12057 | m180 | 7.43487 | 0.0317509 | 249.245

# IfcBeam: PC200*75 (3)
In: Undefined
Description: PC200*75; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +50.387; Top elevation: +50.462; Phase: 11; Class: 2
Tekla Quantity - Weight: 36.4 kg; Volume: 0 m3; Gross footprint area: 0.3 m2; Area per tons: 27.8 m2; Net surface area: 0.9 m2; Height: 200 mm; Width: 75 mm; Length: 1500 mm
Pset_BeamCommon - LoadBearing: yes; Reference: m465
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 1.01282 m2; NetVolume: 0.0045585 m3; NetWeight: 35.7842 kg

# IfcBeam: PC230*90 (47)
In: Undefined
Description: PC230*90; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 3
Tekla Quantity - Volume: 0 m3; Area per tons: 24.8 m2; Height: 230 mm; Width: 90 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x Channel | +56.095 | +56.325 | 7.3 | 0 | 0.2 | 230 | A182 | 0.182781 | 0.00092805 | 7.28519
Beam | +56.095 | +56.325 | 6.9 | 0 | 0.2 | 210 | m27 | 0.166887 | 0.00084735 | 6.6517
Beam | +56.095 | +56.325 | 282.7 | 0.8 | 7.1 | 8780 | m26 | 6.97746 | 0.0354273 | 278.104
Beam | +56.095 | +56.325 | 282.7 | 0.8 | 7.1 | 8780 | m25 | 6.97746 | 0.0354273 | 278.104
4 x Channel | +55.144 | +55.374 | 7.3 | 0 | 0.2 | 230 | A182 | 0.182781 | 0.00092805 | 7.28519
Beam | +55.144 | +55.374 | 6.9 | 0 | 0.2 | 210 | m27 | 0.166887 | 0.00084735 | 6.6517
Beam | +55.144 | +55.374 | 282.7 | 0.8 | 7.1 | 8780 | m26 | 6.97746 | 0.0354273 | 278.104
Beam | +55.144 | +55.374 | 282.7 | 0.8 | 7.1 | 8780 | m25 | 6.97746 | 0.0354273 | 278.104
Beam | +54.151 | +54.381 | 6.9 | 0 | 0.2 | 210 | m27 | 0.166887 | 0.00084735 | 6.6517
4 x Channel | +54.151 | +54.381 | 7.3 | 0 | 0.2 | 230 | A182 | 0.182781 | 0.00092805 | 7.28519
Beam | +54.151 | +54.381 | 282.7 | 0.8 | 7.1 | 8780 | m26 | 6.97746 | 0.0354273 | 278.104
Beam | +54.151 | +54.381 | 282.7 | 0.8 | 7.1 | 8780 | m25 | 6.97746 | 0.0354273 | 278.104
Beam | +53.159 | +53.389 | 6.9 | 0 | 0.2 | 210 | m27 | 0.166887 | 0.00084735 | 6.6517
4 x Channel | +53.159 | +53.389 | 7.3 | 0 | 0.2 | 230 | A182 | 0.182781 | 0.00092805 | 7.28519
Beam | +53.159 | +53.389 | 282.7 | 0.8 | 7.1 | 8780 | m26 | 6.97746 | 0.0354273 | 278.104
Beam | +53.159 | +53.389 | 282.7 | 0.8 | 7.1 | 8780 | m25 | 6.97746 | 0.0354273 | 278.104
Beam | +52.166 | +52.396 | 6.9 | 0 | 0.2 | 210 | m27 | 0.166887 | 0.00084735 | 6.6517
4 x Channel | +52.166 | +52.396 | 7.3 | 0 | 0.2 | 230 | A182 | 0.182781 | 0.00092805 | 7.28519
Beam | +52.166 | +52.396 | 282.7 | 0.8 | 7.1 | 8780 | m26 | 6.97746 | 0.0354273 | 278.104
Beam | +52.166 | +52.396 | 282.7 | 0.8 | 7.1 | 8780 | m25 | 6.97746 | 0.0354273 | 278.104
4 x Channel | +51.173 | +51.403 | 7.3 | 0 | 0.2 | 230 | A182 | 0.182781 | 0.00092805 | 7.28519
2 x Beam | +51.173 | +51.403 | 282.7 | 0.8 | 7.1 | 8780 | A180 | 6.97746 | 0.0354273 | 278.104
4 x Channel | +50.585 | +50.815 | 7.3 | 0 | 0.2 | 230 | A182 | 0.182781 | 0.00092805 | 7.28519
2 x Beam | +50.585 | +50.815 | 282.7 | 0.8 | 7.1 | 8780 | A180 | 6.97746 | 0.0354273 | 278.104

# IfcBeam: PC260*90, Beam
In: Undefined
Description: PC260*90; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +55.005; Top elevation: +55.095; Phase: 1; Class: 3
Tekla Quantity - Weight: 298.1 kg; Volume: 0 m3; Gross footprint area: 2.2 m2; Area per tons: 24.5 m2; Net surface area: 7.3 m2; Height: 260 mm; Width: 90 mm; Length: 8565.6 mm
Pset_BeamCommon - LoadBearing: yes; Reference: m257
BaseQuantities - Length: 8565.6 mm; OuterSurfaceArea: 7.31245 m2; NetVolume: 0.0370729 m3; NetWeight: 291.022 kg

# IfcBeam: PC300*100 (12)
In: Undefined
Description: PC300*100; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +56.442; Top elevation: +56.742; Phase: 11; Class: 2
Tekla Quantity - Volume: 0 m3; Area per tons: 21.5 m2; Height: 300 mm; Width: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x DUMMY | 67.9 | 0.1 | 1.4 | 1500 | m417 | 1.45755 | 0.0085545 | 67.1528
DUMMY | 67.9 | 0.1 | 1.4 | 1500 | m416 | 1.45755 | 0.0085545 | 67.1528
5 x DUMMY | 77.9 | 0.2 | 1.7 | 1720 | m414 | 1.67132 | 0.00980916 | 77.0019
DUMMY | 67.9 | 0.1 | 1.4 | 1500 | m413 | 1.45755 | 0.0085545 | 67.1528
DUMMY | 67.9 | 0.1 | 1.4 | 1500 | m415 | 1.45755 | 0.0085545 | 67.1528
DUMMY | 77.9 | 0.2 | 1.7 | 1720 | A443 | 1.67132 | 0.00980916 | 77.0019

# IfcBeam: PD23*1.5 (120)
In: Undefined
Description: PD23*1.5; Material: Undefined/Vesconite
Tekla Common - Phase: 4; Class: 10
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Length: 22 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Bottom elevation | Top elevation | Height (mm) = Width (mm) | Reference | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
15 x Bush | +58.341 | +58.381 | 40 | A672 | 22.0012 | 0.00256257 | 0.00000293223
15 x Bush | +58.341 | +58.381 | 39.1 | A671 | 22.0011 | 0.0025679 | 0.00000293176
15 x Bush | +58.094 | +58.134 | 40 | A672 | 22.0012 | 0.00256257 | 0.00000293223
15 x Bush | +58.094 | +58.134 | 39.1 | A671 | 22.0011 | 0.0025679 | 0.00000293176
15 x Bush | +58.094 | +58.134 | 40 | A670 | 22.0011 | 0.0025626 | 0.00000293148
15 x Bush | +58.094 | +58.134 | 40 | A672 | 22.0011 | 0.00256256 | 0.00000293217
15 x Bush | +58.341 | +58.381 | 40 | A670 | 22.0011 | 0.0025626 | 0.00000293148
15 x Bush | +58.341 | +58.381 | 40 | A672 | 22.0011 | 0.00256256 | 0.00000293217

# IfcBeam: PD40*10 (60)
In: Undefined
Description: PD40*10; Material: Undefined/Vesconite
Tekla Common - Phase: 4; Class: 11
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 40 mm; Width: 40 mm; Length: 4 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A669
BaseQuantities - Length: 4 mm; OuterSurfaceArea: 0.00169693 m2; NetVolume: 0.0000036 m3; NetWeight: 0 kg
Name | Bottom elevation | Top elevation
30 x Washer | +58.094 | +58.134
30 x Washer | +58.341 | +58.381

# IfcBeam: PL10*140 (6)
In: Undefined
Description: PL10*140; Material: Undefined/80SHORE
Tekla Common - Bottom elevation: +52.275; Top elevation: +53.016; Phase: 6; Class: 14
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 2.2 m2; Height: 140 mm; Width: 10 mm; Length: 7302 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A779
BaseQuantities - Length: 7302 mm; OuterSurfaceArea: 2.1934 m2; NetVolume: 0.0102228 m3; NetWeight: 0 kg

# IfcBeam: PL10*145 (6)
In: Undefined
Description: PL10*145; Material: Undefined/80SHORE
Tekla Common - Bottom elevation: +52.788; Top elevation: +52.942; Phase: 6; Class: 14
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.5 m2; Height: 145 mm; Width: 10 mm; Length: 1746 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A778
BaseQuantities - Length: 1746 mm; OuterSurfaceArea: 0.54416 m2; NetVolume: 0.0025317 m3; NetWeight: 0 kg

# IfcBeam: PL10*189 (3)
In: Undefined
Description: PL10*189; Material: Undefined/80SHORE
Tekla Common - Bottom elevation: +52.778; Top elevation: +52.803; Phase: 6; Class: 14
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 189 mm; Width: 10 mm; Length: 979.9 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 980 mm; OuterSurfaceArea: 0.39382 m2; NetVolume: 0.0018522 m3; NetWeight: 0 kg
Name | Reference
Rubber | A775
2 x Rubber | A773

# IfcBeam: PL10*220 (3)
In: Undefined
Description: PL10*220; Material: Undefined/80SHORE
Tekla Common - Bottom elevation: +52.937; Top elevation: +52.965; Phase: 6; Class: 14
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.5 m2; Height: 220 mm; Width: 10 mm; Length: 979.9 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A774
BaseQuantities - Length: 980 mm; OuterSurfaceArea: 0.4552 m2; NetVolume: 0.002156 m3; NetWeight: 0 kg

# IfcBeam: PL16*272 (6)
In: Undefined
Description: PL16*272; Material: Undefined/VRN500
Tekla Common - Bottom elevation: +52.872; Top elevation: +53.301; Phase: 6; Class: 13
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 272 mm; Width: 16 mm; Length: 408 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A835
BaseQuantities - Length: 408 mm; OuterSurfaceArea: 0.243712 m2; NetVolume: 0.00177562 m3; NetWeight: 0 kg

# IfcBeam: PL16*350 (90)
In: Undefined
Description: PL16*350; Material: Undefined/VRN500
Tekla Common - Phase: 6; Class: 13
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 350 mm; Width: 16 mm; Length: 408 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A832
BaseQuantities - Length: 408 mm; OuterSurfaceArea: 0.309856 m2; NetVolume: 0.0022848 m3; NetWeight: 0 kg
Name | Bottom elevation | Top elevation
6 x Liner Plate | +52.843 | +53.278
6 x Liner Plate | +52.814 | +53.249
6 x Liner Plate | +52.748 | +53.184
6 x Liner Plate | +52.719 | +53.155
6 x Liner Plate | +52.690 | +53.126
6 x Liner Plate | +52.625 | +53.060
6 x Liner Plate | +52.596 | +53.031
6 x Liner Plate | +52.567 | +53.002
6 x Liner Plate | +52.501 | +52.936
6 x Liner Plate | +52.472 | +52.907
6 x Liner Plate | +52.443 | +52.878
6 x Liner Plate | +52.380 | +52.815
6 x Liner Plate | +52.351 | +52.786
6 x Liner Plate | +52.322 | +52.757
6 x Liner Plate | +52.293 | +52.728

# IfcBeam: PL16*402 (6)
In: Undefined
Description: PL16*402; Material: Undefined/VRN500
Tekla Common - Bottom elevation: +52.409; Top elevation: +52.848; Phase: 6; Class: 13
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 402 mm; Width: 16 mm; Length: 408 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A833
BaseQuantities - Length: 408 mm; OuterSurfaceArea: 0.353951 m2; NetVolume: 0.00262425 m3; NetWeight: 0 kg

# IfcBeam: PL16*408 (18)
In: Undefined
Description: PL16*408; Material: Undefined/VRN500
Tekla Common - Phase: 6; Class: 13
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.3 m2; Height: 408 mm; Width: 16 mm; Length: 428 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A834
BaseQuantities - Length: 427.999 mm; OuterSurfaceArea: 0.375999 m2; NetVolume: 0.00279398 m3; NetWeight: 0 kg
Name | Bottom elevation | Top elevation
6 x Liner Plate | +52.777 | +53.219
6 x Liner Plate | +52.654 | +53.096
6 x Liner Plate | +52.530 | +52.972

# IfcBeam: PL3*1500 (12)
In: Undefined
Description: PL3*1500; Material: STEEL/S355JR
Tekla Common - Phase: 6; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.2 m2; Net surface area: 6.3 m2; Height: 1500 mm; Width: 3 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x Deck Plate | +51.812 | +52.027 | 74.1 | 2091.7 | A798 | 2091.68 | 6.31463 | 0.00943957 | 74.1006
2 x Deck Plate | +51.977 | +52.192 | 74 | 2088 | A795 | 2087.97 | 6.30347 | 0.00942286 | 73.9694
2 x Deck Plate | +52.142 | +52.357 | 74 | 2088 | A793 | 2087.95 | 6.3034 | 0.00942276 | 73.9686
2 x Deck Plate | +52.307 | +52.521 | 73.8 | 2084.2 | A791 | 2084.24 | 6.29227 | 0.00940609 | 73.8378
Deck Plate | +51.977 | +52.192 | 74 | 2088 | A790 | 2087.97 | 6.30347 | 0.00942286 | 73.9694
Deck Plate | +52.142 | +52.357 | 74 | 2088 | A794 | 2087.95 | 6.3034 | 0.00942276 | 73.9686
Deck Plate | +52.307 | +52.521 | 73.8 | 2084.2 | A792 | 2084.24 | 6.29227 | 0.00940609 | 73.8378

# IfcBeam: PL3*175 (3)
In: Undefined
Description: PL3*175; Material: Undefined/VALMETEX 6320H
Tekla Common - Bottom elevation: +51.115; Top elevation: +51.221; Phase: 22; Class: 2
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Height: 175 mm; Width: 3 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3)
DUMMY | 0.3 | 3.3 | 9046 | A801 | 3.30624 | 0.00487594
DUMMY | 0.2 | 1.9 | 5546 | A800 | 2.01824 | 0.00297544
DUMMY | 0.1 | 0.6 | 2046 | A799 | 0.730236 | 0.00107494

# IfcBeam: PL3*970 (3)
In: Undefined
Description: PL3*970; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +52.702; Top elevation: +53.192; Phase: 11; Class: 2
Tekla Quantity - Weight: 39 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.3 m2; Net surface area: 3.3 m2; Height: 970 mm; Width: 3 mm; Length: 1703.5 mm
Pset_BeamCommon - LoadBearing: yes; Reference: p327
BaseQuantities - Length: 1703.46 mm; OuterSurfaceArea: 3.32913 m2; NetVolume: 0.00496959 m3; NetWeight: 39.0113 kg

# IfcBeam: PL5*138.8 (3)
In: Undefined
Description: PL5*138.8; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +52.945; Top elevation: +53.021; Phase: 6; Class: 99
Tekla Quantity - Weight: 5.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 53 m2; Net surface area: 0.3 m2; Height: 138.8 mm; Width: 5 mm; Length: 968 mm
Pset_BeamCommon - LoadBearing: yes; Reference: p566
BaseQuantities - Length: 968 mm; OuterSurfaceArea: 0.289513 m2; NetVolume: 0.000695988 m3; NetWeight: 5.4635 kg

# IfcBeam: PL5*293.8 (3)
In: Undefined
Description: PL5*293.8; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +53.294; Top elevation: +53.378; Phase: 6; Class: 99
Tekla Quantity - Weight: 11.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 52.1 m2; Net surface area: 0.6 m2; Height: 293.8 mm; Width: 5 mm; Length: 968 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A815
BaseQuantities - Length: 968 mm; OuterSurfaceArea: 0.600875 m2; NetVolume: 0.00147039 m3; NetWeight: 11.5426 kg

# IfcBeam: PL5*803.8 (3)
In: Undefined
Description: PL5*803.8; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +52.717; Top elevation: +52.787; Phase: 6; Class: 99
Tekla Quantity - Weight: 30.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 51.5 m2; Net surface area: 1.6 m2; Height: 803.8 mm; Width: 5 mm; Length: 968 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 968 mm; OuterSurfaceArea: 1.58361 m2; NetVolume: 0.0039146 m3; NetWeight: 30.7296 kg
Name | Reference
Cover Plate | p563
2 x Cover Plate | p562

# IfcBeam: PL5*967.6 (3)
In: Undefined
Description: PL5*967.6; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +53.211; Top elevation: +53.351; Phase: 6; Class: 99
Tekla Quantity - Weight: 37.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 51.5 m2; Net surface area: 1.9 m2; Height: 967.6 mm; Width: 5 mm; Length: 968 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A814
BaseQuantities - Length: 968 mm; OuterSurfaceArea: 1.91209 m2; NetVolume: 0.00473158 m3; NetWeight: 37.1429 kg

# IfcBeam: PL5*968 (6)
In: Undefined
Description: PL5*968; Material: STEEL/S355JR
Tekla Common - Phase: 6
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 968 mm; Width: 5 mm; Length: 1467.6 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 1467.6 mm
Name | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x Vastrap Plate | +52.964 | +53.145 | 8 | 56.1 | 51.5 | 2.9 | A823 | 2.88509 | 0.00715158 | 56.1399
3 x Cover Plate | +53.088 | +53.269 | 99 | 45.8 | 51.7 | 2.4 | p561 | 2.36877 | 0.00583522 | 45.8065

# IfcBeam: PL50*50 (12)
In: Undefined
Description: PL50*50; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +56.735; Top elevation: +56.785; Phase: 12; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.3 m2; Area per tons: 10.2 m2; Height: 50 mm; Width: 50 mm
Pset_BeamCommon - LoadBearing: yes
Name | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x Rail | 117.8 | 1.3 | 6000 | A825 | 1.205 | 0.015 | 117.75
6 x Rail | 112.3 | 1.1 | 5720 | A824 | 1.149 | 0.0143 | 112.255

# IfcBeam: PL60*245 (8)
In: Undefined
Description: PL60*245; Material: MISCELLANEOUS/COMPONENT
Tekla Common - Phase: 3; Class: 22
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0.2 m2; Net surface area: 0.5 m2; Height: 245 mm; Width: 60 mm; Length: 750 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A676
BaseQuantities - Length: 750 mm; OuterSurfaceArea: 0.480971 m2; NetVolume: 0.01095 m3; NetWeight: 0 kg
Name | Bottom elevation | Top elevation
4 x Tread | +57.032 | +57.092
4 x Tread | +56.853 | +56.913

# IfcBeam: PL60*260 (12)
In: Undefined
Description: PL60*260; Material: MISCELLANEOUS/COMPONENT
Tekla Common - Phase: 2; Class: 22
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0.2 m2; Net surface area: 0.5 m2; Height: 260 mm; Width: 60 mm; Length: 750 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A675
BaseQuantities - Length: 750 mm; OuterSurfaceArea: 0.505271 m2; NetVolume: 0.011625 m3; NetWeight: 0 kg
Name | Bottom elevation | Top elevation
4 x Tread | +50.781 | +50.841
4 x Tread | +50.584 | +50.644
4 x Tread | +50.387 | +50.447

# IfcBeam: PLT28*50 (90)
In: Undefined
Description: PLT28*50; Material: Undefined/Hard Rubber
Tekla Common - Phase: 4; Class: 99
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 50 mm; Width: 28 mm; Length: 50 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A837
BaseQuantities - Length: 50 mm; OuterSurfaceArea: 0.01204 m2; NetVolume: 0.0000592 m3; NetWeight: 0 kg
Name | Bottom elevation | Top elevation
60 x Rubber | +58.266 | +58.316
30 x Rubber | +58.349 | +58.399

# IfcBeam: PLT5*130 (60)
In: Undefined
Description: PLT5*130; Material: STEEL/S355JR
Tekla Common - Phase: 4; Class: 3
Tekla Quantity - Weight: 1.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 53.7 m2; Net surface area: 0.1 m2; Height: 130 mm; Width: 5 mm; Length: 280 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A838
BaseQuantities - Length: 280 mm; OuterSurfaceArea: 0.0756143 m2; NetVolume: 0.000179401 m3; NetWeight: 1.40829 kg
Name | Bottom elevation | Top elevation
30 x Bracket | +58.261 | +58.411
30 x Bracket | +58.014 | +58.164

# IfcBeam: ROD2.5 (6)
In: Undefined
Description: ROD2.5; Material: MISCELLANEOUS/COMPONENT
Tekla Common - Bottom elevation: +51.160; Top elevation: +51.176; Phase: 22; Class: 2
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 2.2 mm; Width: 2.5 mm; Length: 233.5 mm
Pset_BeamCommon - LoadBearing: yes; Reference: m955
BaseQuantities - Length: 233.504 mm; OuterSurfaceArea: 0.00175004 m2; NetVolume: 9.39833e-07 m3; NetWeight: 0 kg

# IfcBeam: ROD26 (6)
In: Undefined
Description: ROD26; Material: Undefined/WIRE ROPE
Tekla Common - Class: 2
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Height: 26 mm; Width: 26 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Bottom elevation | Top elevation | Phase | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3)
DUMMY | +51.155 | +51.181 | 22 | 0.9 | 10439 | A711 | 0.843979 | 0.00529257
DUMMY | +51.155 | +51.181 | 22 | 0.6 | 6939 | A710 | 0.561349 | 0.00351807
DUMMY | +51.155 | +51.181 | 22 | 0.3 | 3439 | A709 | 0.278719 | 0.00174357
3 x DUMMY | +51.168 | +56.735 | 11 | 0.5 | 5567.5 | A708 | 0.450598 | 0.00282272

# IfcBeam: ROD35 (3)
In: Undefined
Description: ROD35; Material: Undefined/EN8
Tekla Common - Bottom elevation: +51.150; Top elevation: +51.185; Phase: 22; Class: 2
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 35 mm; Width: 35 mm; Length: 140 mm
Pset_BeamCommon - LoadBearing: yes; Reference: m954
BaseQuantities - Length: 140 mm; OuterSurfaceArea: 0.0176455 m2; NetVolume: 0.000126404 m3; NetWeight: 0 kg

# IfcBeam: ROD520 (2)
In: Undefined
Description: ROD520; Material: MISCELLANEOUS/ZERO
Tekla Common - Bottom elevation: +55.215; Top elevation: +55.735; Phase: 12; Class: 2
Tekla Quantity - Weight: 0 kg; Volume: 0.4 m3; Gross footprint area: 0 m2; Net surface area: 2.6 m2; Height: 520 mm; Width: 520 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A658
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 2.62613 m2; NetVolume: 0.285524 m3; NetWeight: 0 kg

# IfcBeam: ROD650 (3)
In: Undefined
Description: ROD650; Material: MISCELLANEOUS/ZERO
Tekla Common - Bottom elevation: +50.839; Top elevation: +51.489; Phase: 22; Class: 2
Tekla Quantity - Weight: 0 kg; Volume: 0.4 m3; Gross footprint area: 0 m2; Net surface area: 3.4 m2; Height: 650 mm; Width: 650 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A696
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 3.41581 m2; NetVolume: 0.446451 m3; NetWeight: 0 kg

# IfcBeam: ROD652 (2)
In: Undefined
Description: ROD652; Material: MISCELLANEOUS/ZERO
Tekla Common - Bottom elevation: +51.506; Top elevation: +52.158; Phase: 22; Class: 2
Tekla Quantity - Weight: 0 kg; Volume: 0.4 m3; Gross footprint area: 0 m2; Net surface area: 3.4 m2; Height: 652 mm; Width: 652 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A703
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 3.42837 m2; NetVolume: 0.449202 m3; NetWeight: 0 kg

# IfcBeam: ROD654 (7)
In: Undefined
Description: ROD654
Tekla Common - Class: 2
Tekla Quantity - Volume: 0.4 m3; Gross footprint area: 0 m2; Net surface area: 3.4 m2; Height: 654 mm; Width: 654 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 3.44093 m2; NetVolume: 0.451962 m3
Name | Material | Bottom elevation | Top elevation | Phase | Weight (kg) = NetWeight (kg) | Reference
DUMMY_PULLY | MISCELLANEOUS/ZERO | +51.505 | +52.159 | 22 | 0 | A438
3 x DUMMY_PULLY | STEEL/S355JR | +57.460 | +58.114 | 3 | 3547.9 | A437 | Tekla Quantity - Area per tons: 1 m2
3 x DUMMY_PULLY | Undefined/Dummy | +50.545 | +51.199 | 9 | 0 | A436

# IfcBeam: ROD824 (11)
In: Undefined
Description: ROD824
Tekla Common - Class: 2
Tekla Quantity - Weight: 0 kg; Volume: 0.7 m3; Gross footprint area: 0 m2; Net surface area: 4.6 m2; Height: 824 mm; Width: 824 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 4.5557 m2; NetVolume: 0.717856 m3; NetWeight: 0 kg
Name | Material | Bottom elevation | Top elevation | Phase | Reference
3 x DUMMY_PULLY | MISCELLANEOUS/ZERO | +51.375 | +52.199 | 22 | A440
3 x DUMMY_PULLY | MISCELLANEOUS/ZERO | +56.729 | +57.553 | 12 | A440
3 x DUMMY_PULLY | MISCELLANEOUS/ZERO | +57.109 | +57.933 | 5 | A440
2 x DUMMY_PULLY | Undefined/Dummy | +51.530 | +52.354 | 9 | A439

# IfcBeam: ROD830 (3)
In: Undefined
Description: ROD830; Material: MISCELLANEOUS/ZERO
Tekla Common - Bottom elevation: +50.837; Top elevation: +51.667; Phase: 22; Class: 2
Tekla Quantity - Weight: 0 kg; Volume: 0.7 m3; Gross footprint area: 0 m2; Net surface area: 4.6 m2; Height: 830 mm; Width: 830 mm; Length: 1350 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A704
BaseQuantities - Length: 1350 mm; OuterSurfaceArea: 4.59668 m2; NetVolume: 0.728348 m3; NetWeight: 0 kg

# IfcBeam: SHS75*75*4.0 (21)
In: Undefined
Description: SHS75*75*4.0; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.2 m2; Area per tons: 32 m2; Net surface area: 0.6 m2; Height: 75 mm; Width: 75 mm
Tekla Common - Phase: 4; Class: 3
Pset_BeamCommon - LoadBearing: yes
Name | Weight (kg) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Bottom elevation | Top elevation | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
15 x Frame | 19.1 | 2130 | +58.170 | +58.245 | m696 | 0.609746 | 0.00241968 | 18.9945
6 x Beam | 20.4 | 2270 | +58.337 | +58.412 | m697 | 0.649823 | 0.00257872 | 20.243

# IfcBeam: UB203*133*25 (19)
In: Undefined
Description: UB203*133*25; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 36.5 m2; Height: 203.2 mm; Width: 133.4 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x DUMMY | +50.822 | +51.025 | 22 | 2 | 231 | 1.2 | 8.6 | 9203.2 | m13 | 9203.2 | 8.42601 | 0.0289934 | 227.598
Beam | +57.067 | +57.270 | 3 | 3 | 50.1 | 0.3 | 1.7 | 1996.8 | m11 | 1996.75 | 1.82813 | 0.00620739 | 48.728
Beam | +57.067 | +57.270 | 3 | 3 | 50.1 | 0.3 | 1.7 | 1996.8 | m9 | 1996.75 | 1.82813 | 0.00620739 | 48.728
Beam | +57.067 | +57.270 | 3 | 3 | 50.1 | 0.3 | 1.7 | 1996.8 | m8 | 1996.75 | 1.82813 | 0.00620739 | 48.728
3 x Beam | +57.067 | +57.270 | 3 | 3 | 93.1 | 0.5 | 3.4 | 3709.5 | m7 | 3709.5 | 3.39624 | 0.0115316 | 90.5232
Beam | +57.067 | +57.270 | 3 | 3 | 50.1 | 0.3 | 1.7 | 1996.8 | m5 | 1996.75 | 1.82813 | 0.00620739 | 48.728
2 x Beam | +57.067 | +57.270 | 3 | 3 | 93.1 | 0.5 | 3.4 | 3709.5 | m6 | 3709.5 | 3.39624 | 0.0115316 | 90.5232
Beam | +57.067 | +57.270 | 3 | 3 | 50.1 | 0.3 | 1.7 | 1996.8 | m4 | 1996.75 | 1.82813 | 0.00620739 | 48.728
Beam | +57.067 | +57.270 | 3 | 3 | 50.1 | 0.3 | 1.7 | 1996.8 | m10 | 1996.75 | 1.82813 | 0.00620739 | 48.728
Beam | +57.067 | +57.270 | 3 | 3 | 93.1 | 0.5 | 3.4 | 3709.9 | m6 | 3709.9 | 3.39661 | 0.0115324 | 90.5296
Beam | +57.067 | +57.270 | 3 | 3 | 292.9 | 1.5 | 10.8 | 11667.5 | m3 | 11667.5 | 10.6822 | 0.03655 | 286.918

# IfcBeam: UB254*146*37 (12)
In: Undefined
Description: UB254*146*37; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +56.745; Top elevation: +56.885; Phase: 5; Class: 3
Tekla Quantity - Weight: 5.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 28.9 m2; Net surface area: 0.2 m2; Height: 256 mm; Width: 146.4 mm; Length: 140 mm
Pset_BeamCommon - LoadBearing: yes; Reference: m255
BaseQuantities - Length: 140 mm; OuterSurfaceArea: 0.150073 m2; NetVolume: 0.000653377 m3; NetWeight: 5.12901 kg

# IfcBeam: UB305*165*41 (6)
In: Undefined
Description: UB305*165*41; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +56.966; Top elevation: +57.270; Phase: 3; Class: 11
Tekla Quantity - Weight: 149.9 kg; Volume: 0 m3; Gross footprint area: 0.6 m2; Area per tons: 30.8 m2; Net surface area: 4.6 m2; Height: 303.8 mm; Width: 165.1 mm; Length: 3719.5 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 3719.5 mm; OuterSurfaceArea: 4.61411 m2; NetVolume: 0.0186916 m3; NetWeight: 146.729 kg
Name | Reference
4 x Beam | m682
2 x Beam | m681

# IfcBeam: UC152*152*23 (28)
In: Undefined
Description: UC152*152*23; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Area per tons: 38.7 m2; Height: 152.4 mm; Width: 152.4 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x DUMMY | +50.490 | +50.642 | 22 | 2 | 52.8 | 0.3 | 2.1 | 2294.2 | m280 | 2294.2 | 2.03989 | 0.0066975 | 52.5754
Frame | +57.118 | +57.270 | 3 | 3 | 24.7 | 0.1 | 0.9 | 1075.7 | m276 | 1075.7 | 0.956461 | 0.00300083 | 23.5565
Beam | +57.118 | +57.270 | 3 | 3 | 22.6 | 0.1 | 0.9 | 984 | m274 | 983.9 | 0.874837 | 0.00280202 | 21.9959
Frame | +57.118 | +57.270 | 3 | 3 | 22.6 | 0.1 | 0.9 | 984 | m273 | 983.9 | 0.874837 | 0.00280202 | 21.9959
Frame | +57.118 | +57.270 | 3 | 3 | 24.7 | 0.1 | 0.9 | 1075.7 | m275 | 1075.7 | 0.956461 | 0.00300083 | 23.5565
Stool | +56.827 | +57.057 | 1 | 3 | 5.3 | 0 | 0.2 | 229.8 | m272 | 229.801 | 0.204328 | 0.000670862 | 5.26627
2 x Stool | +56.827 | +57.057 | 1 | 3 | 5.3 | 0 | 0.2 | 229.8 | m271 | 229.801 | 0.204328 | 0.000670862 | 5.26627
Beam | +57.118 | +57.270 | 3 | 11 | 66 | 0.3 | 2.4 | 2869.5 | m270 | 2869.5 | 2.55142 | 0.00820981 | 64.447
Beam | +57.118 | +57.270 | 3 | 11 | 63.1 | 0.3 | 2.4 | 2742.1 | m269 | 2742.05 | 2.4381 | 0.00784333 | 61.5701
2 x Beam | +57.118 | +57.270 | 3 | 11 | 66 | 0.3 | 2.4 | 2869.5 | m266 | 2869.5 | 2.55142 | 0.00820981 | 64.447
2 x Beam | +57.118 | +57.270 | 3 | 11 | 63.1 | 0.3 | 2.4 | 2742.1 | m265 | 2742.05 | 2.4381 | 0.00784333 | 61.5701
2 x Beam | +57.118 | +57.270 | 3 | 11 | 66 | 0.3 | 2.4 | 2869.5 | m268 | 2869.5 | 2.55142 | 0.00820981 | 64.447
2 x Beam | +57.118 | +57.270 | 3 | 11 | 63.1 | 0.3 | 2.4 | 2742.1 | m267 | 2742.05 | 2.4381 | 0.00784333 | 61.5701
Beam | +57.118 | +57.270 | 3 | 11 | 66 | 0.3 | 2.4 | 2869.5 | m264 | 2869.5 | 2.55142 | 0.00820981 | 64.447
Beam | +57.118 | +57.270 | 3 | 11 | 63.1 | 0.3 | 2.4 | 2742.1 | m263 | 2742.05 | 2.4381 | 0.00784333 | 61.5701
6 x DUMMY | +50.262 | +56.560 | 11 | 2 | 144.9 | 0 | 5.7 | 6298 | m259 | 6298 | 5.59988 | 0.0183859 | 144.329

# IfcBeam: UC254*254*73 (3)
In: Undefined
Description: UC254*254*73; Material: STEEL/S355JR
Tekla Quantity - Weight: 240.9 kg; Volume: 0 m3; Gross footprint area: 0.8 m2; Area per tons: 20.3 m2; Net surface area: 5 m2; Height: 254.2 mm; Width: 254 mm; Length: 3295.8 mm
Tekla Common - Bottom elevation: +52.290; Top elevation: +52.544; Phase: 9; Class: 3
Pset_BeamCommon - LoadBearing: yes; Reference: m384
BaseQuantities - Length: 3295.8 mm; OuterSurfaceArea: 4.89557 m2; NetVolume: 0.0301746 m3; NetWeight: 236.871 kg

# IfcColumn: IPE140 (24)
In: Undefined
Description: IPE140; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +50.329; Phase: 22; Class: 2
Tekla Quantity - Weight: 24.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 42.7 m2; Net surface area: 1.1 m2; Height: 140 mm; Width: 73 mm
Pset_ColumnCommon - LoadBearing: yes
Name | Top elevation | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
13 x DUMMY | +52.226 | 1897 | m677 | 1.04445 | 0.00303622 | 23.8344
4 x DUMMY | +52.226 | 1897 | m680 | 1.04445 | 0.00303622 | 23.8344
6 x DUMMY | +52.232 | 1903 | m678 | 1.04776 | 0.00304583 | 23.9097
DUMMY | +52.226 | 1897 | m676 | 1.04445 | 0.00303622 | 23.8344

# IfcColumn: L100*100*8 (6)
In: Undefined
Description: L100*100*8; Material: STEEL/S355JR
Tekla Quantity - Weight: 79.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 32 m2; Net surface area: 2.6 m2; Height: 100 mm; Width: 100 mm; Length: 6480 mm
Tekla Common - Bottom elevation: +50.262; Top elevation: +56.742; Phase: 11; Class: 2
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - Length: 6480 mm; OuterSurfaceArea: 2.52525 m2; NetVolume: 0.00995328 m3
Name | Reference | NetWeight (kg)
3 x DUMMY | m379 | 78.1333
3 x DUMMY | m381 | 78.1332

# IfcColumn: L60*60*6 (6)
In: Undefined
Description: L60*60*6; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +51.000; Top elevation: +51.280; Phase: 22; Class: 2
Tekla Quantity - Weight: 1.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 43 m2; Net surface area: 0.1 m2; Height: 60 mm; Width: 60 mm; Length: 280.5 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - Length: 280.5 mm; OuterSurfaceArea: 0.0653937 m2; NetVolume: 0.000191862 m3; NetWeight: 1.50612 kg
Name | Reference
3 x DUMMY | m655
3 x DUMMY | m654

# IfcColumn: L80*80*6 (24)
In: Undefined
Description: L80*80*6; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 42.4 m2; Height: 80 mm; Width: 80 mm
Pset_ColumnCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x DUMMY | +50.252 | +52.592 | 22 | 2 | 17.2 | 0.9 | 2340 | m140 | 0.728713 | 0.00216216 | 16.973
2 x DUMMY | +50.252 | +52.592 | 25 | 2 | 17.2 | 0.9 | 2340 | m140 | 0.728713 | 0.00216216 | 16.973
12 x Post | +56.745 | +57.790 | 12 | 3 | 7.6 | 0.3 | 1045 | m134 | 0.32543 | 0.00096558 | 7.5798
6 x DUMMY | +50.252 | +52.302 | 11 | 2 | 14.9 | 0.6 | 2050 | m137 | 0.638403 | 0.0018942 | 14.8695

# IfcColumn: PC100*50 (24)
In: Undefined
Description: PC100*50; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 37.9 m2; Height: 100 mm; Width: 50 mm
Pset_ColumnCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x Post | +50.400 | +51.812 | 9 | 3 | 14.3 | 0.6 | 1412 | m169 | 1412 | 0.540498 | 0.00177347 | 13.9217
6 x Post | +50.400 | +51.564 | 9 | 3 | 11.8 | 0.5 | 1163.9 | m168 | 1163.9 | 0.44553 | 0.00146186 | 11.4756
3 x Column | +50.400 | +52.059 | 9 | 3 | 16.8 | 0.6 | 1659.5 | m165 | 1659.46 | 0.635222 | 0.00208428 | 16.3616
3 x Column | +50.400 | +52.059 | 9 | 3 | 16.8 | 0.6 | 1659.5 | m164 | 1659.46 | 0.635222 | 0.00208428 | 16.3616
3 x DUMMY | +52.303 | +56.478 | 11 | 2 | 42.2 | 1.6 | 4176.2 | m158 | 4176.18 | 1.5986 | 0.00524387 | 41.1644
3 x DUMMY | +52.303 | +56.477 | 11 | 2 | 42.2 | 1.6 | 4173.9 | m158 | 4174 | 1.59776 | 0.00524254 | 41.154

# IfcColumn: PC180*70 (42)
In: Undefined
Description: PC180*70; Material: STEEL/S355JR
Tekla Common - Phase: 4; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.3 m2; Height: 180 mm; Width: 70 mm
Pset_ColumnCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x Column | +57.282 | +58.317 | 21.8 | 0.6 | 1034.9 | m188 | 1035 | 0.638226 | 0.00272557 | 21.3957
6 x Column | +57.282 | +58.317 | 21.8 | 0.6 | 1034.9 | m184 | 1035 | 0.638226 | 0.00272557 | 21.3957
6 x Column | +56.747 | +58.317 | 33.1 | 0.9 | 1570 | m187 | 1570 | 0.96813 | 0.00413444 | 32.4553
6 x Column | +56.747 | +58.317 | 33.1 | 0.9 | 1570 | m183 | 1570 | 0.96813 | 0.00413444 | 32.4553
3 x Column | +56.747 | +58.305 | 32.9 | 0.9 | 1558 | m182 | 1558 | 0.96073 | 0.00410284 | 32.2073
6 x Column | +57.282 | +58.317 | 21.8 | 0.6 | 1034.9 | m186 | 1035 | 0.638226 | 0.00272557 | 21.3957
6 x Column | +56.747 | +58.317 | 33.1 | 0.9 | 1570 | m185 | 1570 | 0.96813 | 0.00413444 | 32.4553
3 x Column | +56.747 | +58.317 | 33.1 | 0.9 | 1570 | m181 | 1570 | 0.96813 | 0.00413444 | 32.4553

# IfcColumn: PC200*75 (9)
In: Undefined
Description: PC200*75; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27.8 m2; Height: 200 mm; Width: 75 mm
Pset_ColumnCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x DUMMY | +50.252 | +51.057 | 22 | 2 | 19.6 | 0.6 | 805 | m468 | 0.543548 | 0.0024464 | 19.2042
3 x Frame | +56.747 | +57.307 | 12 | 3 | 13.6 | 0.3 | 560 | m461 | 0.37812 | 0.00170184 | 13.3594
3 x DUMMY | +50.882 | +53.942 | 11 | 2 | 74.4 | 2.1 | 3060 | m466 | 2.06616 | 0.00929934 | 72.9998

# IfcColumn: PC230*90 (16)
In: Undefined
Description: PC230*90; Material: STEEL/S355JR
Tekla Common - Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24.8 m2; Height: 230 mm; Width: 90 mm
Pset_ColumnCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Column | +55.492 | +55.725 | 3 | 7.5 | 0.2 | 233 | m34 | 0.185165 | 0.000940155 | 7.38022
2 x Column | +50.254 | +56.325 | 1 | 195.5 | 4.8 | 6071 | m24 | 4.82462 | 0.0244965 | 192.297
2 x Column | +50.254 | +55.374 | 1 | 164.9 | 4.2 | 5120 | m23 | 4.06886 | 0.0206592 | 162.175
2 x Column | +50.254 | +54.381 | 1 | 132.9 | 3.3 | 4127 | m22 | 3.27972 | 0.0166524 | 130.722
2 x Column | +50.254 | +53.389 | 1 | 100.9 | 2.4 | 3135 | m21 | 2.49138 | 0.0126497 | 99.3003
2 x Column | +50.254 | +52.396 | 1 | 69 | 1.7 | 2142 | m20 | 1.70225 | 0.00864297 | 67.8473
2 x Column | +50.254 | +51.403 | 1 | 37 | 0.9 | 1149 | m19 | 0.913109 | 0.00463621 | 36.3943
2 x Column | +50.254 | +50.815 | 1 | 18.1 | 0.5 | 561 | m18 | 0.445826 | 0.00226363 | 17.7695

# IfcColumn: UB203*133*25 (20)
In: Undefined
Description: UB203*133*25; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +50.254; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 36.5 m2; Height: 203.2 mm; Width: 133.4 mm
Pset_ColumnCommon - LoadBearing: yes
Name | Top elevation | Phase | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
12 x Stool | +50.380 | 9 | 3.2 | 0.1 | 126 | -38AMm38 | 0.11536 | 0.000396945 | 3.11602
6 x Stool | +50.380 | 9 | 3.2 | 0.1 | 126 | -38AMm31 | 0.11536 | 0.000396945 | 3.11602
Column | +51.403 | 1 | 28.7 | 1.1 | 1149 | m2 | 1.05197 | 0.00361976 | 28.4151
Column | +50.815 | 1 | 14.1 | 0.5 | 561 | m1 | 0.513625 | 0.00176735 | 13.8737

# IfcColumn: UB254*146*37 (2)
In: Undefined
Description: UB254*146*37; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +50.262; Top elevation: +55.395; Phase: 1; Class: 3
Tekla Quantity - Weight: 189.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 28.9 m2; Net surface area: 5.7 m2; Height: 256 mm; Width: 146.4 mm; Length: 5133 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: m252
BaseQuantities - Length: 5133 mm; OuterSurfaceArea: 5.50233 m2; NetVolume: 0.0239556 m3; NetWeight: 188.052 kg

# IfcColumn: UB305*165*41 (6)
In: Undefined
Description: UB305*165*41; Material: STEEL/S355JR
Tekla Common - Phase: 5; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 30.8 m2; Height: 303.8 mm; Width: 165.1 mm
Pset_ColumnCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x Frame | +56.799 | +58.399 | 64.5 | 1.9 | 1600.2 | m684 | 1.98508 | 0.0078301 | 61.4663
3 x Frame | +56.992 | +59.704 | 109.3 | 3.4 | 2712 | m683 | 3.36429 | 0.0138225 | 108.506

# IfcColumn: UB457*191*67 (3)
In: Undefined
Description: UB457*191*67; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +50.262; Top elevation: +50.969; Phase: 22; Class: 2
Tekla Quantity - Weight: 47.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24.3 m2; Net surface area: 1.3 m2; Height: 453.6 mm; Width: 189.9 mm; Length: 707 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: m953
BaseQuantities - Length: 707 mm; OuterSurfaceArea: 1.15403 m2; NetVolume: 0.00598345 m3; NetWeight: 46.9701 kg

# IfcColumn: UC152*152*23, Post
In: Undefined
Description: UC152*152*23; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +55.105; Top elevation: +56.603; Phase: 1; Class: 3
Tekla Quantity - Weight: 34.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 38.7 m2; Net surface area: 1.4 m2; Height: 152.4 mm; Width: 152.4 mm; Length: 1498 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: m258
BaseQuantities - Length: 1498 mm; OuterSurfaceArea: 1.33195 m2; NetVolume: 0.00437314 m3; NetWeight: 34.3291 kg

# IfcColumn: UC254*254*73 (5)
In: Undefined
Description: UC254*254*73; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +50.262; Top elevation: +52.432; Phase: 22; Class: 2
Tekla Quantity - Weight: 158.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 20.3 m2; Net surface area: 3.3 m2; Height: 254.2 mm; Width: 254 mm; Length: 2170 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - Length: 2170 mm; OuterSurfaceArea: 3.22331 m2; NetVolume: 0.0198674 m3; NetWeight: 155.959 kg
Name | Reference
3 x DUMMY | m393
2 x DUMMY | m395

# IfcCovering: COMPONENT (4)
Material: Undefined/Undefined

# IfcCovering: SITE MODS (16)
Material: Undefined/Undefined

# IfcDiscreteAccessory: Angle (1712)
In: Undefined
Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
4 x Angle | L70*70*6 | +51.017 | +51.087 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 50 | m109 | 0.0136137 | 0.000812739 | 0.0000402 | 0.0000406369
4 x Angle | L70*70*6 | +51.017 | +51.087 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 50 | m108 | 0.0136137 | 0.000812739 | 0.0000402 | 0.0000406369
6 x Angle | L40*40*3 | +52.554 | +52.594 | 9 | 3 | 0.9 | 0 | 83.7 | 0.1 | 40 | 40 | 501 | m554 | 0.0775796 | 0.000235669 | 0.000115731 | 0.00011807
6 x Angle | L40*40*3 | +50.342 | +50.382 | 9 | 3 | 0.9 | 0 | 83.7 | 0.1 | 40 | 40 | 501 | m554 | 0.0775797 | 0.000235669 | 0.000115731 | 0.00011807
42 x Angle | L40*40*3 | +50.345 | +52.591 | 9 | 3 | 4.2 | 0 | 83.7 | 0.3 | 40 | 40 | 2246 | m543 | 0.347792 | 0.000235669 | 0.000510612 | 0.000529312
6 x Angle | L70*70*6 | +50.937 | +50.997 | 9 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m107 | 0.0163365 | 0.000812739 | 0.00004824 | 0.0000487643
2 x Angle | L60*60*6 | +57.167 | +57.228 | 2 | 99 | 0.3 | 0 | 43 | 0 | 60 | 60 | 75 | m649 | 0.0174847 | 0.000690446 | 0.0000512993 | 0.0000517828
2 x Angle | L60*60*6 | +57.167 | +57.228 | 2 | 99 | 0.3 | 0 | 43 | 0 | 60 | 60 | 75 | m648 | 0.0174847 | 0.000690446 | 0.0000512993 | 0.0000517828
6 x Angle | L100*75*8 | +58.085 | +58.190 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546268 | 0.00135032 | 0.000213761 | 0.000216052
5 x Angle | L100*75*8 | +57.931 | +58.038 | 2 | 99 | 1.7 | 0 | 32.2 | 0.1 | 100 | 75 | 160 | m965 | 0.0546265 | 0.00135032 | 0.00021376 | 0.000216051
6 x Angle | L50*50*6 | +51.126 | +51.190 | 6 | 99 | 0.3 | 0 | 43.4 | 0 | 50 | 50 | 60 | m916 | 0.0116396 | 0.000569427 | 0.0000338404 | 0.000034166
6 x Angle | L70*70*6 | +57.182 | +57.244 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m106 | 0.0163367 | 0.000812739 | 0.0000482406 | 0.000048765
6 x Angle | L70*70*6 | +56.644 | +56.708 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m106 | 0.0163367 | 0.000812739 | 0.0000482406 | 0.0000487649
6 x Angle | L70*70*6 | +56.636 | +56.700 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m106 | 0.0163367 | 0.000812739 | 0.0000482406 | 0.000048765
6 x Angle | L70*70*6 | +55.693 | +55.759 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m106 | 0.0163367 | 0.000812739 | 0.0000482406 | 0.0000487649
6 x Angle | L70*70*6 | +55.682 | +55.748 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m106 | 0.0163367 | 0.000812739 | 0.0000482406 | 0.0000487649
6 x Angle | L70*70*6 | +54.701 | +54.767 | 2 | 99 | 0.3 | 0 | 42.7 | 0 | 70 | 70 | 60 | m106 | 0.0163367 | 0.000812739 | 0.0000482406 | 0.0000487649
