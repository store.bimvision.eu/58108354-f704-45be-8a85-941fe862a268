Properties of the parts of a building model (IFC2X3), part 8 of 16

# IfcDiscreteAccessory: Plate (5440)
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
4 x Plate | PLT10*229.9 | +53.094 | +53.451 | 1 | 99 | 4.8 | 0 | 27.5 | 0.1 | 230 | 10 | 297.9 | p50 | 0.135678 | 0.0684927 | 0.0001 | 0.000629348 | 0.000629348
Plate | PLT10*201.7 | +55.105 | +55.307 | 1 | 99 | 3.9 | 0 | 27.8 | 0.1 | 201.7 | 10 | 332.9 | -38AKp42 | 0.11207 | 0.0671333 | 0.0001 | 0.00051366 | 0.00051366
Plate | PLT10*201.7 | +55.105 | +55.307 | 1 | 99 | 3.9 | 0 | 27.8 | 0.1 | 201.7 | 10 | 332.9 | -38AKp42 | 0.11207 | 0.0671332 | 0.0001 | 0.00051366 | 0.00051366
2 x Plate | PLT10*380.9 | +56.331 | +56.712 | 1 | 99 | 14.9 | 0 | 26.7 | 0.3 | 380.9 | 10 | 590.9 | -38AKp43 | 0.400396 | 0.225061 | 0.0001 | 0.00191307 | 0.00191307
2 x Plate | PLT12*107.1 | +56.383 | +56.712 | 1 | 99 | 2.4 | 0 | 24.9 | 0.1 | 107.1 | 12 | 328.9 | p119 | 0.0632979 | 0.0352246 | 0.000144 | 0.000323198 | 0.000323198
2 x Plate | PLT12*117.1 | +56.383 | +56.712 | 1 | 99 | 2.7 | 0 | 24.8 | 0.1 | 117.1 | 12 | 328.9 | p120 | 0.0674349 | 0.0385136 | 0.000144 | 0.000347132 | 0.000347132
2 x Plate | PLT12*86.8 | +56.718 | +56.805 | 1 | 99 | 2 | 0 | 25.4 | 0 | 86.8 | 12 | 256 | p121 | 0.0473955 | 0.022221 | 0.000144 | 0.00023754 | 0.00023754
3 x Plate | PLT8*218.7 | +56.889 | +57.194 | 3 | 99 | 3.2 | 0 | 34 | 0.1 | 218.7 | 8 | 302.4 | p441 | 0.107203 | 0.0661306 | 0.000064 | 0.00040138 | 0.00040138
2 x Plate | PLT8*38 | +56.976 | +57.108 | 3 | 99 | 0.2 | 0 | 46.3 | 0 | 38 | 8 | 131.7 | p440 | 0.00727865 | 0.0050082 | 0.000064 | 0.0000200328 | 0.0000200328
2 x Plate | PLT8*38 | +56.976 | +57.108 | 3 | 99 | 0.2 | 0 | 46.3 | 0 | 38 | 8 | 131.7 | p440 | 0.00727868 | 0.00500822 | 0.000064 | 0.0000200329 | 0.0000200329
Plate | PLT8*291.6 | +56.767 | +57.173 | 3 | 99 | 5.3 | 0 | 33.5 | 0.2 | 291.6 | 8 | 402.8 | p439 | 0.180645 | 0.11744 | 0.000064 | 0.000686774 | 0.000686774
2 x Plate | PLT8*291.6 | +56.767 | +57.173 | 3 | 99 | 5.7 | 0 | 33.5 | 0.2 | 291.6 | 8 | 402.8 | p436 | 0.187372 | 0.11744 | 0.000064 | 0.000712936 | 0.000712936
2 x Plate | PLT8*291.6 | +56.767 | +57.173 | 3 | 99 | 5.7 | 0 | 33.5 | 0.2 | 291.6 | 8 | 402.8 | p432 | 0.187372 | 0.11744 | 0.000064 | 0.000712936 | 0.000712936
2 x Plate | PLT8*291.6 | +56.767 | +57.173 | 3 | 99 | 5.7 | 0 | 33.5 | 0.2 | 291.6 | 8 | 402.8 | p442 | 0.187372 | 0.11744 | 0.000064 | 0.000712936 | 0.000712936
2 x Plate | PLT8*291.6 | +56.767 | +57.173 | 3 | 99 | 5.7 | 0 | 33.5 | 0.2 | 291.6 | 8 | 402.8 | p437 | 0.187372 | 0.11744 | 0.000064 | 0.000712936 | 0.000712936
2 x Plate | PLT8*291.6 | +56.767 | +57.173 | 3 | 99 | 5.7 | 0 | 33.5 | 0.2 | 291.6 | 8 | 402.8 | p438 | 0.187372 | 0.11744 | 0.000064 | 0.000712936 | 0.000712936
2 x Plate | PLT8*291.6 | +56.767 | +57.173 | 3 | 99 | 5.7 | 0 | 33.5 | 0.2 | 291.6 | 8 | 402.8 | p433 | 0.187372 | 0.11744 | 0.000064 | 0.000712936 | 0.000712936
2 x Plate | PLT8*218.7 | +56.889 | +57.194 | 3 | 99 | 3.2 | 0 | 34 | 0.1 | 218.7 | 8 | 302.4 | p434 | 0.107203 | 0.0661306 | 0.000064 | 0.00040138 | 0.00040138
2 x Plate | PLT8*218.7 | +56.889 | +57.194 | 3 | 99 | 3.2 | 0 | 34 | 0.1 | 218.7 | 8 | 302.4 | p435 | 0.107203 | 0.0661306 | 0.000064 | 0.00040138 | 0.00040138
Plate | PLT8*218.7 | +56.889 | +57.194 | 3 | 99 | 3.2 | 0 | 34 | 0.1 | 218.7 | 8 | 302.4 | p443 | 0.107203 | 0.0661306 | 0.000064 | 0.00040138 | 0.00040138
2 x Plate | PL8*328.2 | +56.700 | +57.157 | 3 | 99 | 7.1 | 0 | 33.3 | 0.2 | 328.2 | 8 | 453.3 | p302 | 0.236042 | 0.148758 | 0.000064 | 0.000903032 | 0.000903032
2 x Plate | PL8*328.2 | +56.700 | +57.157 | 3 | 99 | 7.1 | 0 | 33.3 | 0.2 | 328.2 | 8 | 453.3 | p301 | 0.236042 | 0.148758 | 0.000064 | 0.000903032 | 0.000903032
6 x Plate | PLT6*218.7 | +58.169 | +58.475 | 5 | 99 | 2.3 | 0 | 44.7 | 0.1 | 218.7 | 6 | 302.4 | p218 | 0.102548 | 0.0661207 | 0.000036 | 0.00029249 | 0.00029249
6 x Plate | PLT6*218.7 | +58.158 | +58.464 | 5 | 99 | 2.4 | 0 | 44.6 | 0.1 | 218.7 | 6 | 302.4 | p231 | 0.105472 | 0.0661207 | 0.000036 | 0.000300987 | 0.000300987
6 x Plate | PLT6*218.7 | +58.132 | +58.438 | 5 | 99 | 2.4 | 0 | 44.6 | 0.1 | 218.7 | 6 | 302.4 | p231 | 0.105472 | 0.0661207 | 0.000036 | 0.000300987 | 0.000300987
6 x Plate | PLT6*218.7 | +58.111 | +58.417 | 5 | 99 | 2.4 | 0 | 44.6 | 0.1 | 218.7 | 6 | 302.4 | p231 | 0.105472 | 0.0661207 | 0.000036 | 0.000300987 | 0.000300987
6 x Plate | PLT6*218.7 | +58.084 | +58.390 | 5 | 99 | 2.4 | 0 | 44.6 | 0.1 | 218.7 | 6 | 302.4 | p231 | 0.105472 | 0.0661207 | 0.000036 | 0.000300987 | 0.000300987
6 x Plate | PLT6*218.7 | +58.063 | +58.369 | 5 | 99 | 2.4 | 0 | 44.6 | 0.1 | 218.7 | 6 | 302.4 | p231 | 0.105472 | 0.0661207 | 0.000036 | 0.000300987 | 0.000300987
6 x Plate | PLT6*218.7 | +58.047 | +58.353 | 5 | 99 | 2.4 | 0 | 44.6 | 0.1 | 218.7 | 6 | 302.4 | p231 | 0.105472 | 0.0661207 | 0.000036 | 0.000300987 | 0.000300987
6 x Plate | PLT6*218.7 | +58.037 | +58.343 | 5 | 99 | 2.4 | 0 | 44.6 | 0.1 | 218.7 | 6 | 302.4 | p231 | 0.105472 | 0.0661207 | 0.000036 | 0.000300987 | 0.000300987
6 x Plate | PLT6*218.7 | +58.031 | +58.337 | 5 | 99 | 2.3 | 0 | 44.7 | 0.1 | 218.7 | 6 | 302.4 | p218 | 0.102543 | 0.0661207 | 0.000036 | 0.000292474 | 0.000292474
3 x Plate | FL8*130 | +57.259 | +57.270 | 2 | 99 | 2.2 | 0 | 34.8 | 0.1 | 130 | 8 | 270 | p550 | 0.0766021 | 0.035101 | 0.000064 | 0.000280808 | 0.000280808
12 x Plate | PL10*120 | +57.861 | +57.871 | 5 | 99 | 1.4 | 0 | 29.1 | 0 | 120 | 10 | 196 | p263 | 0.0446468 | 0.02352 | 0.0001 | 0.000195212 | 0.000195212
12 x Plate | PL10*120 | +57.625 | +57.635 | 5 | 99 | 1.4 | 0 | 29.1 | 0 | 120 | 10 | 196 | p263 | 0.0446468 | 0.02352 | 0.0001 | 0.000195212 | 0.000195212
12 x Plate | PL10*120 | +57.407 | +57.417 | 5 | 99 | 1.4 | 0 | 29.1 | 0 | 120 | 10 | 196 | p263 | 0.0446468 | 0.02352 | 0.0001 | 0.000195212 | 0.000195212
12 x Plate | PL10*120 | +57.192 | +57.202 | 5 | 99 | 1.4 | 0 | 29.1 | 0 | 120 | 10 | 196 | p263 | 0.0446468 | 0.02352 | 0.0001 | 0.000195212 | 0.000195212
6 x Plate | PL10*120 | +58.695 | +58.705 | 5 | 99 | 1.4 | 0 | 29.1 | 0 | 120 | 10 | 196 | p263 | 0.0446468 | 0.02352 | 0.0001 | 0.000195212 | 0.000195212
6 x Plate | PL10*120 | +58.695 | +58.705 | 5 | 99 | 1.4 | 0 | 29.1 | 0 | 120 | 10 | 196 | p263 | 0.0446468 | 0.02352 | 0.0001 | 0.000195211 | 0.000195211
6 x Plate | PL10*120 | +58.450 | +58.460 | 5 | 99 | 1.4 | 0 | 29.1 | 0 | 120 | 10 | 196 | p263 | 0.0446468 | 0.02352 | 0.0001 | 0.000195212 | 0.000195212
6 x Plate | PL10*120 | +58.450 | +58.460 | 5 | 99 | 1.4 | 0 | 29.1 | 0 | 120 | 10 | 196 | p263 | 0.0446468 | 0.02352 | 0.0001 | 0.000195211 | 0.000195211
6 x Plate | PL10*120 | +58.250 | +58.260 | 5 | 99 | 1.4 | 0 | 29.1 | 0 | 120 | 10 | 196 | p263 | 0.0446468 | 0.02352 | 0.0001 | 0.000195212 | 0.000195212
6 x Plate | PL10*120 | +58.250 | +58.260 | 5 | 99 | 1.4 | 0 | 29.1 | 0 | 120 | 10 | 196 | p263 | 0.0446468 | 0.02352 | 0.0001 | 0.000195211 | 0.000195211
6 x Plate | FL10*100 | +56.468 | +56.484 | 2 | 99 | 1.2 | 0 | 29.6 | 0 | 100 | 10 | 160 | p49 | 0.0372 | 0.016 | 0.0001 | 0.00016 | 0.00016
3 x Plate | FL8*130 | +56.840 | +56.858 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 150 | p549 | 0.04348 | 0.0195 | 0.000064 | 0.000156 | 0.000156
6 x Plate | FL10*80 | +51.126 | +51.296 | 9 | 99 | 1.1 | 0 | 30.2 | 0 | 80 | 10 | 170 | p79 | 0.0322 | 0.0322 | 0.0008 | 0.000136 | 0.000136
3 x Plate | PLT8*50.7 | +52.964 | +53.028 | 6 | 99 | 0.2 | 0 | 42.6 | 0 | 50.7 | 8 | 75 | -38AMp91 | 0.00651945 | 0.00379704 | 0.000064 | 0.0000195102 | 0.0000195102
3 x Plate | PLT8*50.7 | +52.921 | +52.985 | 6 | 99 | 0.2 | 0 | 42.6 | 0 | 50.7 | 8 | 75 | -38AMp91 | 0.00651945 | 0.00379704 | 0.000064 | 0.0000195102 | 0.0000195102
24 x Plate | PL8*67 | +50.400 | +50.467 | 9 | 99 | 0.2 | 0 | 41 | 0 | 67 | 8 | 67 | -38AMp74 | 0.00837747 | 0.004489 | 0.000064 | 0.000026034 | 0.000026034
9 x Plate | FL8*150 | +50.392 | +50.400 | 9 | 99 | 1.2 | 0 | 35.6 | 0 | 127 | 8 | 127 | -38AMp73 | 0.042532 | 0.042532 | 0.001016 | 0.0001524 | 0.0001524
9 x Plate | FL12*130 | +50.380 | +50.392 | 9 | 99 | 2.3 | 0 | 24.5 | 0.1 | 130 | 12 | 190 | -38AMp47 | 0.05708 | 0.05708 | 0.00156 | 0.0002964 | 0.0002964
9 x Plate | FL12*130 | +50.242 | +50.254 | 9 | 99 | 2.3 | 0 | 24.5 | 0.1 | 130 | 12 | 190 | -38AMp46 | 0.05708 | 0.05708 | 0.00156 | 0.0002964 | 0.0002964
3 x Plate | FL8*150 | +50.392 | +50.400 | 9 | 99 | 1.2 | 0 | 35.6 | 0 | 127 | 8 | 127 | -38AMp11 | 0.042532 | 0.042532 | 0.001016 | 0.0001524 | 0.0001524
3 x Plate | FL12*130 | +50.380 | +50.392 | 9 | 99 | 2.3 | 0 | 24.5 | 0.1 | 130 | 12 | 190 | -38AMp20 | 0.05708 | 0.05708 | 0.00156 | 0.0002964 | 0.0002964
3 x Plate | FL12*130 | +50.242 | +50.254 | 9 | 99 | 2.3 | 0 | 24.5 | 0.1 | 130 | 12 | 190 | -38AMp19 | 0.05708 | 0.05708 | 0.00156 | 0.0002964 | 0.0002964
2 x Plate | PLT10*209.9 | +50.944 | +51.154 | 9 | 99 | 6.9 | 0 | 27.2 | 0.2 | 209.9 | 10 | 437.2 | -38AMp33 | 0.189424 | 0.0917711 | 0.0001 | 0.00088572 | 0.00088572
12 x Plate | PL8*67 | +50.400 | +50.467 | 9 | 99 | 0.2 | 0 | 41 | 0 | 67 | 8 | 67 | -38AMp39 | 0.00837747 | 0.004489 | 0.000064 | 0.000026034 | 0.000026034
6 x Plate | FL8*150 | +50.392 | +50.400 | 9 | 99 | 1.2 | 0 | 35.6 | 0 | 127 | 8 | 127 | -38AMp38 | 0.042532 | 0.042532 | 0.001016 | 0.0001524 | 0.0001524
6 x Plate | FL12*130 | +50.380 | +50.392 | 9 | 99 | 2.3 | 0 | 24.5 | 0.1 | 130 | 12 | 190 | -38AMp41 | 0.05708 | 0.05708 | 0.00156 | 0.0002964 | 0.0002964
6 x Plate | FL12*130 | +50.242 | +50.254 | 9 | 99 | 2.3 | 0 | 24.5 | 0.1 | 130 | 12 | 190 | -38AMp40 | 0.05708 | 0.05708 | 0.00156 | 0.0002964 | 0.0002964
6 x Plate | FL10*70 | +51.084 | +51.234 | 9 | 99 | 0.7 | 0 | 30.8 | 0 | 70 | 10 | 150 | -38AMp121 | 0.0254 | 0.0254 | 0.0015 | 0.000105 | 0.000105
3 x Plate | PLT10*162.5 | +50.458 | +50.621 | 9 | 99 | 2.2 | 0 | 28.5 | 0.1 | 162.5 | 10 | 216.2 | -38AMp117 | 0.0623546 | 0.0351438 | 0.0001 | 0.000278675 | 0.000278675
3 x Plate | PLT10*162.6 | +50.458 | +50.621 | 9 | 99 | 2.2 | 0 | 28.5 | 0.1 | 162.6 | 10 | 216.2 | -38AMp123 | 0.0623566 | 0.0351461 | 0.0001 | 0.000278684 | 0.000278684
3 x Plate | FL8*130 | +56.705 | +56.722 | 2 | 99 | 2.1 | 0 | 34.8 | 0.1 | 130 | 8 | 260 | p532 | 0.07384 | 0.0338 | 0.000064 | 0.0002704 | 0.0002704
3 x Plate | FL8*150 | +56.645 | +56.663 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | PLT8*155 | +56.651 | +56.669 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 155 | 8 | 160 | p480 | 0.05464 | 0.0248 | 0.000064 | 0.0001984 | 0.0001984
3 x Plate | FL8*130 | +56.575 | +56.595 | 2 | 99 | 1.2 | 0 | 35.3 | 0 | 130 | 8 | 160 | p529 | 0.04624 | 0.0208 | 0.000064 | 0.0001664 | 0.0001664
3 x Plate | PLT8*160 | +56.582 | +56.601 | 2 | 99 | 2 | 0 | 34.8 | 0.1 | 160 | 8 | 190 | p533 | 0.0664 | 0.0304 | 0.000064 | 0.0002432 | 0.0002432
3 x Plate | FL8*150 | +56.497 | +56.518 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +56.504 | +56.525 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*130 | +56.422 | +56.442 | 2 | 99 | 1.2 | 0 | 35.3 | 0 | 130 | 8 | 160 | p529 | 0.0462403 | 0.0208001 | 0.000064 | 0.000166401 | 0.000166401
3 x Plate | PLT8*160 | +56.429 | +56.450 | 2 | 99 | 2 | 0 | 34.8 | 0.1 | 160 | 8 | 190 | p533 | 0.0664002 | 0.0304001 | 0.000064 | 0.000243201 | 0.000243201
3 x Plate | FL8*130 | +57.239 | +57.251 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 155 | p481 | 0.04486 | 0.02015 | 0.000064 | 0.0001612 | 0.0001612
3 x Plate | FL8*130 | +57.238 | +57.249 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 150 | p482 | 0.0434802 | 0.0195001 | 0.000064 | 0.000156001 | 0.000156001
3 x Plate | FL8*130 | +57.212 | +57.224 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 195 | p540 | 0.0559 | 0.02535 | 0.000064 | 0.0002028 | 0.0002028
3 x Plate | FL8*130 | +57.209 | +57.222 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 155 | p541 | 0.044859 | 0.0201495 | 0.000064 | 0.000161196 | 0.000161196
3 x Plate | FL8*150 | +57.178 | +57.190 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130.7 | 8 | 130.7 | p482 | 0.0436994 | 0.017081 | 0.000064 | 0.000156833 | 0.000156833
3 x Plate | FL8*130 | +57.175 | +57.188 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 150 | p482 | 0.0434803 | 0.0195001 | 0.000064 | 0.000156001 | 0.000156001
3 x Plate | FL8*130 | +57.140 | +57.153 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p542 | 0.05452 | 0.0247 | 0.000064 | 0.0001976 | 0.0001976
3 x Plate | FL8*80 | +57.679 | +57.698 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*80 | +57.608 | +57.628 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*80 | +57.532 | +57.553 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*80 | +57.459 | +57.480 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*80 | +57.685 | +57.703 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p474 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | FL8*80 | +57.615 | +57.635 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | FL8*80 | +57.539 | +57.560 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | FL8*80 | +57.466 | +57.487 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | FL8*130 | +57.137 | +57.151 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 155 | p543 | 0.04486 | 0.02015 | 0.000064 | 0.0001612 | 0.0001612
3 x Plate | FL8*130 | +57.098 | +57.112 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 150 | p482 | 0.04348 | 0.0195 | 0.000064 | 0.000156 | 0.000156
3 x Plate | FL8*130 | +57.096 | +57.109 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 150 | p482 | 0.04348 | 0.0195 | 0.000064 | 0.000156 | 0.000156
3 x Plate | PLT8*195 | +57.052 | +57.069 | 2 | 99 | 2.7 | 0 | 34.4 | 0.1 | 195 | 8 | 220 | p483 | 0.0924397 | 0.0429001 | 0.000064 | 0.000343199 | 0.000343199
3 x Plate | FL8*130 | +57.007 | +57.022 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 150 | p482 | 0.0434798 | 0.0195 | 0.000064 | 0.000155999 | 0.000155999
3 x Plate | FL8*130 | +57.004 | +57.019 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 150 | p482 | 0.0434798 | 0.0195 | 0.000064 | 0.000155999 | 0.000155999
3 x Plate | FL8*130 | +56.957 | +56.972 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p530 | 0.0545201 | 0.0247002 | 0.000064 | 0.0001976 | 0.0001976
3 x Plate | FL8*130 | +56.953 | +56.969 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 155 | p541 | 0.0448594 | 0.0201497 | 0.000064 | 0.000161198 | 0.000161198
3 x Plate | FL8*130 | +56.902 | +56.917 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 150 | p482 | 0.04348 | 0.0195 | 0.000064 | 0.000156 | 0.000156
3 x Plate | FL8*130 | +56.899 | +56.914 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 150 | p482 | 0.04348 | 0.0195 | 0.000064 | 0.000156 | 0.000156
2 x Plate | FL8*130 | +56.845 | +56.862 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p544 | 0.05452 | 0.0247042 | 0.000064 | 0.0001976 | 0.0001976
3 x Plate | FL8*130 | +56.783 | +56.799 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 150 | p482 | 0.04348 | 0.0195 | 0.000064 | 0.000156 | 0.000156
3 x Plate | FL8*130 | +56.779 | +56.795 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 130 | 8 | 155 | p481 | 0.04486 | 0.02015 | 0.000064 | 0.0001612 | 0.0001612
3 x Plate | FL8*130 | +56.729 | +56.745 | 2 | 99 | 2.1 | 0 | 34.8 | 0.1 | 130 | 8 | 260 | p536 | 0.07384 | 0.0338 | 0.000064 | 0.0002704 | 0.0002704
5 x Plate | FL8*50 | +56.710 | +56.764 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70.8 | p545 | 0.00891806 | 0.00353914 | 0.000064 | 0.0000279928 | 0.0000279928
6 x Plate | FL8*60 | +56.406 | +56.480 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170.1 | p459 | 0.0240801 | 0.0102057 | 0.000064 | 0.0000816003 | 0.0000816003
6 x Plate | FL8*60 | +56.486 | +56.560 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.0240801 | 0.0102024 | 0.000064 | 0.0000816005 | 0.0000816005
6 x Plate | FL8*50 | +57.332 | +57.397 | 2 | 99 | 0.7 | 0 | 38.4 | 0 | 50 | 8 | 180.1 | p484 | 0.0216875 | 0.00900325 | 0.000064 | 0.000072026 | 0.000072026
5 x Plate | FL8*60 | +56.565 | +56.637 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170.7 | p491 | 0.024017 | 0.0102392 | 0.000064 | 0.0000813515 | 0.0000813515
4 x Plate | FL8*50 | +57.410 | +57.474 | 2 | 99 | 0.7 | 0 | 38.4 | 0 | 50 | 8 | 180.4 | p497 | 0.0216869 | 0.00901746 | 0.000064 | 0.0000720236 | 0.0000720236
3 x Plate | FL8*80 | +58.276 | +58.289 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 145 | p485 | 0.0267968 | 0.0115986 | 0.000064 | 0.0000927885 | 0.0000927885
2 x Plate | FL8*80 | +58.279 | +58.291 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 140 | p499 | 0.0259178 | 0.011199 | 0.000064 | 0.0000895921 | 0.0000895921
3 x Plate | FL8*80 | +58.248 | +58.261 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 140 | p492 | 0.0259178 | 0.011199 | 0.000064 | 0.0000895921 | 0.0000895921
3 x Plate | FL8*80 | +58.245 | +58.258 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 145 | p485 | 0.0267968 | 0.0115986 | 0.000064 | 0.0000927885 | 0.0000927885
6 x Plate | FL8*80 | +56.767 | +56.858 | 2 | 99 | 0.9 | 0 | 36.5 | 0 | 80 | 8 | 171.3 | p493 | 0.031197 | 0.0136989 | 0.000064 | 0.000108788 | 0.000108788
6 x Plate | FL8*60 | +56.639 | +56.711 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170.7 | p491 | 0.0241065 | 0.0102471 | 0.000064 | 0.0000816932 | 0.0000816932
6 x Plate | FL8*60 | +57.545 | +57.625 | 2 | 99 | 1.1 | 0 | 36.9 | 0 | 60 | 8 | 301 | p430 | 0.0417783 | 0.0180581 | 0.000064 | 0.000144063 | 0.000144063
4 x Plate | FL8*50 | +57.485 | +57.548 | 2 | 99 | 0.7 | 0 | 38.4 | 0 | 50 | 8 | 180.6 | p497 | 0.0216905 | 0.00903096 | 0.000064 | 0.000072036 | 0.000072036
3 x Plate | FL8*80 | +58.214 | +58.228 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 140 | p492 | 0.0259184 | 0.0111993 | 0.000064 | 0.0000895942 | 0.0000895942
3 x Plate | FL8*80 | +58.211 | +58.225 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 145 | p485 | 0.0267977 | 0.011599 | 0.000064 | 0.0000927916 | 0.0000927916
2 x Plate | FL8*80 | +58.176 | +58.190 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 140 | p492 | 0.0259184 | 0.0111993 | 0.000064 | 0.0000895942 | 0.0000895942
3 x Plate | FL8*80 | +58.172 | +58.186 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 145 | p485 | 0.0267964 | 0.011599 | 0.000064 | 0.000092787 | 0.000092787
3 x Plate | FL8*80 | +58.135 | +58.149 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 140 | p492 | 0.0259184 | 0.0111993 | 0.000064 | 0.0000895942 | 0.0000895942
3 x Plate | FL8*80 | +58.131 | +58.146 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 145 | p485 | 0.0267982 | 0.0115992 | 0.000064 | 0.0000927936 | 0.0000927936
3 x Plate | FL8*50 | +58.091 | +58.102 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
3 x Plate | FL8*80 | +58.088 | +58.106 | 2 | 99 | 1.1 | 0 | 36.2 | 0 | 80 | 8 | 220 | p431 | 0.0399976 | 0.0175989 | 0.000064 | 0.000140791 | 0.000140791
2 x Plate | FL8*80 | +58.043 | +58.059 | 2 | 99 | 0.7 | 0 | 36.7 | 0 | 80 | 8 | 150 | p494 | 0.0276786 | 0.0119993 | 0.000064 | 0.0000959947 | 0.0000959947
3 x Plate | FL8*80 | +58.040 | +58.055 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 140 | p492 | 0.0259192 | 0.0111996 | 0.000064 | 0.0000895972 | 0.0000895972
Plate | FL8*80 | +57.992 | +58.008 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 140 | p500 | 0.0259192 | 0.0111996 | 0.000064 | 0.0000895972 | 0.0000895972
3 x Plate | FL8*110 | +57.988 | +58.003 | 2 | 99 | 0.9 | 0 | 36 | 0 | 110 | 8 | 140 | p495 | 0.034799 | 0.0153995 | 0.000064 | 0.000123196 | 0.000123196
3 x Plate | FL8*80 | +57.938 | +57.954 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 140.3 | p492 | 0.0259789 | 0.0112268 | 0.000064 | 0.0000898141 | 0.0000898141
3 x Plate | FL8*80 | +57.934 | +57.950 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 140.3 | p492 | 0.0259789 | 0.0112268 | 0.000064 | 0.0000898141 | 0.0000898141
3 x Plate | FL8*80 | +57.875 | +57.892 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 140.3 | p492 | 0.0259789 | 0.0112268 | 0.000064 | 0.0000898141 | 0.0000898141
3 x Plate | FL8*80 | +57.880 | +57.896 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 140.3 | p492 | 0.0259789 | 0.0112268 | 0.000064 | 0.0000898141 | 0.0000898141
3 x Plate | FL8*80 | +57.819 | +57.836 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 140.3 | p492 | 0.0259776 | 0.0112262 | 0.000064 | 0.0000898094 | 0.0000898094
3 x Plate | FL8*80 | +57.814 | +57.831 | 2 | 99 | 0.7 | 0 | 36.9 | 0 | 80 | 8 | 135.3 | p496 | 0.0250977 | 0.0108262 | 0.000064 | 0.0000866099 | 0.0000866099
6 x Plate | FL8*50 | +57.969 | +58.023 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 71.9 | p545 | 0.00894133 | 0.00359385 | 0.000064 | 0.0000280713 | 0.0000280713
6 x Plate | PLT8*50.1 | +58.185 | +58.238 | 2 | 99 | 0.3 | 0 | 39.8 | 0 | 50.1 | 8 | 90.2 | p519 | 0.0112685 | 0.00451823 | 0.000064 | 0.0000361031 | 0.0000361031
6 x Plate | FL8*60 | +58.144 | +58.212 | 2 | 99 | 1.1 | 0 | 36.9 | 0 | 60 | 8 | 308.3 | p429 | 0.0423924 | 0.0184723 | 0.000064 | 0.000146206 | 0.000146206
6 x Plate | FL8*50 | +58.123 | +58.179 | 2 | 99 | 0.7 | 0 | 38.4 | 0 | 50 | 8 | 182.6 | p497 | 0.0216578 | 0.00911609 | 0.000064 | 0.0000719104 | 0.0000719104
6 x Plate | FL8*50 | +58.088 | +58.145 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 187.3 | p456 | 0.0222371 | 0.00935515 | 0.000064 | 0.0000739099 | 0.0000739099
6 x Plate | FL8*50 | +58.050 | +58.107 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 187.1 | p456 | 0.0222371 | 0.00934756 | 0.000064 | 0.0000739113 | 0.0000739113
6 x Plate | FL8*50 | +58.009 | +58.067 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 187 | p456 | 0.0222371 | 0.00933994 | 0.000064 | 0.0000739126 | 0.0000739126
6 x Plate | FL8*50 | +57.922 | +57.981 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 186.6 | p456 | 0.0222371 | 0.00932465 | 0.000064 | 0.000073915 | 0.000073915
6 x Plate | FL8*50 | +57.871 | +57.930 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 186.4 | p456 | 0.0222371 | 0.00931698 | 0.000064 | 0.000073916 | 0.000073916
6 x Plate | FL8*50 | +57.816 | +57.877 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 186.2 | p456 | 0.022237 | 0.00930467 | 0.000064 | 0.0000739174 | 0.0000739174
6 x Plate | FL8*50 | +57.759 | +57.819 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 186.2 | p456 | 0.022237 | 0.00930467 | 0.000064 | 0.0000739174 | 0.0000739174
6 x Plate | FL8*60 | +57.679 | +57.758 | 2 | 99 | 1.1 | 0 | 36.9 | 0 | 60 | 8 | 301.1 | p428 | 0.0417383 | 0.0180613 | 0.000064 | 0.00014392 | 0.00014392
6 x Plate | FL8*50 | +57.638 | +57.694 | 2 | 99 | 0.3 | 0 | 39.8 | 0 | 50 | 8 | 90.9 | p519 | 0.0112367 | 0.00454521 | 0.000064 | 0.0000359878 | 0.0000359878
6 x Plate | PLT8*85 | +56.783 | +56.880 | 2 | 99 | 0.9 | 0 | 36.2 | 0 | 85 | 8 | 191.6 | p489 | 0.0366947 | 0.0162816 | 0.000064 | 0.000129179 | 0.000129179
6 x Plate | FL8*80 | +57.325 | +57.410 | 2 | 99 | 0.9 | 0 | 36.5 | 0 | 80 | 8 | 175.4 | p490 | 0.0320449 | 0.0140177 | 0.000064 | 0.000111866 | 0.000111866
6 x Plate | FL8*50 | +57.302 | +57.353 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 73.1 | p545 | 0.0089438 | 0.00365131 | 0.000064 | 0.0000280758 | 0.0000280758
6 x Plate | FL8*50 | +56.843 | +56.897 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 71.1 | p545 | 0.00891307 | 0.00355408 | 0.000064 | 0.0000279751 | 0.0000279751
6 x Plate | FL8*60 | +56.899 | +56.969 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 171.3 | p459 | 0.0240752 | 0.0102795 | 0.000064 | 0.0000815807 | 0.0000815807
6 x Plate | FL8*60 | +56.957 | +57.026 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 171.7 | p459 | 0.0240727 | 0.0102962 | 0.000064 | 0.0000815705 | 0.0000815705
6 x Plate | FL8*60 | +57.011 | +57.080 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 171.7 | p459 | 0.0240701 | 0.010304 | 0.000064 | 0.0000815606 | 0.0000815606
6 x Plate | FL8*60 | +57.062 | +57.130 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 172 | p459 | 0.0240689 | 0.0103145 | 0.000064 | 0.0000815553 | 0.0000815553
6 x Plate | FL8*60 | +57.110 | +57.183 | 2 | 99 | 0.9 | 0 | 37 | 0 | 60 | 8 | 274.1 | p427 | 0.0379317 | 0.0164367 | 0.000064 | 0.000130479 | 0.000130479
3 x Plate | FL8*150 | +55.852 | +55.873 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
4 x Plate | FL8*60 | +57.159 | +57.226 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 172.4 | p491 | 0.0240625 | 0.0103405 | 0.000064 | 0.00008153 | 0.00008153
6 x Plate | FL8*60 | +57.200 | +57.267 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 172.7 | p491 | 0.0240613 | 0.0103466 | 0.000064 | 0.0000815248 | 0.0000815248
6 x Plate | FL8*60 | +57.238 | +57.303 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 173 | p487 | 0.0240549 | 0.0103658 | 0.000064 | 0.0000814995 | 0.0000814995
6 x Plate | FL8*60 | +57.271 | +57.336 | 2 | 99 | 0.7 | 0 | 37.7 | 0 | 60 | 8 | 163 | p488 | 0.0226964 | 0.00976657 | 0.000064 | 0.0000767054 | 0.0000767054
6 x Plate | PLT10*202.5 | +51.206 | +51.433 | 6 | 99 | 2.7 | 0 | 28.2 | 0.1 | 202.5 | 10 | 269.5 | p83 | 0.0773581 | 0.0545727 | 0.0001 | 0.000348814 | 0.000348814
3 x Plate | FL8*80 | +52.623 | +52.644 | 2 | 99 | 0.7 | 0 | 36.7 | 0 | 80 | 8 | 150 | p467 | 0.0276819 | 0.0120008 | 0.000064 | 0.0000960067 | 0.0000960067
6 x Plate | FL8*50 | +56.686 | +56.743 | 2 | 99 | 0.3 | 0 | 39.8 | 0 | 50 | 8 | 90 | p519 | 0.0112444 | 0.00450189 | 0.000064 | 0.0000360151 | 0.0000360151
6 x Plate | FL8*50 | +56.675 | +56.733 | 2 | 99 | 0.3 | 0 | 39.8 | 0 | 50 | 8 | 90 | p519 | 0.011245 | 0.00450216 | 0.000064 | 0.0000360173 | 0.0000360173
6 x Plate | FL8*50 | +55.694 | +55.751 | 2 | 99 | 0.3 | 0 | 39.8 | 0 | 50 | 8 | 90 | p519 | 0.011245 | 0.00450215 | 0.000064 | 0.0000360172 | 0.0000360172
6 x Plate | FL8*50 | +55.683 | +55.740 | 2 | 99 | 0.3 | 0 | 39.8 | 0 | 50 | 8 | 90 | p519 | 0.011245 | 0.00450216 | 0.000064 | 0.0000360173 | 0.0000360173
6 x Plate | FL8*50 | +54.702 | +54.759 | 2 | 99 | 0.3 | 0 | 39.8 | 0 | 50 | 8 | 90 | p519 | 0.0112446 | 0.004502 | 0.000064 | 0.0000360159 | 0.0000360159
6 x Plate | FL8*50 | +54.691 | +54.748 | 2 | 99 | 0.3 | 0 | 39.8 | 0 | 50 | 8 | 90 | p519 | 0.0112444 | 0.00450192 | 0.000064 | 0.0000360151 | 0.0000360151
6 x Plate | FL8*50 | +53.709 | +53.767 | 2 | 99 | 0.3 | 0 | 39.8 | 0 | 50 | 8 | 90.2 | p519 | 0.0112399 | 0.00450688 | 0.000064 | 0.0000359996 | 0.0000359996
6 x Plate | FL8*50 | +53.699 | +53.756 | 2 | 99 | 0.3 | 0 | 39.8 | 0 | 50 | 8 | 90 | p519 | 0.0112444 | 0.00450193 | 0.000064 | 0.0000360151 | 0.0000360151
6 x Plate | FL8*50 | +52.717 | +52.775 | 2 | 99 | 0.3 | 0 | 39.7 | 0 | 50 | 8 | 92 | p519 | 0.0114662 | 0.00459752 | 0.000064 | 0.0000367801 | 0.0000367801
6 x Plate | FL10*100 | +56.964 | +56.977 | 2 | 99 | 1.2 | 0 | 29.6 | 0 | 100 | 10 | 160 | p49 | 0.0372029 | 0.0160014 | 0.0001 | 0.000160014 | 0.000160014
6 x Plate | FL10*100 | +56.476 | +56.492 | 2 | 99 | 1.2 | 0 | 29.6 | 0 | 100 | 10 | 160 | p49 | 0.0372 | 0.016 | 0.0001 | 0.00016 | 0.00016
6 x Plate | PLT8*85 | +55.834 | +55.932 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 170 | p453 | 0.03298 | 0.0144501 | 0.000064 | 0.0001156 | 0.0001156
6 x Plate | FL8*70 | +52.276 | +52.364 | 2 | 99 | 0.9 | 0 | 36.6 | 0 | 70 | 8 | 220 | p300 | 0.03544 | 0.03544 | 0.00056 | 0.0001232 | 0.0001232
6 x Plate | FL8*70 | +52.194 | +52.281 | 2 | 99 | 0.9 | 0 | 36.6 | 0 | 70 | 8 | 220 | p300 | 0.03544 | 0.03544 | 0.00056 | 0.0001232 | 0.0001232
6 x Plate | FL10*100 | +50.956 | +50.974 | 6 | 99 | 1.4 | 0 | 29.5 | 0 | 100 | 10 | 180 | p264 | 0.0416 | 0.018 | 0.0001 | 0.00018 | 0.00018
6 x Plate | FL10*100 | +50.966 | +50.984 | 2 | 99 | 1.2 | 0 | 29.6 | 0 | 100 | 10 | 160 | p49 | 0.0372 | 0.016 | 0.0001 | 0.00016 | 0.00016
6 x Plate | FL10*100 | +52.547 | +52.565 | 2 | 99 | 1.2 | 0 | 29.6 | 0 | 100 | 10 | 160 | p49 | 0.0372 | 0.016 | 0.0001 | 0.00016 | 0.00016
6 x Plate | FL10*100 | +52.537 | +52.555 | 2 | 99 | 1.2 | 0 | 29.6 | 0 | 100 | 10 | 160 | p49 | 0.0372 | 0.016 | 0.0001 | 0.00016 | 0.00016
Plate | FL8*60 | +52.252 | +52.267 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90 | p520 | 0.0131879 | 0.00539465 | 0.000064 | 0.0000431572 | 0.0000431572
3 x Plate | FL8*150 | +51.588 | +51.609 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p461 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
2 x Plate | PLT8*190 | +51.498 | +51.527 | 2 | 99 | 3 | 0 | 34.2 | 0.1 | 190 | 8 | 250 | p462 | 0.10204 | 0.0475 | 0.000064 | 0.00038 | 0.00038
3 x Plate | FL8*150 | +51.416 | +51.437 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p461 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
Plate | FL8*150 | +52.252 | +52.272 | 2 | 99 | 1.2 | 0 | 35.3 | 0 | 135 | 8 | 135 | p463 | 0.0450579 | 0.018225 | 0.000064 | 0.000161992 | 0.000161992
2 x Plate | PLT8*140 | +52.824 | +52.843 | 2 | 99 | 1.2 | 0 | 35.5 | 0 | 140 | 8 | 140 | p464 | 0.0437054 | 0.019612 | 0.000064 | 0.000156896 | 0.000156896
3 x Plate | FL8*60 | +52.828 | +52.843 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90.2 | p520 | 0.0131997 | 0.00540988 | 0.000064 | 0.000043199 | 0.000043199
6 x Plate | FL10*100 | +51.544 | +51.562 | 2 | 99 | 1.2 | 0 | 29.6 | 0 | 100 | 10 | 160 | p49 | 0.0372 | 0.016 | 0.0001 | 0.00016 | 0.00016
3 x Plate | FL8*130 | +51.224 | +51.243 | 2 | 99 | 2.4 | 0 | 34.6 | 0.1 | 130 | 8 | 305 | p524 | 0.08626 | 0.03965 | 0.000064 | 0.0003172 | 0.0003172
3 x Plate | FL8*110 | +52.765 | +52.784 | 2 | 99 | 0.9 | 0 | 36.1 | 0 | 110 | 8 | 130 | p465 | 0.0324425 | 0.0143012 | 0.000064 | 0.000114409 | 0.000114409
3 x Plate | FL8*130 | +52.706 | +52.724 | 2 | 99 | 0.9 | 0 | 35.9 | 0 | 120 | 8 | 120 | p466 | 0.0352027 | 0.0144 | 0.000064 | 0.00012481 | 0.00012481
6 x Plate | FL8*60 | +51.557 | +51.639 | 2 | 99 | 0.9 | 0 | 37 | 0 | 60 | 8 | 270 | p417 | 0.03768 | 0.0162 | 0.000064 | 0.0001296 | 0.0001296
6 x Plate | FL8*50 | +52.706 | +52.764 | 2 | 99 | 0.3 | 0 | 39.8 | 0 | 50 | 8 | 90 | p522 | 0.0112401 | 0.00450004 | 0.000064 | 0.0000360003 | 0.0000360003
6 x Plate | FL8*50 | +52.337 | +52.402 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185 | p456 | 0.02226 | 0.00925 | 0.000064 | 0.000074 | 0.000074
6 x Plate | FL8*50 | +51.341 | +51.397 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | PLT8*105 | +51.278 | +51.396 | 2 | 99 | 1.1 | 0 | 35.9 | 0 | 105 | 8 | 164.9 | p457 | 0.0389705 | 0.0173255 | 0.000064 | 0.000138602 | 0.000138602
6 x Plate | FL8*50 | +52.255 | +52.320 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185 | p456 | 0.02226 | 0.00925 | 0.000064 | 0.000074 | 0.000074
6 x Plate | PLT8*75 | +52.162 | +52.258 | 2 | 99 | 1.2 | 0 | 36.2 | 0 | 75 | 8 | 265 | p426 | 0.04519 | 0.019875 | 0.000064 | 0.000159 | 0.000159
6 x Plate | PLT8*85 | +51.393 | +51.491 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 160 | p458 | 0.03112 | 0.0136 | 0.000064 | 0.0001088 | 0.0001088
6 x Plate | FL8*60 | +51.475 | +51.548 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*50 | +52.492 | +52.557 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185 | p456 | 0.02226 | 0.00925 | 0.000064 | 0.000074 | 0.000074
6 x Plate | FL8*50 | +52.130 | +52.187 | 2 | 99 | 0.3 | 0 | 39.8 | 0 | 50 | 8 | 90 | p519 | 0.0112397 | 0.00449989 | 0.000064 | 0.000035999 | 0.000035999
6 x Plate | FL8*50 | +51.789 | +51.845 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | FL8*50 | +52.419 | +52.475 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | PLT8*120 | +51.845 | +51.978 | 2 | 99 | 1.2 | 0 | 35.6 | 0 | 120 | 8 | 155 | p469 | 0.0416003 | 0.0186004 | 0.000064 | 0.000148801 | 0.000148801
6 x Plate | FL8*50 | +52.575 | +52.640 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185 | p456 | 0.02226 | 0.00925 | 0.000064 | 0.000074 | 0.000074
6 x Plate | PLT8*75 | +52.611 | +52.707 | 2 | 99 | 1.2 | 0 | 36.2 | 0 | 75 | 8 | 260 | p424 | 0.04436 | 0.0195 | 0.000064 | 0.000156 | 0.000156
6 x Plate | PLT8*85 | +51.730 | +51.828 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 160 | p458 | 0.03112 | 0.0136 | 0.000064 | 0.0001088 | 0.0001088
6 x Plate | FL8*60 | +51.648 | +51.722 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
3 x Plate | PLT8*155 | +51.580 | +51.602 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 155 | 8 | 160 | p470 | 0.05464 | 0.0248 | 0.000064 | 0.0001984 | 0.0001984
3 x Plate | FL8*150 | +51.665 | +51.686 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p525 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
2 x Plate | PLT8*160 | +51.722 | +51.743 | 2 | 99 | 2 | 0 | 34.8 | 0.1 | 160 | 8 | 190 | p471 | 0.0664 | 0.0304 | 0.000064 | 0.0002432 | 0.0002432
2 x Plate | FL8*130 | +51.672 | +51.691 | 2 | 99 | 2 | 0 | 34.8 | 0.1 | 130 | 8 | 245 | p526 | 0.0697 | 0.03185 | 0.000064 | 0.0002548 | 0.0002548
3 x Plate | PLT8*160 | +51.730 | +51.751 | 2 | 99 | 1.7 | 0 | 34.8 | 0.1 | 160 | 8 | 180 | p460 | 0.06304 | 0.0288 | 0.000064 | 0.0002304 | 0.0002304
2 x Plate | FL8*150 | +51.423 | +51.444 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*130 | +51.343 | +51.361 | 2 | 99 | 1.7 | 0 | 35 | 0.1 | 130 | 8 | 220 | p527 | 0.0628 | 0.0286 | 0.000064 | 0.0002288 | 0.0002288
3 x Plate | FL8*150 | +51.281 | +51.302 | 2 | 99 | 1.7 | 0 | 34.8 | 0.1 | 150 | 8 | 190 | p472 | 0.06244 | 0.0285 | 0.000064 | 0.000228 | 0.000228
3 x Plate | PLT8*135 | +51.337 | +51.356 | 2 | 99 | 1.2 | 0 | 35.6 | 0 | 135 | 8 | 140 | p528 | 0.0422 | 0.0189 | 0.000064 | 0.0001512 | 0.0001512
3 x Plate | FL8*80 | +52.452 | +52.472 | 2 | 99 | 0.7 | 0 | 36.7 | 0 | 80 | 8 | 150 | p467 | 0.0276819 | 0.0120008 | 0.000064 | 0.0000960067 | 0.0000960067
3 x Plate | FL8*130 | +52.371 | +52.390 | 2 | 99 | 0.9 | 0 | 35.9 | 0 | 120 | 8 | 120 | p455 | 0.0352208 | 0.0144 | 0.000064 | 0.000124878 | 0.000124878
3 x Plate | FL8*80 | +52.459 | +52.479 | 2 | 99 | 0.7 | 0 | 36.7 | 0 | 80 | 8 | 150 | p467 | 0.02768 | 0.012 | 0.000064 | 0.000096 | 0.000096
3 x Plate | FL8*80 | +52.376 | +52.397 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | PLT8*120 | +52.317 | +52.335 | 2 | 99 | 0.9 | 0 | 35.9 | 0 | 120 | 8 | 129.7 | p455 | 0.0351608 | 0.0155816 | 0.000064 | 0.000124653 | 0.000124653
6 x Plate | PLT6*67 | +52.492 | +52.656 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
6 x Plate | PLT6*67 | +52.204 | +52.368 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
3 x Plate | PLT8*160 | +51.274 | +51.295 | 2 | 99 | 1.7 | 0 | 34.8 | 0.1 | 160 | 8 | 180 | p460 | 0.06304 | 0.0288 | 0.000064 | 0.0002304 | 0.0002304
3 x Plate | FL8*50 | +52.541 | +52.555 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
3 x Plate | FL8*80 | +52.617 | +52.637 | 2 | 99 | 0.7 | 0 | 36.7 | 0 | 80 | 8 | 150 | p467 | 0.02768 | 0.012 | 0.000064 | 0.000096 | 0.000096
3 x Plate | FL8*80 | +52.698 | +52.720 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | PLT8*120 | +52.760 | +52.779 | 2 | 99 | 0.9 | 0 | 35.9 | 0 | 120 | 8 | 129.7 | p455 | 0.0351608 | 0.0155816 | 0.000064 | 0.000124653 | 0.000124653
3 x Plate | FL8*110 | +52.311 | +52.330 | 2 | 99 | 0.9 | 0 | 36.1 | 0 | 110 | 8 | 130 | p468 | 0.0324425 | 0.0143012 | 0.000064 | 0.000114409 | 0.000114409
3 x Plate | FL8*80 | +52.534 | +52.561 | 2 | 99 | 1.2 | 0 | 36.1 | 0 | 80 | 8 | 230 | p425 | 0.0417635 | 0.0184016 | 0.000064 | 0.000147213 | 0.000147213
6 x Plate | FL10*100 | +55.525 | +55.543 | 2 | 99 | 1.2 | 0 | 29.6 | 0 | 100 | 10 | 160 | p49 | 0.0372 | 0.016 | 0.0001 | 0.00016 | 0.00016
6 x Plate | FL10*100 | +55.515 | +55.533 | 2 | 99 | 1.2 | 0 | 29.6 | 0 | 100 | 10 | 160 | p49 | 0.0372 | 0.016 | 0.0001 | 0.00016 | 0.00016
6 x Plate | FL10*100 | +54.532 | +54.550 | 2 | 99 | 1.2 | 0 | 29.6 | 0 | 100 | 10 | 160 | p49 | 0.0372 | 0.016 | 0.0001 | 0.00016 | 0.00016
6 x Plate | FL10*100 | +54.522 | +54.540 | 2 | 99 | 1.2 | 0 | 29.6 | 0 | 100 | 10 | 160 | p49 | 0.0372 | 0.016 | 0.0001 | 0.00016 | 0.00016
6 x Plate | FL10*100 | +53.540 | +53.558 | 2 | 99 | 1.2 | 0 | 29.6 | 0 | 100 | 10 | 160 | p49 | 0.0372 | 0.016 | 0.0001 | 0.00016 | 0.00016
6 x Plate | FL10*100 | +53.530 | +53.548 | 2 | 99 | 1.2 | 0 | 29.6 | 0 | 100 | 10 | 160 | p49 | 0.0372 | 0.016 | 0.0001 | 0.00016 | 0.00016
6 x Plate | FL10*100 | +51.554 | +51.572 | 2 | 99 | 1.2 | 0 | 29.6 | 0 | 100 | 10 | 160 | p49 | 0.0372 | 0.016 | 0.0001 | 0.00016 | 0.00016
3 x Plate | FL8*130 | +51.782 | +51.801 | 2 | 99 | 2.4 | 0 | 34.7 | 0.1 | 130 | 8 | 300 | p531 | 0.08488 | 0.039 | 0.000064 | 0.000312 | 0.000312
Plate | PLT6*67 | +57.708 | +57.872 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244704 | 0.0109846 | 0.000036 | 0.0000653078 | 0.0000653078
6 x Plate | PLT6*67 | +56.792 | +56.956 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
6 x Plate | PLT6*67 | +57.163 | +57.327 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
6 x Plate | FL8*50 | +56.931 | +56.996 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925324 | 0.000064 | 0.0000740259 | 0.0000740259
6 x Plate | FL8*50 | +56.848 | +56.913 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925322 | 0.000064 | 0.0000740258 | 0.0000740258
6 x Plate | FL8*60 | +56.746 | +56.831 | 2 | 99 | 1.2 | 0 | 36.9 | 0 | 60 | 8 | 310.1 | p422 | 0.0431384 | 0.0186081 | 0.000064 | 0.000148865 | 0.000148865
6 x Plate | FL8*60 | +56.069 | +56.143 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +55.986 | +56.060 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
3 x Plate | FL8*150 | +56.339 | +56.360 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
6 x Plate | FL8*60 | +56.316 | +56.398 | 2 | 99 | 0.9 | 0 | 37 | 0 | 60 | 8 | 270 | p417 | 0.03768 | 0.0162 | 0.000064 | 0.0001296 | 0.0001296
6 x Plate | FL8*60 | +56.233 | +56.307 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +56.151 | +56.225 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*50 | +57.251 | +57.316 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925325 | 0.000064 | 0.000074026 | 0.000074026
6 x Plate | FL8*50 | +57.096 | +57.161 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222676 | 0.00925326 | 0.000064 | 0.0000740261 | 0.0000740261
6 x Plate | FL8*50 | +57.178 | +57.233 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | FL8*50 | +57.013 | +57.078 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925327 | 0.000064 | 0.000074026 | 0.000074026
3 x Plate | FL8*130 | +55.929 | +55.950 | 2 | 99 | 1.2 | 0 | 35.3 | 0 | 130 | 8 | 160 | p529 | 0.04624 | 0.0208 | 0.000064 | 0.0001664 | 0.0001664
3 x Plate | FL8*130 | +55.937 | +55.955 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p530 | 0.05452 | 0.0247 | 0.000064 | 0.0001976 | 0.0001976
Plate | FL8*60 | +56.808 | +56.823 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90 | p520 | 0.0132 | 0.00539999 | 0.000064 | 0.0000432 | 0.0000432
3 x Plate | PLT8*155 | +55.845 | +55.866 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 155 | 8 | 160 | p473 | 0.05464 | 0.0248 | 0.000064 | 0.0001984 | 0.0001984
2 x Plate | FL8*150 | +56.010 | +56.031 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
2 x Plate | FL8*80 | +56.970 | +56.991 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p474 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +56.880 | +56.901 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p474 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +56.887 | +56.908 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +56.962 | +56.984 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +57.382 | +57.404 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | FL8*80 | +57.292 | +57.321 | 2 | 99 | 1.2 | 0 | 36.1 | 0 | 80 | 8 | 250 | p418 | 0.04528 | 0.02 | 0.000064 | 0.00016 | 0.00016
3 x Plate | FL8*80 | +57.210 | +57.231 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +57.128 | +57.149 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +57.045 | +57.066 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
2 x Plate | FL8*150 | +56.182 | +56.203 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +56.017 | +56.038 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*130 | +56.102 | +56.120 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p530 | 0.0545267 | 0.0247032 | 0.000064 | 0.000197625 | 0.000197625
3 x Plate | FL8*150 | +56.347 | +56.368 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +56.174 | +56.196 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*130 | +56.094 | +56.115 | 2 | 99 | 1.2 | 0 | 35.3 | 0 | 130 | 8 | 160 | p529 | 0.0462407 | 0.0208003 | 0.000064 | 0.000166402 | 0.000166402
3 x Plate | PLT8*190 | +56.257 | +56.285 | 2 | 99 | 3 | 0 | 34.2 | 0.1 | 190 | 8 | 249.7 | p462 | 0.101966 | 0.0474646 | 0.000064 | 0.000379717 | 0.000379717
3 x Plate | FL8*80 | +57.052 | +57.074 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p474 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +57.135 | +57.156 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p474 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +57.217 | +57.239 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p474 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
2 x Plate | FL8*80 | +57.375 | +57.396 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*50 | +57.300 | +57.314 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | PLT8*85 | +54.842 | +54.940 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 170 | p453 | 0.0329805 | 0.0144504 | 0.000064 | 0.000115602 | 0.000115602
6 x Plate | PLT8*95 | +55.812 | +55.922 | 2 | 99 | 1.1 | 0 | 35.9 | 0 | 95 | 8 | 180 | p476 | 0.0386003 | 0.0171002 | 0.000064 | 0.000136801 | 0.000136801
6 x Plate | FL8*50 | +55.939 | +56.004 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925324 | 0.000064 | 0.0000740259 | 0.0000740259
6 x Plate | FL8*50 | +55.856 | +55.921 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925322 | 0.000064 | 0.0000740258 | 0.0000740258
6 x Plate | FL8*60 | +55.754 | +55.839 | 2 | 99 | 1.1 | 0 | 36.9 | 0 | 60 | 8 | 305.1 | p420 | 0.0424584 | 0.0183081 | 0.000064 | 0.000146465 | 0.000146465
6 x Plate | FL8*60 | +56.578 | +56.663 | 2 | 99 | 1.1 | 0 | 36.9 | 0 | 60 | 8 | 305.1 | p420 | 0.0424588 | 0.0183083 | 0.000064 | 0.000146466 | 0.000146466
6 x Plate | FL8*50 | +56.506 | +56.571 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222676 | 0.00925328 | 0.000064 | 0.0000740262 | 0.0000740262
6 x Plate | FL8*50 | +56.424 | +56.489 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222676 | 0.00925326 | 0.000064 | 0.0000740261 | 0.0000740261
6 x Plate | FL8*60 | +55.661 | +55.735 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +55.579 | +55.653 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +55.076 | +55.150 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +54.994 | +55.068 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*50 | +54.920 | +54.975 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | FL8*60 | +55.497 | +55.570 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +55.414 | +55.488 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +55.324 | +55.406 | 2 | 99 | 0.9 | 0 | 37 | 0 | 60 | 8 | 270 | p417 | 0.03768 | 0.0162 | 0.000064 | 0.0001296 | 0.0001296
6 x Plate | FL8*60 | +55.241 | +55.315 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +55.159 | +55.233 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*50 | +56.341 | +56.406 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925325 | 0.000064 | 0.000074026 | 0.000074026
6 x Plate | FL8*50 | +56.259 | +56.324 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925325 | 0.000064 | 0.000074026 | 0.000074026
6 x Plate | FL8*50 | +56.103 | +56.169 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222676 | 0.00925326 | 0.000064 | 0.0000740261 | 0.0000740261
6 x Plate | FL8*50 | +56.186 | +56.241 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | FL8*50 | +56.021 | +56.086 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925325 | 0.000064 | 0.000074026 | 0.000074026
6 x Plate | PLT6*67 | +55.800 | +55.964 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
6 x Plate | PLT6*67 | +56.501 | +56.665 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
6 x Plate | PLT6*67 | +56.171 | +56.335 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
3 x Plate | FL8*150 | +54.937 | +54.958 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p525 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | PLT8*160 | +55.603 | +55.625 | 2 | 99 | 2 | 0 | 34.8 | 0.1 | 160 | 8 | 190 | p533 | 0.0664 | 0.0304 | 0.000064 | 0.0002432 | 0.0002432
3 x Plate | FL8*130 | +55.594 | +55.617 | 2 | 99 | 1.4 | 0 | 35.2 | 0.1 | 130 | 8 | 180 | p534 | 0.05176 | 0.0234 | 0.000064 | 0.0001872 | 0.0001872
3 x Plate | FL8*130 | +54.944 | +54.963 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p530 | 0.05452 | 0.0247 | 0.000064 | 0.0001976 | 0.0001976
3 x Plate | FL8*60 | +56.797 | +56.812 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90 | p520 | 0.0132002 | 0.0054001 | 0.000064 | 0.0000432008 | 0.0000432008
3 x Plate | FL8*110 | +56.790 | +56.812 | 2 | 99 | 1.2 | 0 | 35.7 | 0 | 110 | 8 | 171.1 | p451 | 0.0421507 | 0.0188262 | 0.000064 | 0.000150609 | 0.000150609
Plate | FL8*60 | +55.815 | +55.831 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90 | p520 | 0.0132 | 0.00539999 | 0.000064 | 0.0000431999 | 0.0000431999
3 x Plate | FL8*150 | +54.860 | +54.881 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | PLT8*155 | +54.852 | +54.874 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 155 | 8 | 160 | p473 | 0.05464 | 0.0248 | 0.000064 | 0.0001984 | 0.0001984
3 x Plate | PLT8*153 | +55.684 | +55.705 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 153 | 8 | 160 | p480 | 0.053968 | 0.02448 | 0.000064 | 0.00019584 | 0.00019584
3 x Plate | FL8*150 | +55.676 | +55.698 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +55.017 | +55.038 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*80 | +55.978 | +55.999 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +56.719 | +56.740 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p474 | 0.0294129 | 0.0127877 | 0.000064 | 0.000102301 | 0.000102301
3 x Plate | FL8*80 | +56.712 | +56.733 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294545 | 0.0128066 | 0.000064 | 0.000102453 | 0.000102453
3 x Plate | FL8*80 | +56.637 | +56.658 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294129 | 0.0127877 | 0.000064 | 0.000102301 | 0.000102301
3 x Plate | FL8*80 | +56.629 | +56.651 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*80 | +56.554 | +56.576 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | FL8*80 | +55.888 | +55.909 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p474 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +55.895 | +55.917 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +55.970 | +55.992 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +56.472 | +56.493 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | FL8*80 | +56.390 | +56.411 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.029413 | 0.0127877 | 0.000064 | 0.000102302 | 0.000102302
3 x Plate | FL8*80 | +56.300 | +56.328 | 2 | 99 | 1.2 | 0 | 36.1 | 0 | 80 | 8 | 250 | p418 | 0.04528 | 0.02 | 0.000064 | 0.00016 | 0.00016
3 x Plate | FL8*80 | +56.217 | +56.239 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +56.135 | +56.156 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*80 | +56.053 | +56.074 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160 | p454 | 0.0294389 | 0.0127995 | 0.000064 | 0.000102396 | 0.000102396
3 x Plate | FL8*150 | +55.189 | +55.211 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +55.025 | +55.046 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | PLT8*170 | +55.429 | +55.453 | 2 | 99 | 2 | 0 | 34.7 | 0.1 | 170 | 8 | 190 | p537 | 0.07036 | 0.0323 | 0.000064 | 0.0002584 | 0.0002584
3 x Plate | FL8*150 | +55.512 | +55.533 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +55.347 | +55.368 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*130 | +55.109 | +55.128 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p530 | 0.0545267 | 0.0247032 | 0.000064 | 0.000197625 | 0.000197625
3 x Plate | FL8*150 | +55.354 | +55.376 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +55.182 | +55.203 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*150 | +55.519 | +55.540 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*130 | +55.439 | +55.457 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p538 | 0.05452 | 0.0247 | 0.000064 | 0.0001976 | 0.0001976
3 x Plate | FL8*130 | +55.102 | +55.123 | 2 | 99 | 1.2 | 0 | 35.3 | 0 | 130 | 8 | 160 | p529 | 0.0462407 | 0.0208003 | 0.000064 | 0.000166402 | 0.000166402
3 x Plate | PLT8*190 | +55.265 | +55.293 | 2 | 99 | 3 | 0 | 34.2 | 0.1 | 190 | 8 | 249.7 | p462 | 0.101966 | 0.0474646 | 0.000064 | 0.000379717 | 0.000379717
3 x Plate | FL8*80 | +56.060 | +56.081 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +56.142 | +56.164 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
3 x Plate | FL8*80 | +56.225 | +56.246 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 159.8 | p454 | 0.0294274 | 0.0127943 | 0.000064 | 0.000102354 | 0.000102354
2 x Plate | FL8*80 | +56.382 | +56.403 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*80 | +56.465 | +56.486 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*80 | +56.547 | +56.568 | 2 | 99 | 0.7 | 0 | 36.6 | 0 | 80 | 8 | 160.1 | p454 | 0.0294543 | 0.0128065 | 0.000064 | 0.000102452 | 0.000102452
3 x Plate | FL8*50 | +56.307 | +56.321 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | PLT8*85 | +53.849 | +53.948 | 2 | 99 | 0.9 | 0 | 36.3 | 0 | 85 | 8 | 170 | p453 | 0.0329797 | 0.01445 | 0.000064 | 0.000115599 | 0.000115599
6 x Plate | PLT8*95 | +54.820 | +54.929 | 2 | 99 | 1.1 | 0 | 35.9 | 0 | 95 | 8 | 180 | p476 | 0.0386001 | 0.0171002 | 0.000064 | 0.0001368 | 0.0001368
6 x Plate | FL8*50 | +54.946 | +55.011 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925324 | 0.000064 | 0.0000740259 | 0.0000740259
6 x Plate | FL8*50 | +54.864 | +54.929 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925322 | 0.000064 | 0.0000740258 | 0.0000740258
6 x Plate | FL8*60 | +54.762 | +54.847 | 2 | 99 | 1.1 | 0 | 36.9 | 0 | 60 | 8 | 305.1 | p420 | 0.0424584 | 0.0183081 | 0.000064 | 0.000146465 | 0.000146465
6 x Plate | FL8*60 | +55.586 | +55.671 | 2 | 99 | 1.1 | 0 | 36.9 | 0 | 60 | 8 | 305.1 | p420 | 0.0424588 | 0.0183083 | 0.000064 | 0.000146466 | 0.000146466
6 x Plate | FL8*50 | +55.514 | +55.579 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222676 | 0.00925328 | 0.000064 | 0.0000740262 | 0.0000740262
6 x Plate | FL8*50 | +55.431 | +55.496 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222676 | 0.00925326 | 0.000064 | 0.0000740261 | 0.0000740261
6 x Plate | FL8*60 | +54.669 | +54.743 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +54.587 | +54.661 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +54.084 | +54.158 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +54.002 | +54.075 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*50 | +53.927 | +53.983 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | FL8*60 | +54.504 | +54.578 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +54.422 | +54.496 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +54.331 | +54.413 | 2 | 99 | 0.9 | 0 | 37 | 0 | 60 | 8 | 270 | p417 | 0.03768 | 0.0162 | 0.000064 | 0.0001296 | 0.0001296
6 x Plate | FL8*60 | +54.249 | +54.323 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*60 | +54.166 | +54.240 | 2 | 99 | 0.7 | 0 | 37.6 | 0 | 60 | 8 | 170 | p459 | 0.02408 | 0.0102 | 0.000064 | 0.0000816 | 0.0000816
6 x Plate | FL8*50 | +55.349 | +55.414 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925325 | 0.000064 | 0.000074026 | 0.000074026
6 x Plate | FL8*50 | +55.267 | +55.332 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925325 | 0.000064 | 0.000074026 | 0.000074026
6 x Plate | FL8*50 | +55.111 | +55.176 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222676 | 0.00925326 | 0.000064 | 0.0000740261 | 0.0000740261
6 x Plate | FL8*50 | +55.194 | +55.249 | 2 | 99 | 0.2 | 0 | 40.6 | 0 | 50 | 8 | 70 | p523 | 0.00892 | 0.0035 | 0.000064 | 0.000028 | 0.000028
6 x Plate | FL8*50 | +55.029 | +55.094 | 2 | 99 | 0.7 | 0 | 38.3 | 0 | 50 | 8 | 185.1 | p456 | 0.0222675 | 0.00925325 | 0.000064 | 0.000074026 | 0.000074026
6 x Plate | PLT6*67 | +54.808 | +54.972 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
6 x Plate | PLT6*67 | +55.508 | +55.672 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
6 x Plate | PLT6*67 | +55.179 | +55.343 | 2 | 99 | 0.5 | 0 | 47.7 | 0 | 67 | 6 | 163.9 | p229 | 0.0244777 | 0.010988 | 0.000036 | 0.000065328 | 0.000065328
3 x Plate | FL8*150 | +53.945 | +53.966 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p525 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | FL8*130 | +54.759 | +54.777 | 2 | 99 | 2.1 | 0 | 34.8 | 0.1 | 130 | 8 | 260 | p532 | 0.07384 | 0.0338 | 0.000064 | 0.0002704 | 0.0002704
2 x Plate | PLT8*160 | +54.611 | +54.632 | 2 | 99 | 2 | 0 | 34.8 | 0.1 | 160 | 8 | 190 | p533 | 0.0664 | 0.0304 | 0.000064 | 0.0002432 | 0.0002432
3 x Plate | FL8*130 | +54.602 | +54.625 | 2 | 99 | 1.4 | 0 | 35.2 | 0.1 | 130 | 8 | 180 | p534 | 0.05176 | 0.0234 | 0.000064 | 0.0001872 | 0.0001872
3 x Plate | FL8*130 | +53.952 | +53.971 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 130 | 8 | 190 | p530 | 0.05452 | 0.0247 | 0.000064 | 0.0001976 | 0.0001976
3 x Plate | FL8*60 | +55.805 | +55.820 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90 | p520 | 0.0132002 | 0.0054001 | 0.000064 | 0.0000432008 | 0.0000432008
3 x Plate | FL8*110 | +55.798 | +55.820 | 2 | 99 | 1.2 | 0 | 35.7 | 0 | 110 | 8 | 171.1 | p451 | 0.0421507 | 0.0188262 | 0.000064 | 0.000150609 | 0.000150609
2 x Plate | FL8*60 | +54.823 | +54.839 | 2 | 99 | 0.3 | 0 | 38.9 | 0 | 60 | 8 | 90 | p520 | 0.0132 | 0.0054 | 0.000064 | 0.0000432 | 0.0000432
3 x Plate | FL8*130 | +53.796 | +53.814 | 2 | 99 | 2.1 | 0 | 34.8 | 0.1 | 130 | 8 | 260 | p536 | 0.07384 | 0.0338 | 0.000064 | 0.0002704 | 0.0002704
3 x Plate | FL8*150 | +53.867 | +53.889 | 2 | 99 | 1.4 | 0 | 35.1 | 0.1 | 150 | 8 | 160 | p475 | 0.05296 | 0.024 | 0.000064 | 0.000192 | 0.000192
3 x Plate | PLT8*155 | +53.860 | +53.881 | 2 | 99 | 1.6 | 0 | 35.1 | 0.1 | 155 | 8 | 160 | p480 | 0.05464 | 0.0248 | 0.000064 | 0.0001984 | 0.0001984
