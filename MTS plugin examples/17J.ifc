Properties of the parts of a building model (IFC2X3), part 16 of 16

# IfcMember: CHS43*3 (134)
Name | Bottom elevation | Top elevation | Width (mm) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3)
HANDRAIL | +53.313 | +54.344 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +52.774 | +53.805 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +51.868 | +52.899 | 60 | 1030 | m430 | 1029.99 | 0.144363 | 0.144364 | 0.000759596 | 0.000759599
HANDRAIL | +51.950 | +52.981 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +52.074 | +53.059 | 60 | 984.7 | m434 | 984.652 | 0.138306 | 0.144364 | 0.000743268 | 0.000759599
HANDRAIL | +52.198 | +53.228 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +52.692 | +53.723 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +52.568 | +53.558 | 60 | 988.9 | m435 | 988.945 | 0.138879 | 0.144364 | 0.000744813 | 0.000759599
HANDRAIL | +52.445 | +53.476 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +52.321 | +53.309 | 60 | 986.8 | m436 | 986.798 | 0.138592 | 0.144364 | 0.000744041 | 0.000759599
HANDRAIL | +51.779 | +52.810 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +51.655 | +52.686 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +51.284 | +52.315 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +51.408 | +52.439 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +51.531 | +52.512 | 60 | 979.9 | m426 | 979.941 | 0.137677 | 0.144364 | 0.000741572 | 0.000759599

# IfcMember: FL5*50 (6)
In: Undefined
Description: FL5*50; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +53.010; Top elevation: +53.299; Phase: 6; Class: 99
Tekla Quantity - Weight: 0.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 56.9 m2; Net surface area: 0 m2; Height: 50 mm; Width: 5 mm; Length: 290 mm
Pset_MemberCommon - LoadBearing: yes; Reference: A816
BaseQuantities - Length: 290 mm; OuterSurfaceArea: 0.0324 m2; GrossSurfaceArea: 0.0324 m2; CrossSectionArea: 0.00025 m2; NetVolume: 0.0000725 m3; GrossVolume: 0.0000725 m3; NetWeight: 0.569125 kg; GrossWeight: 0.569125 kg

# IfcMember: FL8*150 (10)
In: Undefined
Description: FL8*150; Material: STEEL/S355JR
Tekla Common - Phase: 999; Class: 100
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 150 mm; Width: 8 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.0012 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) = GrossVolume (m3) | NetWeight (kg) = GrossWeight (kg)
2 x PLATE | +53.163 | +53.371 | 2.4 | 34.6 | 250 | p515 | 250.001 | 0.0814004 | 0.000300001 | 2.35501
2 x PLATE | +52.694 | +52.889 | 2.4 | 34.6 | 250 | p515 | 250.001 | 0.0814004 | 0.000300001 | 2.35501
2 x PLATE | +52.206 | +52.383 | 2.4 | 34.6 | 250 | p515 | 250.001 | 0.0814003 | 0.000300001 | 2.35501
2 x PLATE | +51.726 | +51.876 | 2.4 | 34.6 | 250 | p515 | 250.001 | 0.0814002 | 0.000300001 | 2.35501
2 x PLATE | +51.239 | +51.375 | 2.8 | 34.4 | 300 | p516 | 300 | 0.0972 | 0.00036 | 2.826

# IfcMember: L100*100*8 (14)
In: Undefined
Description: L100*100*8; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 32 m2; Height: 100 mm; Width: 100 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00155414 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x VB | +55.195 | +56.605 | 23.3 | 0.9 | 1912.9 | A435 | 1912.94 | 0.74547 | 0.00293827 | 0.00297297 | 23.0654 | 23.3378
4 x VB | +51.761 | +53.149 | 27.7 | 0.9 | 2266.7 | A434 | 2266.69 | 0.883327 | 0.00348164 | 0.00352275 | 27.3308 | 27.6536
4 x VB | +52.795 | +55.134 | 36.5 | 1.3 | 2994.2 | A432 | 2994.19 | 1.16683 | 0.00459908 | 0.00465339 | 36.1028 | 36.5291
4 x VB | +53.271 | +56.085 | 41.4 | 1.4 | 3396.3 | A433 | 3396.29 | 1.32353 | 0.00521671 | 0.00527832 | 40.9511 | 41.4348

# IfcMember: L60*60*6 (6)
In: Undefined
Description: L60*60*6; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +50.466; Top elevation: +51.099; Phase: 9; Class: 4
Tekla Quantity - Weight: 4.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 43 m2; Net surface area: 0.2 m2; Height: 60 mm; Width: 60 mm; Length: 845.4 mm
Pset_MemberCommon - LoadBearing: yes; Reference: A649
BaseQuantities - OuterSurfaceArea: 0.197089 m2; GrossSurfaceArea: 0.197089 m2; CrossSectionArea: 0.000690446 m2
Name | Length (mm) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
5 x VB | 845.395 | 0.00057825 | 0.000583699 | 4.53926 | 4.58204
VB | 845.393 | 0.000578249 | 0.000583698 | 4.53925 | 4.58203

# IfcMember: L70*70*6 (54)
In: Undefined
Description: L70*70*6; Material: STEEL/S355JR
Tekla Common - Phase: 11; Class: 2
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 42.7 m2; Height: 70 mm; Width: 70 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.000812739 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
3 x DUMMY | +55.766 | +56.345 | 5 | 0.2 | 779.3 | A205 | 779.334 | 0.212192 | 0.000626584 | 0.000633395 | 4.91869 | 4.97215
6 x DUMMY | +54.376 | +55.012 | 5.5 | 0.2 | 857.6 | A200 | 857.587 | 0.233499 | 0.0006895 | 0.000696994 | 5.41257 | 5.4714
6 x DUMMY | +52.976 | +53.527 | 4.7 | 0.2 | 733 | A199 | 733.012 | 0.19958 | 0.000589342 | 0.000595747 | 4.62633 | 4.67662
3 x DUMMY | +55.112 | +56.345 | 11.1 | 0.5 | 1744.7 | A197 | 1744.67 | 0.475029 | 0.00140272 | 0.00141796 | 11.0113 | 11.131
6 x DUMMY | +55.112 | +55.738 | 5.3 | 0.2 | 849.1 | A194 | 849.112 | 0.231191 | 0.000682686 | 0.000690106 | 5.35908 | 5.41733
3 x DUMMY | +53.759 | +55.012 | 11.4 | 0.5 | 1763.6 | A204 | 1763.58 | 0.480178 | 0.00141737 | 0.00143333 | 11.1264 | 11.2517
3 x DUMMY | +53.759 | +54.348 | 5 | 0.2 | 788.9 | A203 | 788.911 | 0.2148 | 0.000634285 | 0.000641179 | 4.97914 | 5.03325
2 x DUMMY | +52.317 | +53.530 | 10.8 | 0.5 | 1703 | A202 | 1703.02 | 0.463689 | 0.00136923 | 0.00138411 | 10.7485 | 10.8653
6 x DUMMY | +52.317 | +52.948 | 5.3 | 0.2 | 850.3 | A194 | 850.259 | 0.231504 | 0.000683608 | 0.000691039 | 5.36632 | 5.42465
3 x DUMMY | +55.766 | +56.347 | 5 | 0.2 | 782.1 | A201 | 782.05 | 0.212932 | 0.000628768 | 0.000635603 | 4.93583 | 4.98948
3 x DUMMY | +55.112 | +56.347 | 11.1 | 0.5 | 1747.4 | A198 | 1747.39 | 0.475769 | 0.0014049 | 0.00142017 | 11.0285 | 11.1483
3 x DUMMY | +53.771 | +55.012 | 11.1 | 0.5 | 1744.2 | A197 | 1744.24 | 0.474911 | 0.00140237 | 0.00141761 | 11.0086 | 11.1282
3 x DUMMY | +53.771 | +54.348 | 4.8 | 0.2 | 771.6 | A196 | 771.554 | 0.210074 | 0.000620329 | 0.000627072 | 4.86958 | 4.92251
3 x DUMMY | +52.317 | +53.527 | 10.8 | 0.5 | 1698.4 | A195 | 1698.37 | 0.462422 | 0.00136549 | 0.00138033 | 10.7191 | 10.8356
DUMMY | +52.317 | +53.530 | 10.8 | 0.5 | 1703 | m47 | 1703.02 | 0.463689 | 0.00136923 | 0.00138411 | 10.7485 | 10.8653

# IfcMember: L70*70*8 (22)
In: Undefined
Description: L70*70*8; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 32.6 m2; Height: 70 mm; Width: 70 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00106497 m2
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
6 x Angle | +57.311 | +58.297 | 3 | 3 | 11.1 | 0.3 | 1324.7 | A429 | 1324.74 | 0.360693 | 0.00139893 | 0.00141081 | 10.9816 | 11.0748
6 x VB | +57.511 | +58.228 | 3 | 3 | 6.4 | 0.2 | 761 | A431 | 760.968 | 0.207192 | 0.000803583 | 0.000810407 | 6.30812 | 6.36169
3 x VB | +51.216 | +51.994 | 6 | 4 | 9.2 | 0.3 | 1118.3 | A430 | 1118.29 | 0.304481 | 0.00118091 | 0.00119094 | 9.27015 | 9.34887
3 x VB | +51.216 | +51.994 | 6 | 4 | 9.2 | 0.3 | 1118.3 | A430 | 1118.29 | 0.304481 | 0.00118091 | 0.00119094 | 9.27015 | 9.34888
4 x VB | +51.273 | +52.156 | 1 | 4 | 15.9 | 0.5 | 1914.3 | A419 | 1914.27 | 0.521208 | 0.00202147 | 0.00203864 | 15.8686 | 16.0033

# IfcMember: L80*80*6 (30)
In: Undefined
Description: L80*80*6; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 42.4 m2; Height: 80 mm; Width: 80 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.000935032 m2
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x VB | +55.130 | +56.615 | 1 | 4 | 21.3 | 0.9 | 2902.4 | A294 | 2902.44 | 0.903867 | 0.00268186 | 0.00271388 | 21.0526 | 21.3039
6 x VB | +56.759 | +58.285 | 4 | 4 | 14.9 | 0.6 | 2027.4 | A295 | 2027.39 | 0.631362 | 0.00187331 | 0.00189568 | 14.7055 | 14.8811
6 x DUMMY | +51.389 | +52.191 | 11 | 2 | 7.1 | 0.3 | 977.1 | A287 | 977.101 | 0.304285 | 0.000902842 | 0.000913621 | 7.08731 | 7.17192
6 x DUMMY | +50.617 | +52.191 | 11 | 2 | 14.5 | 0.6 | 1981.5 | A286 | 1981.53 | 0.617079 | 0.00183093 | 0.00185279 | 14.3728 | 14.5444
3 x DUMMY | +50.617 | +51.335 | 11 | 2 | 6.4 | 0.3 | 867.8 | A285 | 867.759 | 0.270234 | 0.000801809 | 0.000811382 | 6.2942 | 6.36935
3 x DUMMY | +50.617 | +51.335 | 11 | 2 | 6.4 | 0.3 | 867.8 | A285 | 867.758 | 0.270234 | 0.000801809 | 0.000811381 | 6.2942 | 6.36934
4 x VB | +52.264 | +54.141 | 1 | 4 | 19.5 | 0.9 | 2661.1 | A284 | 2661.14 | 0.82872 | 0.00245889 | 0.00248825 | 19.3023 | 19.5327

# IfcMember: M16_NUT (144)
In: Undefined
Description: M16_NUT; Material: MISCELLANEOUS/EXISTING
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 24 mm; Width: 27.7 mm; Length: 16 mm
Tekla Common - Phase: 6; Class: 99
Pset_MemberCommon - LoadBearing: yes; Reference: A691
BaseQuantities - Length: 16 mm; OuterSurfaceArea: 1.33022e-09 m2; GrossSurfaceArea: 0.00232831 m2; CrossSectionArea: 0.00049896 m2; NetVolume: 0.00000431773 m3; GrossVolume: 0.00000798338 m3; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Bottom elevation | Top elevation
6 x Nut | +52.349 | +52.367
6 x Nut | +52.383 | +52.401
6 x Nut | +52.368 | +52.386
6 x Nut | +52.402 | +52.420
6 x Nut | +52.267 | +52.285
6 x Nut | +52.301 | +52.319
6 x Nut | +52.286 | +52.304
6 x Nut | +52.320 | +52.338
6 x Nut | +52.143 | +52.161
6 x Nut | +52.177 | +52.195
6 x Nut | +52.162 | +52.180
6 x Nut | +52.196 | +52.214
6 x Nut | +52.020 | +52.038
6 x Nut | +52.053 | +52.072
6 x Nut | +52.038 | +52.057
6 x Nut | +52.072 | +52.091
6 x Nut | +51.772 | +51.791
6 x Nut | +51.806 | +51.824
6 x Nut | +51.791 | +51.809
6 x Nut | +51.825 | +51.843
6 x Nut | +51.896 | +51.914
6 x Nut | +51.930 | +51.948
6 x Nut | +51.915 | +51.933
6 x Nut | +51.949 | +51.967

# IfcMember: O30*6 (144)
In: Undefined
Description: O30*6; Material: MISCELLANEOUS/EXISTING
Tekla Common - Phase: 6; Class: 99
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 30 mm; Width: 30 mm; Length: 4 mm
Pset_MemberCommon - LoadBearing: yes; Reference: A690
BaseQuantities - OuterSurfaceArea: 0.0009127 m2; GrossSurfaceArea: 0.0009127 m2; CrossSectionArea: 0.000432 m2; NetVolume: 0.000001728 m3; GrossVolume: 0.000001728 m3; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Bottom elevation | Top elevation | Length (mm)
6 x Washar | +52.365 | +52.372 | 4
6 x Washar | +52.379 | +52.385 | 4
6 x Washar | +52.384 | +52.390 | 4.00001
6 x Washar | +52.398 | +52.404 | 4
6 x Washar | +52.283 | +52.289 | 4
6 x Washar | +52.297 | +52.303 | 4
6 x Washar | +52.301 | +52.308 | 4
6 x Washar | +52.315 | +52.322 | 4
6 x Washar | +52.159 | +52.165 | 4.00001
3 x Washar | +52.173 | +52.179 | 4
3 x Washar | +52.178 | +52.184 | 4.00001
6 x Washar | +52.192 | +52.198 | 4
6 x Washar | +52.035 | +52.042 | 4
6 x Washar | +52.049 | +52.056 | 4
6 x Washar | +52.054 | +52.061 | 4
6 x Washar | +52.068 | +52.075 | 4
6 x Washar | +51.788 | +51.795 | 4
6 x Washar | +51.802 | +51.809 | 4
6 x Washar | +51.807 | +51.813 | 4
3 x Washar | +51.821 | +51.827 | 4.00001
6 x Washar | +51.912 | +51.918 | 4
6 x Washar | +51.926 | +51.932 | 4
6 x Washar | +51.931 | +51.937 | 4.00001
6 x Washar | +51.945 | +51.951 | 4
3 x Washar | +51.821 | +51.827 | 4
3 x Washar | +52.173 | +52.179 | 4.00001
3 x Washar | +52.178 | +52.184 | 4

# IfcMember: PC100*50 (6)
In: Undefined
Description: PC100*50; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +50.967; Top elevation: +52.254; Phase: 6; Class: 3
Tekla Quantity - Weight: 13 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 37.9 m2; Net surface area: 0.5 m2; Height: 100 mm; Width: 50 mm; Length: 1287.2 mm
Pset_MemberCommon - LoadBearing: yes; Reference: m170
BaseQuantities - CrossSectionArea: 0.00128662 m2
Name | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
3 x Post | 1287.17 | 0.492715 | 0.00161668 | 0.0016561 | 12.691 | 13.0004
3 x Post | 1287.19 | 0.492723 | 0.00161671 | 0.00165613 | 12.6912 | 13.0006

# IfcMember: PC180*70 (16)
In: Undefined
Description: PC180*70; Material: STEEL/S355JR
Tekla Common - Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.3 m2; Height: 180 mm; Width: 70 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.0026879 m2
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
3 x Stair | +56.743 | +57.270 | 3 | 15.4 | 0.3 | 734.8 | m195 | 734.753 | 0.453081 | 0.00165714 | 0.00197494 | 13.0085 | 15.5033
3 x Stair | +56.743 | +57.270 | 3 | 15.4 | 0.3 | 734.8 | m194 | 734.753 | 0.453081 | 0.00165714 | 0.00197494 | 13.0085 | 15.5033
Stair | +56.743 | +57.270 | 3 | 15.4 | 0.3 | 734.8 | m178 | 734.753 | 0.453081 | 0.00165714 | 0.00197494 | 13.0085 | 15.5033
Stair | +56.743 | +57.270 | 3 | 15.4 | 0.3 | 734.8 | m177 | 734.753 | 0.453081 | 0.00165714 | 0.00197494 | 13.0085 | 15.5033
Stringer | +50.250 | +51.017 | 2 | 23.8 | 0.6 | 1122 | m174 | 1121.96 | 0.691846 | 0.00267439 | 0.0030157 | 20.9939 | 23.6733
2 x Stringer | +50.250 | +51.017 | 2 | 23.8 | 0.6 | 1122 | m173 | 1121.96 | 0.691846 | 0.00267439 | 0.0030157 | 20.9939 | 23.6733
3 x Stringer | +50.250 | +51.017 | 2 | 23.8 | 0.6 | 1122 | m172 | 1121.96 | 0.691846 | 0.00267439 | 0.0030157 | 20.9939 | 23.6733
2 x Stringer | +50.250 | +51.017 | 2 | 23.8 | 0.6 | 1122 | m171 | 1121.96 | 0.691846 | 0.00267439 | 0.0030157 | 20.9939 | 23.6733

# IfcMember: PC230*90 (10)
In: Undefined
Description: PC230*90; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24.8 m2; Height: 230 mm; Width: 90 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00410191 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
VB | +50.267 | +52.156 | 135.8 | 3.4 | 4218.2 | m29 | 4218.15 | 3.35216 | 0.0170202 | 0.0173025 | 133.609 | 135.824
2 x VB | +50.259 | +53.149 | 157.4 | 3.9 | 4887.8 | m30 | 4887.82 | 3.88435 | 0.0197224 | 0.0200494 | 154.821 | 157.388
2 x VB | +50.266 | +54.141 | 179.5 | 4.4 | 5575 | m31 | 5574.97 | 4.43042 | 0.022495 | 0.022868 | 176.586 | 179.514
VB | +50.280 | +56.085 | 228.3 | 5.7 | 7089.7 | m33 | 7089.7 | 5.63417 | 0.0286069 | 0.0290813 | 224.564 | 228.288
VB | +50.280 | +56.085 | 228.3 | 5.7 | 7089.7 | m33 | 7089.7 | 5.63418 | 0.0286069 | 0.0290813 | 224.564 | 228.288
2 x VB | +50.264 | +55.134 | 204 | 5.1 | 6336.5 | m32 | 6336.52 | 5.03563 | 0.0255679 | 0.0259919 | 200.708 | 204.036
VB | +50.267 | +52.156 | 135.8 | 3.4 | 4218.2 | m29 | 4218.15 | 3.35216 | 0.0170202 | 0.0173025 | 133.609 | 135.825

# IfcMember: TI152*165*20 (6)
In: Undefined
Description: TI152*165*20; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 23.7 m2; Height: 151.8 mm; Width: 165.1 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00258556 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | GrossSurfaceArea (m2) | NetVolume (m3) = GrossVolume (m3) | NetWeight (kg) = GrossWeight (kg)
VB | +52.436 | +55.027 | 76.3 | 2.4 | 3812.5 | A397 | 3812.54 | 1.8089 | 2.42225 | 0.00971583 | 76.2693
2 x VB | +52.413 | +54.862 | 51.8 | 1.6 | 2591.2 | A395 | 2591.22 | 1.22943 | 1.64793 | 0.00660343 | 51.8369
VB | +50.368 | +52.407 | 44.3 | 1.4 | 2215.6 | A394 | 2215.6 | 1.05121 | 1.40978 | 0.0056462 | 44.3227
VB | +52.436 | +55.027 | 76.3 | 2.4 | 3812.5 | A396 | 3812.54 | 1.8089 | 2.42225 | 0.00971584 | 76.2693
VB | +50.368 | +52.407 | 44.3 | 1.4 | 2215.6 | A394 | 2215.59 | 1.05121 | 1.40978 | 0.0056462 | 44.3227

# IfcMember: UB254*146*37 (2)
In: Undefined
Description: UB254*146*37; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +55.277; Top elevation: +56.793; Phase: 1; Class: 4
Tekla Quantity - Weight: 75.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 28.9 m2; Net surface area: 2.2 m2; Height: 256 mm; Width: 146.4 mm; Length: 2046.1 mm
Pset_MemberCommon - LoadBearing: yes; Reference: m253
BaseQuantities - Length: 2046.1 mm; OuterSurfaceArea: 2.19332 m2; GrossSurfaceArea: 2.19332 m2; CrossSectionArea: 0.00471338 m2; NetVolume: 0.00923944 m3; GrossVolume: 0.00964403 m3; NetWeight: 72.5296 kg; GrossWeight: 75.7056 kg

# IfcPlate: FL10*100 (6)
In: Undefined
Description: FL10*100; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +51.162; Top elevation: +51.562; Phase: 11; Class: 2
Tekla Quantity - Weight: 3.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 28.6 m2; Net surface area: 0.1 m2; Height: 100 mm; Width: 10 mm; Length: 436.7 mm
Pset_PlateCommon - LoadBearing: yes; Reference: DUMMY1148
BaseQuantities - Width: 100 mm; NetArea: 0.0980667 m2; GrossArea: 0.0436667 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.000436667 m3; GrossVolume: 0.000436667 m3

# IfcPlate: FL10*90 (29)
In: Undefined
Description: FL10*90; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 90 mm; Width: 10 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - Width: 90 mm; CrossSectionArea: 0.0001 m2
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
12 x Plate | +58.428 | +58.518 | 5 | 99 | 0.9 | 29.9 | 0 | 150 | p77 | 0.0307657 | 0.0135 | 0.000131
6 x DUMMY | +55.578 | +55.926 | 11 | 2 | 3 | 28.9 | 0.1 | 416.2 | DUMMY1149 | 0.0850452 | 0.0374603 | 0.000374603
6 x DUMMY | +54.187 | +54.537 | 11 | 2 | 3 | 28.9 | 0.1 | 415.1 | DUMMY1149 | 0.084819 | 0.0373586 | 0.000373586
5 x DUMMY | +52.787 | +53.137 | 11 | 2 | 3 | 28.9 | 0.1 | 415.1 | DUMMY1149 | 0.084819 | 0.0373586 | 0.000373586

# IfcPlate: FL16*100 (24)
In: Undefined
Description: FL16*100; Material: STEEL/S355JR
Tekla Common - Phase: 11; Class: 2
Tekla Quantity - Weight: 2.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 19.9 m2; Net surface area: 0 m2; Height: 100 mm; Width: 16 mm; Length: 180 mm
Pset_PlateCommon - LoadBearing: yes; Reference: p180
BaseQuantities - Width: 100 mm; NetArea: 0.04496 m2; GrossArea: 0.018 m2; CrossSectionArea: 0.000256 m2; NetVolume: 0.000288 m3; GrossVolume: 0.000288 m3
Name | Bottom elevation | Top elevation
12 x DUMMY | +53.762 | +53.942
12 x DUMMY | +50.882 | +51.062

# IfcPlate: FL5*20 (60)
In: Undefined
Description: FL5*20; Material: STEEL/S355JR
Tekla Common - Phase: 4; Class: 99
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 67.9 m2; Net surface area: 0 m2; Height: 20 mm; Width: 5 mm; Length: 60 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A839
BaseQuantities - Width: 20 mm; NetArea: 0.0032 m2; GrossArea: 0.0012 m2; CrossSectionArea: 0.000025 m2; NetVolume: 0.000006 m3; GrossVolume: 0.000006 m3
Name | Bottom elevation | Top elevation
30 x Plate | +58.367 | +58.387
30 x Plate | +58.120 | +58.140

# IfcPlate: FL8*100 (12)
In: Undefined
Description: FL8*100; Material: STEEL/S355JR
Tekla Quantity - Weight: 1.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 35.9 m2; Net surface area: 0 m2; Height: 100 mm; Width: 8 mm; Length: 180 mm
Tekla Common - Bottom elevation: +53.762; Top elevation: +53.942; Phase: 11; Class: 2
Pset_PlateCommon - LoadBearing: yes; Reference: A804
BaseQuantities - Width: 100 mm; NetArea: 0.04048 m2; GrossArea: 0.018 m2; CrossSectionArea: 0.000064 m2; NetVolume: 0.000144 m3; GrossVolume: 0.000144 m3

# IfcPlate: PL10*120 (60)
In: Undefined
Description: PL10*120; Material: STEEL/S355JR
Tekla Common - Phase: 4; Class: 3
Tekla Quantity - Weight: 0.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 31.6 m2; Net surface area: 0 m2; Height: 120 mm; Width: 10 mm; Length: 133 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A772
BaseQuantities - Width: 120 mm; NetArea: 0.0249087 m2; GrossArea: 0.01596 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.000100561 m3; GrossVolume: 0.000100561 m3
Name | Bottom elevation | Top elevation
30 x Plate | +58.266 | +58.399
30 x Plate | +58.183 | +58.316

# IfcPlate: PL10*130.2 (6)
In: Undefined
Description: PL10*130.2; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +56.827; Top elevation: +56.957; Phase: 1; Class: 99
Tekla Quantity - Weight: 2.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 28.7 m2; Net surface area: 0.1 m2; Height: 130.2 mm; Width: 10 mm; Length: 205.5 mm
Pset_PlateCommon - LoadBearing: yes; Reference: p239
BaseQuantities - Width: 130.19 mm; NetArea: 0.0590659 m2; GrossArea: 0.0267529 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.000262026 m3; GrossVolume: 0.000262026 m3

# IfcPlate: PL10*410 (3)
In: Undefined
Description: PL10*410; Material: Undefined/80SHORE
Tekla Common - Bottom elevation: +52.055; Top elevation: +52.465; Phase: 6; Class: 14
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.9 m2; Height: 410 mm; Width: 10 mm; Length: 958 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A777
BaseQuantities - Width: 410 mm; NetArea: 0.81292 m2; GrossArea: 0.39278 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.0039278 m3; GrossVolume: 0.0039278 m3

# IfcPlate: PL10*720 (3)
In: Undefined
Description: PL10*720; Material: Undefined/80SHORE
Tekla Common - Bottom elevation: +52.660; Top elevation: +53.379; Phase: 6; Class: 14
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 1.4 m2; Height: 720 mm; Width: 10 mm; Length: 958 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A776
BaseQuantities - Width: 720 mm; NetArea: 1.41308 m2; GrossArea: 0.689759 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.00689759 m3; GrossVolume: 0.00689759 m3

# IfcPlate: PL16*290 (6)
In: Undefined
Description: PL16*290; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +57.307; Top elevation: +57.323; Phase: 12; Class: 99
Tekla Quantity - Weight: 10.3 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 17.6 m2; Net surface area: 0.2 m2; Height: 290 mm; Width: 16 mm; Length: 290 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A831
BaseQuantities - Width: 290 mm; NetArea: 0.185295 m2; GrossArea: 0.0841 m2; CrossSectionArea: 0.000256 m2; NetVolume: 0.00133029 m3; GrossVolume: 0.0013456 m3

# IfcPlate: PL3*228.6 (30)
In: Undefined
Description: PL3*228.6; Material: STEEL/S355JR
Tekla Quantity - Weight: 0.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 87.2 m2; Net surface area: 0.1 m2; Height: 228.6 mm; Width: 3 mm; Length: 228.6 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - Width: 228.554 mm; NetArea: 0.0824831 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0001205 m3; GrossVolume: 0.0001205 m3
Name | Bottom elevation | Top elevation | Phase | Class | Reference | GrossArea (m2)
6 x Cover Plate | +51.611 | +51.835 | 9 | 99 | A797 | 0.0522368
6 x Cover Plate | +50.760 | +50.984 | 9 | 99 | A797 | 0.0522368
6 x DUMMY | +51.137 | +51.367 | 22 | 2 | A802 | 0.0522369
6 x Plate | +57.865 | +58.089 | 9 | 3 | A796 | 0.0522368
6 x Plate | +57.248 | +57.472 | 12 | 3 | A796 | 0.0522368

# IfcPlate: PL3*964 (2)
In: Undefined
Description: PL3*964; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +51.062; Top elevation: +52.702; Phase: 11; Class: 2
Tekla Quantity - Weight: 37.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.3 m2; Net surface area: 3.2 m2; Height: 964 mm; Width: 3 mm; Length: 1640 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A789
BaseQuantities - Width: 964.001 mm; NetArea: 3.17755 m2; GrossArea: 1.58096 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00474289 m3; GrossVolume: 0.00474289 m3

# IfcPlate: PL30*1045 (3)
In: Undefined
Description: PL30*1045; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +53.697; Top elevation: +53.727; Phase: 11; Class: 2
Tekla Quantity - Volume: 0.1 m3; Area per tons: 9 m2; Height: 1045 mm; Width: 30 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - Width: 1045 mm; CrossSectionArea: 0.0009 m2
Name | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
DUMMY | 475.3 | 2 | 4.2 | 2230 | A786 | 4.25678 | 2.33035 | 0.0605446
2 x DUMMY | 416.6 | 1.8 | 3.7 | 1965 | A785 | 3.74211 | 2.05343 | 0.053072

# IfcPlate: PL30*691.8 (4)
In: Undefined
Description: PL30*691.8; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +56.742; Top elevation: +56.772; Phase: 11; Class: 2
Tekla Quantity - Weight: 277 kg; Volume: 0 m3; Gross footprint area: 1.2 m2; Area per tons: 9 m2; Net surface area: 2.4 m2; Height: 691.8 mm; Width: 30 mm; Length: 1700 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A787
BaseQuantities - Width: 691.8 mm; NetArea: 2.49563 m2; GrossArea: 1.17606 m2; CrossSectionArea: 0.0009 m2; NetVolume: 0.0352818 m3; GrossVolume: 0.0352818 m3

# IfcPlate: PL30*956.6 (2)
In: Undefined
Description: PL30*956.6; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +56.742; Top elevation: +56.772; Phase: 11; Class: 2
Tekla Quantity - Weight: 383 kg; Volume: 0 m3; Gross footprint area: 1.6 m2; Area per tons: 9 m2; Net surface area: 3.4 m2; Height: 956.6 mm; Width: 30 mm; Length: 1700 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A788
BaseQuantities - Width: 956.576 mm; NetArea: 3.41175 m2; GrossArea: 1.62618 m2; CrossSectionArea: 0.0009 m2; NetVolume: 0.0487854 m3; GrossVolume: 0.0487854 m3

# IfcPlate: PL5*370 (3)
In: Undefined
Description: PL5*370; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +52.405; Top elevation: +52.774; Phase: 6; Class: 99
Tekla Quantity - Weight: 13.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 51.9 m2; Net surface area: 0.6 m2; Height: 370 mm; Width: 5 mm; Length: 948 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A818
BaseQuantities - Width: 370 mm; NetArea: 0.7147 m2; GrossArea: 0.35076 m2; CrossSectionArea: 0.000025 m2; NetVolume: 0.0017538 m3; GrossVolume: 0.0017538 m3

# IfcPlate: PL6*64.8 (6)
In: Undefined
Description: PL6*64.8; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +51.135; Top elevation: +51.200; Phase: 22; Class: 2
Tekla Quantity - Weight: 0.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 60.1 m2; Net surface area: 0 m2; Height: 64.8 mm; Width: 6 mm; Length: 64.8 mm
Pset_PlateCommon - LoadBearing: yes; Reference: p618
BaseQuantities - Width: 64.7527 mm; NetArea: 0.00644853 m2; GrossArea: 0.00419291 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000013676 m3; GrossVolume: 0.000019508 m3

# IfcPlate: PLT10*139.2 (6)
In: Undefined
Description: PLT10*139.2; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +56.335; Top elevation: +56.474; Phase: 1; Class: 99
Tekla Quantity - Weight: 3.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 28.2 m2; Net surface area: 0.1 m2; Height: 139.2 mm; Width: 10 mm; Length: 410 mm
Pset_PlateCommon - LoadBearing: yes; Reference: p8
BaseQuantities - Width: 139.2 mm; NetArea: 0.102641 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.000463786 m3; GrossVolume: 0.000463786 m3
Name | GrossArea (m2)
5 x Stool | 0.0570746
Stool | 0.0570745

# IfcPlate: PLT10*141.6 (36)
In: Undefined
Description: PLT10*141.6; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Weight: 3.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 28.2 m2; Net surface area: 0.1 m2; Height: 141.6 mm; Width: 10 mm; Length: 410 mm
Pset_PlateCommon - LoadBearing: yes; Reference: p7
BaseQuantities - CrossSectionArea: 0.0001 m2
Name | Bottom elevation | Top elevation | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
6 x Stool | +50.825 | +50.967 | 141.629 | 0.102716 | 0.058068 | 0.000464135
6 x Stool | +52.406 | +52.548 | 141.625 | 0.102715 | 0.0580687 | 0.000464132
6 x Stool | +55.384 | +55.526 | 141.625 | 0.10271 | 0.0580687 | 0.000464104
6 x Stool | +54.391 | +54.533 | 141.632 | 0.102725 | 0.0580714 | 0.000464177
6 x Stool | +53.399 | +53.541 | 141.602 | 0.1027 | 0.0580592 | 0.000464058
6 x Stool | +51.413 | +51.555 | 141.606 | 0.102709 | 0.0580609 | 0.000464099

# IfcPlate: PLT10*219.1 (2)
In: Undefined
Description: PLT10*219.1; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +52.377; Top elevation: +52.596; Phase: 999; Class: 100
Tekla Quantity - Weight: 4.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27.8 m2; Net surface area: 0.1 m2; Height: 219.1 mm; Width: 10 mm; Length: 440.2 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A739
BaseQuantities - Width: 219.095 mm; NetArea: 0.134241 m2; GrossArea: 0.0964408 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.000615962 m3; GrossVolume: 0.000615962 m3

# IfcPlate: PLT10*251.9 (12)
In: Undefined
Description: PLT10*251.9; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +54.858; Top elevation: +55.265; Phase: 11; Class: 2
Tekla Quantity - Weight: 8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27.1 m2; Net surface area: 0.2 m2; Height: 251.9 mm; Width: 10 mm; Length: 406.6 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A738
BaseQuantities - CrossSectionArea: 0.0001 m2
Name | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
6 x DUMMY | 251.892 | 0.218006 | 0.102418 | 0.00102418
6 x DUMMY | 251.893 | 0.218007 | 0.102419 | 0.00102419

# IfcPlate: PLT10*255.8 (4)
In: Undefined
Description: PLT10*255.8; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +56.186; Top elevation: +56.442; Phase: 11; Class: 2
Tekla Quantity - Weight: 5.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27.5 m2; Net surface area: 0.1 m2; Height: 255.8 mm; Width: 10 mm; Length: 264.6 mm
Pset_PlateCommon - LoadBearing: yes; Reference: DUMMY1162
BaseQuantities - CrossSectionArea: 0.0001 m2
Name | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x DUMMY | 255.836 | 0.145773 | 0.0676824 | 0.000676824
2 x DUMMY | 255.837 | 0.145774 | 0.0676829 | 0.000676829

# IfcPlate: PLT10*257.7 (6)
In: Undefined
Description: PLT10*257.7; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +56.184; Top elevation: +56.442; Phase: 11; Class: 2
Tekla Quantity - Weight: 5.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27.5 m2; Net surface area: 0.1 m2; Height: 257.7 mm; Width: 10 mm; Length: 266.6 mm
Pset_PlateCommon - LoadBearing: yes; Reference: DUMMY1161
BaseQuantities - NetArea: 0.147854 m2; CrossSectionArea: 0.0001 m2
Name | Width (mm) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
3 x DUMMY | 257.677 | 0.0686849 | 0.000686849
3 x DUMMY | 257.676 | 0.0686846 | 0.000686846

# IfcPlate: PLT10*258.1 (12)
In: Undefined
Description: PLT10*258.1; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +52.024; Top elevation: +52.471; Phase: 11; Class: 2
Tekla Quantity - Weight: 9.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27 m2; Net surface area: 0.2 m2; Height: 258.1 mm; Width: 10 mm; Length: 446.2 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A737
BaseQuantities - NetArea: 0.244441 m2; GrossArea: 0.115177 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.00115177 m3; GrossVolume: 0.00115177 m3
Name | Width (mm)
6 x DUMMY | 258.107
6 x DUMMY | 258.108

# IfcPlate: PLT10*267.5 (12)
In: Undefined
Description: PLT10*267.5; Material: STEEL/S355JR
Pset_PlateCommon - LoadBearing: yes; Reference: DUMMY1145
Tekla Common - Bottom elevation: +50.272; Top elevation: +50.784; Phase: 11; Class: 2
Tekla Quantity - Weight: 9.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27 m2; Net surface area: 0.3 m2; Height: 267.5 mm; Width: 10 mm; Length: 511.6 mm
BaseQuantities - Width: 267.485 mm; GrossArea: 0.136851 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.00124447 m3; GrossVolume: 0.00124447 m3
Name | NetArea (m2)
9 x DUMMY | 0.2633
3 x DUMMY | 0.263299

# IfcPlate: PLT10*295.6 (12)
In: Undefined
Description: PLT10*295.6; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +53.373; Top elevation: +53.924; Phase: 11; Class: 2
Tekla Quantity - Weight: 12.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.7 m2; Net surface area: 0.3 m2; Height: 295.6 mm; Width: 10 mm; Length: 550.7 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A736
BaseQuantities - GrossArea: 0.162798 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.00162798 m3; GrossVolume: 0.00162798 m3
Name | Width (mm) | NetArea (m2)
6 x DUMMY | 295.596 | 0.342523
6 x DUMMY | 295.597 | 0.342524

# IfcPlate: PLT100*204.5 (12)
In: Undefined
Description: PLT100*204.5; Material: MISCELLANEOUS/COMPONENT
Tekla Common - Bottom elevation: +56.768; Top elevation: +56.972; Phase: 82; Class: 100
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 204.5 mm; Width: 100 mm; Length: 300 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A716
BaseQuantities - Width: 204.497 mm; NetArea: 0.246631 m2; GrossArea: 0.061349 m2; CrossSectionArea: 0.01 m2; NetVolume: 0.00468324 m3; GrossVolume: 0.00621 m3

# IfcPlate: PLT12*122.7 (5)
In: Undefined
Description: PLT12*122.7; Material: STEEL/S355JR
Tekla Quantity - Weight: 2.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24.5 m2; Net surface area: 0.1 m2; Height: 122.7 mm; Width: 12 mm; Length: 225.8 mm
Tekla Common - Bottom elevation: +52.178; Top elevation: +52.190; Phase: 1; Class: 2
Pset_PlateCommon - LoadBearing: yes; Reference: A741
BaseQuantities - Width: 122.7 mm; NetArea: 0.0615536 m2; GrossArea: 0.0277057 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.000321668 m3; GrossVolume: 0.000321668 m3

# IfcPlate: PLT12*355 (2)
In: Undefined
Description: PLT12*355; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +52.183; Top elevation: +52.659; Phase: 1; Class: 99
Tekla Quantity - Weight: 12.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 22.6 m2; Net surface area: 0.3 m2; Height: 355 mm; Width: 12 mm; Length: 504 mm
Pset_PlateCommon - LoadBearing: yes; Reference: p109
BaseQuantities - Width: 354.988 mm; NetArea: 0.282048 m2; GrossArea: 0.178921 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00158983 m3; GrossVolume: 0.00158983 m3

# IfcPlate: PLT16*356 (3)
In: Undefined
Description: PLT16*356; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +53.746; Top elevation: +53.762; Phase: 11; Class: 2
Tekla Quantity - Weight: 20.1 kg; Volume: 0 m3; Gross footprint area: 0.2 m2; Area per tons: 17.1 m2; Net surface area: 0.3 m2; Height: 356 mm; Width: 16 mm; Length: 450 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A753
BaseQuantities - Width: 356 mm; NetArea: 0.346192 m2; GrossArea: 0.1602 m2; CrossSectionArea: 0.000256 m2; NetVolume: 0.0025632 m3; GrossVolume: 0.0025632 m3

# IfcPlate: PLT16*920, Dummy_Beam
In: Undefined
Description: PLT16*920; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +55.775; Top elevation: +56.695; Phase: 3; Class: 2
Tekla Quantity - Weight: 1933.6 kg; Volume: 0.2 m3; Gross footprint area: 0.3 m2; Area per tons: 16.2 m2; Net surface area: 31.4 m2; Height: 920 mm; Width: 16 mm; Length: 16734 mm
Pset_PlateCommon - LoadBearing: yes; Reference: Dummy9001
BaseQuantities - Width: 920 mm; NetArea: 31.3555 m2; GrossArea: 15.3953 m2; CrossSectionArea: 0.000256 m2; NetVolume: 0.246324 m3; GrossVolume: 0.246324 m3

# IfcPlate: PLT25*1100, Dummy_Plate
In: Undefined
Description: PLT25*1100; Material: MISCELLANEOUS/ZERO
Tekla Common - Bottom elevation: +55.085; Top elevation: +56.185; Phase: 12; Class: 2
Tekla Quantity - Weight: 0 kg; Volume: 0.4 m3; Gross footprint area: 0.3 m2; Net surface area: 37.7 m2; Height: 1100 mm; Width: 25 mm; Length: 16734 mm
Pset_PlateCommon - LoadBearing: yes; Reference: m695
BaseQuantities - Width: 1100 mm; NetArea: 37.7065 m2; GrossArea: 18.4074 m2; CrossSectionArea: 0.000625 m2; NetVolume: 0.460185 m3; GrossVolume: 0.460185 m3

# IfcPlate: PLT3*964, DUMMY
In: Undefined
Description: PLT3*964; Material: STEEL/S355JR
Tekla Quantity - Weight: 26.8 kg; Volume: 0 m3; Gross footprint area: 1.1 m2; Area per tons: 85.3 m2; Net surface area: 2.3 m2; Height: 964 mm; Width: 3 mm; Length: 1180 mm
Tekla Common - Bottom elevation: +52.699; Top elevation: +52.702; Phase: 11; Class: 2
Pset_PlateCommon - LoadBearing: yes; Reference: A803
BaseQuantities - Width: 964.001 mm; NetArea: 2.28791 m2; GrossArea: 1.13752 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.00341256 m3; GrossVolume: 0.00341256 m3

# IfcPlate: PLT32*316.4 (6)
In: Undefined
Description: PLT32*316.4; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +56.894; Top elevation: +56.926; Phase: 11; Class: 2
Tekla Quantity - Weight: 35 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 9.2 m2; Net surface area: 0.3 m2; Height: 316.4 mm; Width: 32 mm; Length: 440 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A783
BaseQuantities - Width: 316.4 mm; NetArea: 0.326842 m2; GrossArea: 0.139216 m2; CrossSectionArea: 0.001024 m2; NetVolume: 0.00445491 m3; GrossVolume: 0.00445491 m3

# IfcPlate: PLT32*366 (3)
In: Undefined
Description: PLT32*366; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +51.176; Top elevation: +51.616; Phase: 11; Class: 2
Tekla Quantity - Weight: 40.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 9.2 m2; Net surface area: 0.3 m2; Height: 366 mm; Width: 32 mm; Length: 440 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A784
BaseQuantities - Width: 366 mm; NetArea: 0.373664 m2; GrossArea: 0.16104 m2; CrossSectionArea: 0.001024 m2; NetVolume: 0.00515328 m3; GrossVolume: 0.00515328 m3

# IfcPlate: PLT6*1089 (2)
In: Undefined
Description: PLT6*1089; Material: Undefined/Vitex W80HR
Tekla Common - Bottom elevation: +57.270; Top elevation: +57.276; Phase: 3; Class: 8
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Height: 1089 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - Width: 1089 mm; CrossSectionArea: 0.000036 m2
Name | Gross footprint area (m2) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
Mesh | 2.5 | 4.8 | 2338 | A755 | 4.94491 | 2.54608 | 0.0147034 | 0.0151445
Mesh | 4.1 | 8.2 | 3740 | A766 | 8.18299 | 4.07286 | 0.0243712 | 0.0243712

# IfcPlate: PLT6*1092 (2)
In: Undefined
Description: PLT6*1092; Material: Undefined/Vitex W80HR
Tekla Common - Bottom elevation: +57.270; Top elevation: +57.276; Phase: 3; Class: 8
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Height: 1092 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - Width: 1092 mm; CrossSectionArea: 0.000036 m2
Name | Gross footprint area (m2) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
Mesh | 2.5 | 5 | 2338 | A756 | 4.95718 | 2.5531 | 0.0147401 | 0.0151866
Mesh | 4.1 | 8.2 | 3740 | A767 | 8.20546 | 4.08408 | 0.0244385 | 0.0244385

# IfcPlate: PLT6*1383.7 (2)
In: Undefined
Description: PLT6*1383.7; Material: Undefined/Vitex W80HR
Tekla Common - Bottom elevation: +57.270; Top elevation: +57.276; Phase: 3; Class: 8
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 2.7 m2; Net surface area: 5.4 m2; Height: 1383.7 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - Width: 1383.68 mm; CrossSectionArea: 0.000036 m2
Name | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
Mesh | 1978 | A763 | 5.44596 | 2.73692 | 0.0162098
Mesh | 1966 | A761 | 5.41679 | 2.72031 | 0.0161231

# IfcPlate: PLT6*1440 (6)
In: Undefined
Description: PLT6*1440; Material: Undefined/Vitex W80HR
Tekla Common - Bottom elevation: +57.270; Top elevation: +57.276; Phase: 3; Class: 8
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 2.8 m2; Net surface area: 5.7 m2; Height: 1440 mm; Width: 6 mm; Length: 1978 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - Width: 1440 mm; GrossArea: 2.84832 m2; CrossSectionArea: 0.000036 m2
Name | Reference | NetArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x Mesh | A769 | 5.70196 | 0.0169828
2 x Mesh | A764 | 5.66945 | 0.0168782
2 x Mesh | A760 | 5.73766 | 0.0170899

# IfcPlate: PLT6*1577 (2)
In: Undefined
Description: PLT6*1577; Material: Undefined/Vitex W80HR
Tekla Common - Bottom elevation: +57.270; Top elevation: +57.276; Phase: 3; Class: 8
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 4.5 m2; Net surface area: 9 m2; Height: 1577 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - Width: 1577 mm; CrossSectionArea: 0.000036 m2
Name | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
Mesh | 2890 | A758 | 9.1188 | 4.55753 | 0.0271923
Mesh | 2833.7 | A765 | 8.9584 | 4.46875 | 0.0267131

# IfcPlate: PLT6*1586 (2)
In: Undefined
Description: PLT6*1586; Material: Undefined/Vitex W80HR
Tekla Common - Bottom elevation: +57.270; Top elevation: +57.276; Phase: 3; Class: 8
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Height: 1586 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - Width: 1586 mm; CrossSectionArea: 0.000036 m2
Name | Gross footprint area (m2) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
Mesh | 4.6 | 9.2 | 2890 | A759 | 9.17054 | 4.58354 | 0.0273469
Mesh | 4.5 | 9 | 2833.7 | A768 | 9.00743 | 4.49425 | 0.0268596

# IfcPlate: PLT6*978 (4)
In: Undefined
Description: PLT6*978; Material: Undefined/Vitex W80HR
Tekla Common - Bottom elevation: +57.270; Top elevation: +57.276; Phase: 3; Class: 8
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Height: 978 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - Width: 978 mm; CrossSectionArea: 0.000036 m2
Name | Gross footprint area (m2) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x Mesh | 2.2 | 4.4 | 2338 | A757 | 4.44452 | 2.28656 | 0.0131992 | 0.0134823
2 x Mesh | 3.6 | 7.3 | 3740 | A762 | 7.33503 | 3.65772 | 0.0218278 | 0.0218278

# IfcPlate: PLT8*170 (4)
In: Undefined
Description: PLT8*170; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +53.767; Top elevation: +53.937; Phase: 11; Class: 2
Tekla Quantity - Weight: 2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 34.7 m2; Net surface area: 0.1 m2; Height: 170 mm; Width: 8 mm; Length: 188 mm
Pset_PlateCommon - LoadBearing: yes; Reference: A805
BaseQuantities - Width: 170 mm; NetArea: 0.069648 m2; GrossArea: 0.03196 m2; CrossSectionArea: 0.000064 m2; NetVolume: 0.00025568 m3; GrossVolume: 0.00025568 m3
