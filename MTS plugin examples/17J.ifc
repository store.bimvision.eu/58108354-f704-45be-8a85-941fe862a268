Properties of the parts of a building model (IFC2X3), part 15 of 16

# IfcElementAssembly (3904)
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Steel Assembly | RIGID_FRAME | 16.3 | +52.301 | +52.478 | 7-8/B-C | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +52.136 | +52.314 | 7-8/B-C | A626 | 66.0003
Steel Assembly | RIGID_FRAME | 16.3 | +51.972 | +52.149 | 7-8/B-C | A626 | 65.996
Steel Assembly | RIGID_FRAME | 16.3 | +51.810 | +51.984 | 7-8/B-C | A629 | 65.9935
Steel Assembly | RIGID_FRAME | 16.3 | +51.660 | +51.815 | 6-7/B-C | A628 | 65.9961
Steel Assembly | RIGID_FRAME | 16.3 | +51.512 | +51.689 | 6-7/B-C | A626 | 65.998
Steel Assembly | RIGID_FRAME | 16.3 | +51.347 | +51.524 | 6-7/B-C | A626 | 66
Steel Assembly | RIGID_FRAME | 6.1 | +51.022 | +51.228 | 5-6/D-E | A611 | 66.1466
Steel Assembly | RIGID_FRAME | 6.1 | +55.443 | +55.620 | 10-11/D-E | A605 | 66.0298
Steel Assembly | RIGID_FRAME | 6.1 | +55.278 | +55.455 | 10-11/D-E | A605 | 66.0298
Steel Assembly | RIGID_FRAME | 6.1 | +55.116 | +55.291 | 10-11/D-E | A606 | 66.0307
Steel Assembly | RIGID_FRAME | 6.1 | +54.951 | +55.126 | 10-11/D-E | A606 | 66.0307
Steel Assembly | RIGID_FRAME | 6.1 | +54.787 | +54.961 | 10-11/D-E | A608 | 66.0315
Steel Assembly | RIGID_FRAME | 6.1 | +54.613 | +54.792 | 9-10/D-E | A609 | 66.0289
Steel Assembly | RIGID_FRAME | 6.1 | +54.451 | +54.628 | 9-10/D-E | A605 | 66.0298
Steel Assembly | RIGID_FRAME | 6.1 | +54.286 | +54.463 | 9-10/D-E | A605 | 66.0298
Steel Assembly | RIGID_FRAME | 6.1 | +54.121 | +54.298 | 9-10/D-E | A605 | 66.0298
Steel Assembly | RIGID_FRAME | 6.1 | +53.956 | +54.134 | 9-10/D-E | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +53.795 | +53.969 | 9-10/D-E | A608 | 66.0315
Steel Assembly | RIGID_FRAME | 6.1 | +53.621 | +53.800 | 8-9/D-E | A609 | 66.0289
Steel Assembly | RIGID_FRAME | 6.1 | +53.458 | +53.636 | 8-9/D-E | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +53.294 | +53.471 | 8-9/D-E | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +53.129 | +53.306 | 8-9/D-E | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +52.964 | +53.141 | 8-9/D-E | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +52.803 | +52.976 | 8-9/D-E | A608 | 66.0336
Steel Assembly | RIGID_FRAME | 6.1 | +52.629 | +52.808 | 7-8/D-E | A609 | 66.0289
Steel Assembly | RIGID_FRAME | 6.1 | +52.466 | +52.643 | 7-8/D-E | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +52.301 | +52.479 | 7-8/D-E | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +52.136 | +52.314 | 7-8/D-E | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +51.972 | +52.149 | 7-8/D-E | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +51.810 | +51.984 | 7-8/D-E | A608 | 66.0336
Steel Assembly | RIGID_FRAME | 6.1 | +51.660 | +51.816 | 6-7/D-E | A607 | 66.0326
Steel Assembly | RIGID_FRAME | 6.1 | +51.512 | +51.689 | 6-7/D-E | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +51.347 | +51.524 | 6-7/D-E | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +51.197 | +51.359 | 6/D-E | A604 | 66.0412
Steel Assembly | RIGID_FRAME | 6.1 | +55.443 | +55.620 | 10-11/A-B | A605 | 66.0298
Steel Assembly | RIGID_FRAME | 6.1 | +55.278 | +55.455 | 10-11/A-B | A605 | 66.0298
Steel Assembly | RIGID_FRAME | 6.1 | +55.116 | +55.291 | 10-11/A-B | A606 | 66.0307
Steel Assembly | RIGID_FRAME | 6.1 | +54.951 | +55.126 | 10-11/A-B | A606 | 66.0307
Steel Assembly | RIGID_FRAME | 6.1 | +54.787 | +54.961 | 10-11/A-B | A608 | 66.0315
Steel Assembly | RIGID_FRAME | 6.1 | +54.613 | +54.792 | 9-10/A-B | A609 | 66.0289
Steel Assembly | RIGID_FRAME | 6.1 | +54.451 | +54.628 | 9-10/A-B | A605 | 66.0298
Steel Assembly | RIGID_FRAME | 6.1 | +54.286 | +54.463 | 9-10/A-B | A605 | 66.0298
Steel Assembly | RIGID_FRAME | 6.1 | +54.121 | +54.298 | 9-10/A-B | A605 | 66.0298
Steel Assembly | RIGID_FRAME | 6.1 | +53.956 | +54.134 | 9-10/A-B | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +53.795 | +53.969 | 9-10/A-B | A608 | 66.0315
Steel Assembly | RIGID_FRAME | 6.1 | +53.621 | +53.800 | 8-9/A-B | A609 | 66.0289
Steel Assembly | RIGID_FRAME | 6.1 | +53.458 | +53.636 | 8-9/A-B | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +53.294 | +53.471 | 8-9/A-B | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +53.129 | +53.306 | 8-9/A-B | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +52.964 | +53.141 | 8-9/A-B | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +52.803 | +52.976 | 8-9/A-B | A608 | 66.0336
Steel Assembly | RIGID_FRAME | 6.1 | +52.629 | +52.808 | 7-8/A-B | A609 | 66.0289
Steel Assembly | RIGID_FRAME | 6.1 | +52.466 | +52.643 | 7-8/A-B | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +52.301 | +52.479 | 7-8/A-B | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +52.136 | +52.314 | 7-8/A-B | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +51.972 | +52.149 | 7-8/A-B | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +51.810 | +51.984 | 7-8/A-B | A608 | 66.0336
Steel Assembly | RIGID_FRAME | 6.1 | +51.660 | +51.816 | 6-7/A-B | A607 | 66.0326
Steel Assembly | RIGID_FRAME | 6.1 | +51.512 | +51.689 | 6-7/A-B | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +51.347 | +51.524 | 6-7/A-B | A605 | 66.0316
Steel Assembly | RIGID_FRAME | 6.1 | +51.197 | +51.359 | 6/A-B | A604 | 66.0412
2 x Steel Assembly |  | 0 | +51.017 | +52.055 | 5/C-D | A164 | 60
2 x Steel Assembly |  | 0 | +50.538 | +51.600 | 4-5/C-D | A163 | 61.9407
2 x Steel Assembly |  | 0 | +51.017 | +52.055 | 5/D-E | A164 | 60
2 x Steel Assembly |  | 0 | +50.538 | +51.600 | 4-5/D-E | A163 | 61.9407
2 x Steel Assembly |  | 0 | +51.017 | +52.055 | 5/B-C | A164 | 60
2 x Steel Assembly |  | 0 | +50.538 | +51.600 | 4-5/B-C | A163 | 61.9407
2 x Steel Assembly |  | 0 | +50.538 | +51.600 | 4-5/A-B | A163 | 61.9407
Steel Assembly |  | 0 | +52.005 | +52.256 | 5-6/A-B | A562 | 34
Steel Assembly |  | 0 | +51.501 | +51.755 | 5-6/A-B | A561 | 34
Steel Assembly | RIGID_FRAME | 104.1 | +51.102 | +51.206 | 6/A-E | A305 | 50
Steel Assembly | RIGID_FRAME | 86.8 | +51.215 | +51.926 | 6-7/C-D | A356 | 75
Steel Assembly | RIGID_FRAME | 37.1 | +53.211 | +53.351 | 6-7/C | A814 | 847.6
Steel Assembly | RIGID_FRAME | 62.1 | +53.088 | +53.275 | 6-7/C | A820 | 1347.6
Rubber |  | 0 | +52.937 | +52.965 | 5/C | A774 | 10
Rubber |  | 0 | +52.778 | +52.803 | 4-5/C | A773 | 10
Steel Assembly | RIGID_FRAME | 86.8 | +51.215 | +51.926 | 6-7/D-E | A349 | 75
Steel Assembly | RIGID_FRAME | 86.8 | +51.215 | +51.926 | 6-7/D-E | A347 | 75
Steel Assembly | RIGID_FRAME | 86.8 | +51.215 | +51.926 | 6-7/A-B | A348 | 75
Steel Assembly | RIGID_FRAME | 86.8 | +51.215 | +51.926 | 6-7/A-B | A346 | 75
Steel Assembly | RIGID_FRAME | 56.1 | +52.964 | +53.145 | 5-6/C | A823 | 1347.6
Steel Assembly | RIGID_FRAME | 1.9 | +52.960 | +52.969 | 5/C | A821 | 5
Rubber_Curtain |  | 0 | +52.660 | +53.379 | 6-7/C | A776 | 10
Steel Assembly | RIGID_FRAME | 13.9 | +52.405 | +52.774 | 4/C | A818 | 5
Steel Assembly | RIGID_FRAME | 11.5 | +53.294 | +53.378 | 6-7/C | A815 | 173.8
2 x Steel Assembly | RIGID_FRAME | 3.2 | +52.721 | +52.885 | 6-7/C | A687 | 30
2 x Steel Assembly | RIGID_FRAME | 3.9 | +52.322 | +52.514 | 4-5/C | A689 | 30
Steel Assembly | RIGID_FRAME | 1.9 | +52.409 | +52.459 | 4/C | A819 | 5
Rubber_Curtain |  | 0 | +52.055 | +52.465 | 4/C | A777 | 10
2 x Steel Assembly | RIGID_FRAME | 3.4 | +52.798 | +52.947 | 4-5/C | A817 | 5
Steel Assembly | RIGID_FRAME | 1.9 | +52.788 | +52.797 | 4-5/C | A821 | 5
2 x Steel Assembly | RIGID_FRAME | 0.7 | +53.010 | +53.299 | 6-7/C | A816 | 5
Steel Assembly | RIGID_FRAME | 1.9 | +53.324 | +53.374 | 6-7/C | A819 | 5
2 x Steel Assembly | RIGID_FRAME | 2.1 | +52.845 | +52.967 | 6-7/C | A688 | 30
2 x Skirt Rubber |  | 0 | +52.275 | +53.016 | 4-7/C | A779 | 10
2 x Steel Assembly | RIGID_FRAME | 3.2 | +52.598 | +52.761 | 5-6/C | A687 | 30
2 x Steel Assembly | RIGID_FRAME | 3.2 | +52.474 | +52.638 | 4-6/C | A687 | 30
Steel Assembly |  | 0 | +57.032 | +57.092 | 17-18/A-B | A676 | 60
Steel Assembly |  | 0 | +56.853 | +56.913 | 17-18/A-B | A676 | 60
Steel Assembly |  | 0 | +57.032 | +57.092 | 17-18/D-E | A676 | 60
Steel Assembly |  | 0 | +56.853 | +56.913 | 17-18/D-E | A676 | 60
Steel Assembly |  | 0 | +57.032 | +57.092 | 17-18/C-D | A676 | 60
Steel Assembly |  | 0 | +56.853 | +56.913 | 17-18/C-D | A676 | 60
Steel Assembly | RIGID_FRAME | 18 | +56.325 | +56.484 | 12/D-E | A735 | 200
Steel Assembly | RIGID_FRAME | 18 | +56.325 | +56.484 | 12/C-D | A735 | 200
Steel Assembly | RIGID_FRAME | 18 | +56.325 | +56.484 | 12/C-D | A732 | 200
2 x Steel Assembly | RIGID_FRAME | 18 | +56.325 | +56.484 | 12/B-C | A735 | 200
Steel Assembly | RIGID_FRAME | 1576.3 | +55.735 | +55.775 | 17-18/A-E | Dummy9002 | 40
Steel Assembly | RIGID_FRAME | 1576.3 | +56.695 | +56.735 | 17-18/A-E | Dummy9003 | 40
Steel Assembly | RIGID_FRAME | 1933.6 | +55.775 | +56.695 | 17-18/A-E | Dummy9001 | 16
Steel Assembly | RIGID_FRAME | 18 | +56.325 | +56.484 | 12/A-B | A735 | 200.001
Steel Assembly | RIGID_FRAME | 18 | +50.815 | +50.977 | 6/A-B | A770 | 200
Steel Assembly | RIGID_FRAME | 18 | +51.403 | +51.565 | 7/A-B | A730 | 200
Steel Assembly | RIGID_FRAME | 18 | +53.389 | +53.551 | 9/A-B | A730 | 200
Steel Assembly | RIGID_FRAME | 44.3 | +50.368 | +52.407 | 13/A-B | A394 | 165.1
Steel Assembly | RIGID_FRAME | 44.3 | +50.368 | +52.407 | 13/D-E | A394 | 165.1
Steel Assembly | RIGID_FRAME | 18 | +54.381 | +54.543 | 10/A-B | A730 | 200
Steel Assembly | RIGID_FRAME | 104.1 | +51.710 | +51.814 | 7/A-E | A303 | 50
Steel Assembly | RIGID_FRAME | 104.1 | +52.682 | +52.785 | 8/A-E | A303 | 50
Steel Assembly | RIGID_FRAME | 146.7 | +51.802 | +52.918 | 7-8/C-D | A342 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +51.802 | +52.918 | 7-8/D-E | A364 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +51.802 | +52.918 | 7-8/D-E | A337 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +51.802 | +52.918 | 7-8/A-B | A363 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +51.802 | +52.918 | 7-8/A-B | A336 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +51.802 | +52.918 | 7-8/B-C | A343 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +51.802 | +52.918 | 7-8/C-D | A343 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +51.802 | +52.918 | 7-8/B-C | A342 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +54.779 | +55.895 | 10-11/C-D | A344 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +54.779 | +55.895 | 10-11/D-E | A339 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +54.779 | +55.895 | 10-11/A-B | A362 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +54.779 | +55.895 | 10-11/A-B | A338 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +54.779 | +55.895 | 10-11/B-C | A345 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +54.779 | +55.895 | 10-11/C-D | A345 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +54.779 | +55.895 | 10-11/B-C | A344 | 75
Steel Assembly | RIGID_FRAME | 104.1 | +53.695 | +53.799 | 9/A-E | A303 | 50
Steel Assembly | RIGID_FRAME | 104.1 | +54.666 | +54.770 | 10/A-E | A304 | 50
Steel Assembly | RIGID_FRAME | 146.7 | +53.787 | +54.903 | 9-10/C-D | A342 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +53.787 | +54.903 | 9-10/D-E | A361 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +53.787 | +54.903 | 9-10/D-E | A337 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +53.787 | +54.903 | 9-10/A-B | A360 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +53.787 | +54.903 | 9-10/A-B | A336 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +53.787 | +54.903 | 9-10/B-C | A343 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +53.787 | +54.903 | 9-10/C-D | A343 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +53.787 | +54.903 | 9-10/B-C | A342 | 75
Steel Assembly | RIGID_FRAME | 104.1 | +52.703 | +52.806 | 8/A-E | A303 | 50
Steel Assembly | RIGID_FRAME | 104.1 | +53.674 | +53.778 | 9/A-E | A303 | 50
Steel Assembly | RIGID_FRAME | 146.7 | +52.795 | +53.911 | 8-9/C-D | A340 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +52.795 | +53.911 | 8-9/D-E | A359 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +52.795 | +53.911 | 8-9/D-E | A335 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +52.795 | +53.911 | 8-9/A-B | A358 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +52.795 | +53.911 | 8-9/A-B | A334 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +52.795 | +53.911 | 8-9/B-C | A341 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +52.795 | +53.911 | 8-9/C-D | A341 | 75
Steel Assembly | RIGID_FRAME | 146.7 | +52.795 | +53.911 | 8-9/B-C | A340 | 75
Steel Assembly | RIGID_FRAME | 86.8 | +51.215 | +51.926 | 6-7/B-C | A357 | 75
Steel Assembly | RIGID_FRAME | 86.8 | +51.215 | +51.926 | 6-7/C-D | A357 | 75
Steel Assembly |  | 0 | +52.806 | +53.833 | 7-8/A-B | A560 | 34
Steel Assembly |  | 0 | +52.308 | +53.334 | 7-8/A-B | A560 | 34
Steel Assembly |  | 0 | +52.219 | +52.840 | 6-7/A-B | A559 | 34
Steel Assembly |  | 0 | +51.721 | +52.342 | 6-7/A-B | A559 | 34
Steel Assembly | RIGID_FRAME | 23.9 | +50.944 | +51.234 | 5/B-D | A40 | 289.898
Steel Assembly |  | 0 | +50.781 | +50.841 | 4-5/B-C | A675 | 60
Steel Assembly |  | 0 | +50.584 | +50.644 | 4-5/B-C | A675 | 60
Steel Assembly |  | 0 | +50.387 | +50.447 | 4-5/B-C | A675 | 60
Steel Assembly |  | 0 | +50.781 | +50.841 | 4-5/C-D | A675 | 60
Steel Assembly |  | 0 | +50.584 | +50.644 | 4-5/C-D | A675 | 60
Steel Assembly |  | 0 | +50.387 | +50.447 | 4-5/C-D | A675 | 60
Steel Assembly |  | 0 | +50.781 | +50.841 | 4-5/A-B | A675 | 60
Steel Assembly |  | 0 | +50.584 | +50.644 | 4-5/A-B | A675 | 60
Steel Assembly |  | 0 | +50.387 | +50.447 | 4-5/A-B | A675 | 60
Steel Assembly |  | 0 | +50.781 | +50.841 | 4-5/D-E | A675 | 60
Steel Assembly |  | 0 | +50.584 | +50.644 | 4-5/D-E | A675 | 60
Steel Assembly |  | 0 | +50.387 | +50.447 | 4-5/D-E | A675 | 60
Steel Assembly | RIGID_FRAME | 106.2 | +50.917 | +51.017 | 5/A-E | A302 | 50
Steel Assembly | RIGID_FRAME | 209.2 | +50.242 | +56.325 | 12/A-B | A20 | 270.708
Steel Assembly | RIGID_FRAME | 238.2 | +50.280 | +56.085 | 12/C-E | A187 | 289.899
Steel Assembly | RIGID_FRAME | 209.2 | +50.242 | +56.325 | 12/D-E | A20 | 270.707
Steel Assembly | RIGID_FRAME | 213.8 | +50.264 | +55.134 | 11/C-E | A186 | 301.803
Steel Assembly | RIGID_FRAME | 178.3 | +50.242 | +55.374 | 11/D-E | A19 | 275.95
Steel Assembly | RIGID_FRAME | 183.2 | +50.266 | +54.141 | 10/C-E | A185 | 254.97
Steel Assembly | RIGID_FRAME | 143.3 | +50.242 | +54.381 | 10/D-E | A18 | 301.018
Steel Assembly | RIGID_FRAME | 42.1 | +50.242 | +51.403 | 7/D-E | A16 | 200
Steel Assembly | RIGID_FRAME | 42.1 | +50.242 | +51.403 | 7/A-B | A16 | 200
Steel Assembly | RIGID_FRAME | 23.3 | +50.242 | +50.815 | 6/D-E | A15 | 200
Steel Assembly | RIGID_FRAME | 23.3 | +50.242 | +50.815 | 6/A-B | A15 | 200
Steel Assembly | RIGID_FRAME | 86.8 | +51.215 | +51.926 | 6-7/B-C | A356 | 75
Steel Assembly | RIGID_FRAME | 104.1 | +51.689 | +51.793 | 7/A-E | A304 | 50
2 x Steel Assembly | RIGID_FRAME | 19.5 | +52.264 | +54.141 | 10/C-E | A284 | 80
2 x Steel Assembly | RIGID_FRAME | 13 | +52.715 | +52.785 | 11/C-E | A190 | 70
2 x Steel Assembly | RIGID_FRAME | 36.5 | +52.795 | +55.134 | 11/C-E | A432 | 100
2 x Steel Assembly | RIGID_FRAME | 13 | +53.191 | +53.261 | 12/C-E | A191 | 70
2 x Steel Assembly | RIGID_FRAME | 41.4 | +53.271 | +56.085 | 12/C-E | A433 | 100
Steel Assembly | RIGID_FRAME | 104.1 | +51.123 | +51.227 | 6/A-E | A303 | 50
Steel Assembly | RIGID_FRAME | 9.9 | +56.095 | +56.325 | 12/C | A181 | 90
2 x Steel Assembly | RIGID_FRAME | 7.4 | +56.095 | +56.325 | 12/C-D | A182 | 90
2 x Steel Assembly | RIGID_FRAME | 7.4 | +56.095 | +56.325 | 12/B-C | A182 | 90
Steel Assembly | RIGID_FRAME | 9.9 | +55.144 | +55.374 | 11/C | A181 | 90
2 x Steel Assembly | RIGID_FRAME | 7.4 | +55.144 | +55.374 | 11/C-D | A182 | 90
2 x Steel Assembly | RIGID_FRAME | 7.4 | +55.144 | +55.374 | 11/B-C | A182 | 90
Steel Assembly | RIGID_FRAME | 9.9 | +54.151 | +54.381 | 10/C | A181 | 90
2 x Steel Assembly | RIGID_FRAME | 7.4 | +54.151 | +54.381 | 10/B-C | A182 | 90
2 x Steel Assembly | RIGID_FRAME | 7.4 | +54.151 | +54.381 | 10/C-D | A182 | 90
Steel Assembly | RIGID_FRAME | 9.9 | +53.159 | +53.389 | 9/C | A181 | 90
2 x Steel Assembly | RIGID_FRAME | 7.4 | +53.159 | +53.389 | 9/B-C | A182 | 90
2 x Steel Assembly | RIGID_FRAME | 7.4 | +53.159 | +53.389 | 9/C-D | A182 | 90
Steel Assembly | RIGID_FRAME | 9.9 | +52.166 | +52.396 | 8/C | A181 | 90
2 x Steel Assembly | RIGID_FRAME | 7.4 | +52.166 | +52.396 | 8/B-C | A182 | 90
2 x Steel Assembly | RIGID_FRAME | 7.4 | +52.166 | +52.396 | 8/C-D | A182 | 90
2 x Steel Assembly | RIGID_FRAME | 282.7 | +51.173 | +51.403 | 7/A-E | A180 | 90
2 x Steel Assembly | RIGID_FRAME | 7.4 | +51.173 | +51.403 | 7/B-C | A182 | 90
2 x Steel Assembly | RIGID_FRAME | 7.4 | +51.173 | +51.403 | 7/C-D | A182 | 90
2 x Steel Assembly | RIGID_FRAME | 282.7 | +50.585 | +50.815 | 6/A-E | A180 | 90
2 x Steel Assembly | RIGID_FRAME | 7.4 | +50.585 | +50.815 | 6/B-C | A182 | 90
2 x Steel Assembly | RIGID_FRAME | 7.4 | +50.585 | +50.815 | 6/C-D | A182 | 90

# IfcMechanicalFastener: Bolt assembly (14275)
In: Undefined
Tekla Bolt - Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) | Material | Washer count | Washer type | Washer name | Nut count | Nut type | Nut name | Slotted hole y (mm) | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt count | Bolt length (mm) | Bolt standard | Bolt Name
14 x Bolt assembly | 20 | 65 | 8.8XOX | 2 | FLAT-E | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 2 | 65 | 8.8XOX | BOLTM20*65
4568 x Bolt assembly | 12 | 8 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 1 | 8 | 8.8XOX | BOLTM12*25
159 x Bolt assembly | 16 | 6 | 4.8XOX | 0 | FLAT-E | WASHERM16-FLAT-E | 0 | GR4-HEX | NUTM16-GR4-HEX | 0 | 0 | 18 | 1 | 6 | 4.8XOX | BOLTM16*30
391 x Bolt assembly | 12 | 10 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 1 | 10 | 8.8XOX | BOLTM12*25
52 x Bolt assembly | 12 | 20 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 1 | 20 | 8.8XOX | BOLTM12*25
70 x Bolt assembly | 12 | 10 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 2 | 10 | 8.8XOX | BOLTM12*25
68 x Bolt assembly | 20 | 60 | 8.8XOX | 1 | FLAT-E | WASHERM20-FLAT-E | 1 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 1 | 60 | 8.8XOX | BOLTM20*60
8 x Bolt assembly | 20 | 60 | 8.8XOX | 2 | FLAT-E | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 28 | 22 | 2 | 60 | 8.8XOX | BOLTM20*60
181 x Bolt assembly | 10 | 8 | 8.8XOX | 0 | FLAT-E | WASHERM10-FLAT-E | 0 | GR8-HEX | NUTM10-GR8-HEX | 0 | 0 | 12 | 1 | 8 | 8.8XOX | BOLTM10*20
8 x Bolt assembly | 16 | 40 | 4.8XOX | 1 | FLAT-E | WASHERM16-FLAT-E | 1 | GR4-HEX | NUTM16-GR4-HEX | 0 | 0 | 18 | 1 | 40 | 4.8XOX | BOLTM16*40
36 x Bolt assembly | 10 | 10 | 8.8XOX | 0 | FLAT-E | WASHERM10-FLAT-E | 0 | GR8-HEX | NUTM10-GR8-HEX | 0 | 0 | 12 | 1 | 10 | 8.8XOX | BOLTM10*20
205 x Bolt assembly | 16 | 40 | 8.8XOX | 2 | FLAT-E | WASHERM16-FLAT-E | 2 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 2 | 40 | 8.8XOX | BOLTM16*40
6 x Bolt assembly | 12 | 35 | 4.8XOX | 1 | FLAT-E | WASHERM12-FLAT-E | 1 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 1 | 35 | 4.8XOX | BOLTM12*35
549 x Bolt assembly | 12 | 8 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 2 | 8 | 8.8XOX | BOLTM12*25
6 x Bolt assembly | 12 | 10.97 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 2 | 16 | 2 | 11 | 8.8XOX | BOLTM12*25
43 x Bolt assembly | 12 | 35 | 4.8XOX | 1 | FLAT-E | WASHERM12-FLAT-E | 1 | GR4-HEX | NUTM12-GR4-HEX | 0 | 2 | 16 | 1 | 35 | 4.8XOX | BOLTM12*35
30 x Bolt assembly | 16 | 13.9 | 8.8XOX | 0 | FLAT-E | WASHERM16-FLAT-E | 0 | GR8-HEX | NUTM16-GR8-HEX | 0 | 2 | 20 | 2 | 13.9 | 8.8XOX | BOLTM16*30
1294 x Bolt assembly | 12 | 4 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 1 | 4 | 8.8XOX | BOLTM12*25
104 x Bolt assembly | 20 | 50 | 8.8XOX | 1 | FLAT-E | WASHERM20-FLAT-E | 1 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 1 | 50 | 8.8XOX | BOLTM20*50
26 x Bolt assembly | 20 | 50 | 8.8XOX | 4 | FLAT-E | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 4 | 50 | 8.8XOX | BOLTM20*50
14 x Bolt assembly | 20 | 55 | 8.8XOX | 4 | FLAT-E | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 4 | 55 | 8.8XOX | BOLTM20*55
2 x Bolt assembly | 20 | 50 | 8.8XOX | 10 | FLAT-E | WASHERM20-FLAT-E | 10 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 10 | 50 | 8.8XOX | BOLTM20*50
8 x Bolt assembly | 12 | 12 | 4.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 1 | 12 | 4.8XOX | BOLTM12*25
247 x Bolt assembly | 20 | 55 | 8.8XOX | 2 | FLAT-E | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 2 | 55 | 8.8XOX | BOLTM20*55
4 x Bolt assembly | 12 | 10.9 | 4.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 4 | 11 | 4.8XOX | BOLTM12*25
240 x Bolt assembly | 16 | 50 | 4.8CSK_NH | 2 |  |  | 2 |  |  | 0 | 0 | 18 | 2 | 50 | 4.8CSK_NH
60 x Bolt assembly | 12 | 6 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 2 | 6 | 8.8XOX | BOLTM12*25
270 x Bolt assembly | 16 | 40 | 8.8XOX | 1 | FLAT-E | WASHERM16-FLAT-E | 1 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 1 | 40 | 8.8XOX | BOLTM16*40
6 x Bolt assembly | 12 | 35 | 4.8XOX | 8 | FLAT-E | WASHERM12-FLAT-E | 8 | GR4-HEX | NUTM12-GR4-HEX | 0 | 2 | 16 | 8 | 35 | 4.8XOX | BOLTM12*35
9 x Bolt assembly | 12 | 30 | 4.8XOX | 7 | FLAT-E | WASHERM12-FLAT-E | 7 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 7 | 30 | 4.8XOX | BOLTM12*30
6 x Bolt assembly | 16 | 45 | 8.8XOX | 1 | FLAT-E | WASHERM16-FLAT-E | 1 | GR8-HEX | NUTM16-GR8-HEX | 0 | 42 | 18 | 1 | 45 | 8.8XOX | BOLTM16*45
Bolt assembly | 16 | 13.59 | 8.8XOX | 0 | FLAT-E | WASHERM16-FLAT-E | 0 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 22 | 1 | 13.6 | 8.8XOX | BOLTM16*30
Bolt assembly | 16 | 13.95 | 8.8XOX | 0 | FLAT-E | WASHERM16-FLAT-E | 0 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 22 | 1 | 13.9 | 8.8XOX | BOLTM16*30
6 x Bolt assembly | 16 | 8 | 8.8XOX | 0 | FLAT-E | WASHERM16-FLAT-E | 0 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 22 | 1 | 8 | 8.8XOX | BOLTM16*30
6 x Bolt assembly | 20 | 10 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 7 | 10 | 8.8XOX | BOLTM20*40
221 x Bolt assembly | 12 | 6 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 1 | 6 | 8.8XOX | BOLTM12*25
226 x Bolt assembly | 16 | 40 | 4.8CSK_NH | 1 |  |  | 1 |  |  | 0 | 0 | 18 | 1 | 40 | 4.8CSK_NH
64 x Bolt assembly | 12 | 12 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 1 | 12 | 8.8XOX | BOLTM12*25
24 x Bolt assembly | 12 | 30 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 2 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 2 | 30 | 8.8XOX | BOLTM12*30
4 x Bolt assembly | 12 | 7.5 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 3 | 7.5 | 8.8XOX | BOLTM12*25
67 x Bolt assembly | 20 | 45 | 8.8XOX | 3 | FLAT-E | WASHERM20-FLAT-E | 3 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 3 | 45 | 8.8XOX | BOLTM20*45
18 x Bolt assembly | 16 | 50 | 8.8XOX | 4 | FLAT-E | WASHERM16-FLAT-E | 4 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 4 | 50 | 8.8XOX | BOLTM16*50
6 x Bolt assembly | 12 | 3 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 1 | 3 | 8.8XOX | BOLTM12*25
6 x Bolt assembly | 16 | 50 | 4.8XOX | 2 | FLAT-E | WASHERM16-FLAT-E | 2 | GR4-HEX | NUTM16-GR4-HEX | 22 | 0 | 18 | 2 | 50 | 4.8XOX | BOLTM16*50
24 x Bolt assembly | 20 | 125 | 8.8XOX | 1 | FLAT-E | WASHERM20-FLAT-E | 1 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 17.5 | 1 | 125 | 8.8XOX | BOLTM20*130
10 x Bolt assembly | 16 | 40 | 4.8XOX | 2 | FLAT-E | WASHERM16-FLAT-E | 2 | GR4-HEX | NUTM16-GR4-HEX | 0 | 0 | 18 | 2 | 40 | 4.8XOX | BOLTM16*40
6 x Bolt assembly | 12 | 7 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 2 | 7 | 8.8XOX | BOLTM12*25
36 x Bolt assembly | 12 | 4 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 2 | 4 | 8.8XOX | BOLTM12*25
Bolt assembly | 12 | 8.03 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 1 | 8 | 8.8XOX | BOLTM12*25
459 x Bolt assembly | 16 | 45 | 8.8XOX | 1 | FLAT-E | WASHERM16-FLAT-E | 1 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 1 | 45 | 8.8XOX | BOLTM16*45
47 x Bolt assembly | 20 | 50 | 8.8XOX | 3 | FLAT-E | WASHERM20-FLAT-E | 3 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 3 | 50 | 8.8XOX | BOLTM20*50
18 x Bolt assembly | 12 | 40 | 8.8XOX | 4 | FLAT-E | WASHERM12-FLAT-E | 2 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 2 | 40 | 8.8XOX | BOLTM12*40
184 x Bolt assembly | 20 | 50 | 8.8XOX | 2 | FLAT-E | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 2 | 50 | 8.8XOX | BOLTM20*50
18 x Bolt assembly | 12 | 35 | 8.8XOX | 1 | FLAT-E | WASHERM12-FLAT-E | 1 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 1 | 35 | 8.8XOX | BOLTM12*35
84 x Bolt assembly | 16 | 45 | 8.8XOX | 2 | FLAT-E | WASHERM16-FLAT-E | 1 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 1 | 45 | 8.8XOX | BOLTM16*45
14 x Bolt assembly | 16 | 45 | 4.8XOX | 1 | FLAT-E | WASHERM16-FLAT-E | 1 | GR4-HEX | NUTM16-GR4-HEX | 0 | 0 | 18 | 1 | 45 | 4.8XOX | BOLTM16*45
18 x Bolt assembly | 16 | 45 | 8.8XOX | 2 | FLAT-E | WASHERM16-FLAT-E | 2 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 2 | 45 | 8.8XOX | BOLTM16*45
3 x Bolt assembly | 20 | 55 | 8.8XOX | 6 | FLAT-E | WASHERM20-FLAT-E | 6 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 6 | 55 | 8.8XOX | BOLTM20*55
3 x Bolt assembly | 20 | 20 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 8 | 20 | 8.8XOX | BOLTM20*40
24 x Bolt assembly | 16 | 50 | 4.8XOX | 2 | FLAT-E | WASHERM16-FLAT-E | 2 | GR4-HEX | NUTM16-GR4-HEX | 0 | 0 | 18 | 2 | 50 | 4.8XOX | BOLTM16*50
44 x Bolt assembly | 12 | 30 | 8.8XOX | 2 | FLAT-E | WASHERM12-FLAT-E | 2 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 2 | 30 | 8.8XOX | BOLTM12*30
8 x Bolt assembly | 16 | 8 | 4.8XOX | 0 | FLAT-E | WASHERM16-FLAT-E | 0 | GR4-HEX | NUTM16-GR4-HEX | 0 | 0 | 20 | 1 | 8 | 4.8XOX | BOLTM16*30
8 x Bolt assembly | 16 | 8 | 4.8XOX | 0 | FLAT-E | WASHERM16-FLAT-E | 0 | GR4-HEX | NUTM16-GR4-HEX | 0 | 0 | 18 | 1 | 8 | 4.8XOX | BOLTM16*30
30 x Bolt assembly | 20 | 70 | 8.8XOX | 1 | FLAT-E | WASHERM20-FLAT-E | 1 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 1 | 70 | 8.8XOX | BOLTM20*70
30 x Bolt assembly | 10 | 10.9 | 8.8XOX | 0 | FLAT-E | WASHERM10-FLAT-E | 0 | GR8-HEX | NUTM10-GR8-HEX | 0 | 0 | 12 | 1 | 11 | 8.8XOX | BOLTM10*20
380 x Bolt assembly | 16 | 45 | 4.8CSK_NH | 1 |  |  | 1 |  |  | 0 | 0 | 18 | 1 | 45 | 4.8CSK_NH
Bolt assembly | 12 | 8.02 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 1 | 8 | 8.8XOX | BOLTM12*25
384 x Bolt assembly | 10 | 4 | 8.8XOX | 0 | FLAT-E | WASHERM10-FLAT-E | 0 | GR8-HEX | NUTM10-GR8-HEX | 0 | 0 | 6 | 1 | 4 | 8.8XOX | BOLTM10*20
117 x Bolt assembly | 10 | 8 | 8.8XOX | 0 | FLAT-E | WASHERM10-FLAT-E | 0 | GR8-HEX | NUTM10-GR8-HEX | 0 | 0 | 6 | 1 | 8 | 8.8XOX | BOLTM10*20
24 x Bolt assembly | 12 | 35 | 4.8XOX | 2 | FLAT-E | WASHERM12-FLAT-E | 2 | GR4-HEX | NUTM12-GR4-HEX | 0 | 2 | 16 | 2 | 35 | 4.8XOX | BOLTM12*35
6 x Bolt assembly | 12 | 35 | 4.8XOX | 4 | FLAT-E | WASHERM12-FLAT-E | 4 | GR4-HEX | NUTM12-GR4-HEX | 0 | 2 | 16 | 4 | 35 | 4.8XOX | BOLTM12*35
145 x Bolt assembly | 16 | 45 | 4.8XOX | 2 | FLAT-E | WASHERM16-FLAT-E | 2 | GR4-HEX | NUTM16-GR4-HEX | 0 | 0 | 18 | 2 | 45 | 4.8XOX | BOLTM16*45
33 x Bolt assembly | 16 | 50 | 8.8XOX | 1 | FLAT-E | WASHERM16-FLAT-E | 1 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 1 | 50 | 8.8XOX | BOLTM16*50
24 x Bolt assembly | 12 | 8 | 4.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 1 | 8 | 4.8XOX | BOLTM12*25
356 x Bolt assembly | 20 | 45 | 8.8XOX | 2 | FLAT-E | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 2 | 45 | 8.8XOX | BOLTM20*45
6 x Bolt assembly | 12 | 6 | 4.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 1 | 6 | 4.8XOX | BOLTM12*25
11 x Bolt assembly | 20 | 120 | 8.8XOX | 1 | FLAT-E | WASHERM20-FLAT-E | 1 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 17.5 | 1 | 120 | 8.8XOX | BOLTM20*120
4 x Bolt assembly | 8 | 64 | 8.8XOX | 4 | FLAT-E | WASHERM8-FLAT-E | 0 | GR8-HEX |  | 0 | 3.2 | 10 | 4 | 64 | 8.8XOX
4 x Bolt assembly | 24 | 90 | 8.8XOX | 2 | FLAT-E | WASHERM24-FLAT-E | 2 | GR8-HEX | NUTM24-GR8-HEX | 0 | 0 | 26 | 2 | 90 | 8.8XOX | BOLTM24*90
6 x Bolt assembly | 12 | 52 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 2 | 3.8 | 14 | 4 | 52 | 8.8XOX | BOLTM12*55
24 x Bolt assembly | 24 | 150 | 8.8XOX | 2 | FLAT-E | WASHERM24-FLAT-E | 2 | GR8-HEX | NUTM24-GR8-HEX | 0 | 0 | 26 | 2 | 150 | 8.8XOX | BOLTM24*150
6 x Bolt assembly | 24 | 90 | 8.8XOX | 4 | FLAT-E | WASHERM24-FLAT-E | 4 | GR8-HEX | NUTM24-GR8-HEX | 0 | 0 | 34 | 4 | 90 | 8.8XOX | BOLTM24*90
4 x Bolt assembly | 20 | 41 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 4 | 41 | 8.8XOX | BOLTM20*45
176 x Bolt assembly | 12 | 40 | 4.8XOX | 1 | FLAT-E | WASHERM12-FLAT-E | 1 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 1 | 40 | 4.8XOX | BOLTM12*40
6 x Bolt assembly | 12 | 30 | 8.8XOX | 1 | FLAT-E | WASHERM12-FLAT-E | 1 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 1 | 30 | 8.8XOX | BOLTM12*30
24 x Bolt assembly | 20 | 140 | 8.8XOX | 1 | FLAT-E | WASHERM20-FLAT-E | 1 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 1 | 140 | 8.8XOX | BOLTM20*140
8 x Bolt assembly | 20 | 9.2 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 3 | 9.2 | 8.8XOX | BOLTM20*40
8 x Bolt assembly | 20 | 14.2 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 3 | 14.2 | 8.8XOX | BOLTM20*40
22 x Bolt assembly | 24 | 20 | 8.8XOX | 0 | FLAT-E | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 0 | 26 | 4 | 20 | 8.8XOX | BOLTM24*50
12 x Bolt assembly | 10 | 100 | 8.8XOX | 0 | FLAT-E | WASHERM10-FLAT-E | 0 | GR8-HEX | NUTM10-GR8-HEX | 0 | 0 | 5 | 1 | 100 | 8.8XOX | BOLTM10*100
12 x Bolt assembly | 10 | 100 | 8.8XOX | 0 | FLAT-E | WASHERM10-FLAT-E | 0 | GR8-HEX | NUTM10-GR8-HEX | 0 | 0 | 12 | 1 | 100 | 8.8XOX | BOLTM10*100
12 x Bolt assembly | 36 | 102.2 | 8.8XOX | 0 | FLAT-E | WASHERM36-FLAT-E | 0 | GR8-HEX | NUTM36-GR8-HEX | 0 | 0 | 40 | 1 | 102.2 | 8.8XOX | BOLTM36*110
12 x Bolt assembly | 36 | 100 | 8.8XOX | 0 | FLAT-E | WASHERM36-FLAT-E | 0 | GR8-HEX | NUTM36-GR8-HEX | 0 | 0 | 41 | 1 | 100 | 8.8XOX | BOLTM36*100
3 x Bolt assembly | 24 | 16 | 8.8XOX | 0 | FLAT-E | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 0 | 26 | 8 | 16 | 8.8XOX | BOLTM24*50
3 x Bolt assembly | 20 | 6.4 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 25 | 3 | 6.4 | 8.8XOX | BOLTM20*40
24 x Bolt assembly | 20 | 45 | 8.8XOX | 1 | FLAT-E | WASHERM20-FLAT-E | 1 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 1 | 45 | 8.8XOX | BOLTM20*45
30 x Bolt assembly | 20 | 45 | 8.8XOX | 4 | FLAT-E | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 4 | 45 | 8.8XOX | BOLTM20*45
46 x Bolt assembly | 20 | 12 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 4 | 12 | 8.8XOX | BOLTM20*40
36 x Bolt assembly | 20 | 10 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 2 | 10 | 8.8XOX | BOLTM20*40
36 x Bolt assembly | 16 | 45 | 4.8XOX | 2 | FLAT-E | WASHERM16-FLAT-E | 2 | GR4-HEX | NUTM16-GR4-HEX | 22 | 0 | 18 | 2 | 45 | 4.8XOX | BOLTM16*45
12 x Bolt assembly | 16 | 50 | 4.8XOX | 4 | FLAT-E | WASHERM16-FLAT-E | 4 | GR4-HEX | NUTM16-GR4-HEX | 0 | 0 | 18 | 4 | 50 | 4.8XOX | BOLTM16*50
6 x Bolt assembly | 16 | 40 | 4.8XOX | 2 | FLAT-E | WASHERM16-FLAT-E | 2 | GR4-HEX | NUTM16-GR4-HEX | 22 | 0 | 18 | 2 | 40 | 4.8XOX | BOLTM16*40
24 x Bolt assembly | 16 | 40 | 8.8XOX | 2 | FLAT-E | WASHERM16-FLAT-E | 1 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 1 | 40 | 8.8XOX | BOLTM16*40
6 x Bolt assembly | 16 | 40 | 8.8XOX | 4 | FLAT-E | WASHERM16-FLAT-E | 2 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 2 | 40 | 8.8XOX | BOLTM16*40
61 x Bolt assembly | 12 | 35 | 8.8XOX | 2 | FLAT-E | WASHERM12-FLAT-E | 2 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 2 | 35 | 8.8XOX | BOLTM12*35
Bolt assembly | 12 | 40 | 8.8XOX | 2 | FLAT-E | WASHERM12-FLAT-E | 2 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 2 | 40 | 8.8XOX | BOLTM12*40
17 x Bolt assembly | 24 | 90 | 8.8XOX | 4 | FLAT-E | WASHERM24-FLAT-E | 4 | GR8-HEX | NUTM24-GR8-HEX | 0 | 0 | 28 | 4 | 90 | 8.8XOX | BOLTM24*90
12 x Bolt assembly | 12 | 51 | 4.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR4-HEX | NUTM12-GR4-HEX | 0 | 3.8 | 14 | 4 | 51 | 4.8XOX | BOLTM12*55
6 x Bolt assembly | 30 | 90 | 8.8XOX | 2 | FLAT-E | WASHERM30-FLAT-E | 2 | GR8-HEX | NUTM30-GR8-HEX | 0 | 0 | 35 | 2 | 90 | 8.8XOX | BOLTM30*90
6 x Bolt assembly | 10 | 64 | 4.8XOX | 4 | FLAT-E | WASHERM10-FLAT-E | 0 | GR4-HEX | NUTM10-GR4-HEX | 0 | 2 | 12 | 4 | 64 | 4.8XOX | BOLTM10*65
Bolt assembly | 24 | 51 | 8.8XOX | 0 | FLAT-E | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 0 | 28 | 4 | 51 | 8.8XOX | BOLTM24*55
48 x Bolt assembly | 16 | 40 | 8.8XOX | 1 | FLAT-E | WASHERM16-FLAT-E | 1 | GR8-HEX | NUTM16-GR8-HEX | 0 | 8 | 18 | 1 | 40 | 8.8XOX | BOLTM16*40
6 x Bolt assembly | 10 | 44 | 4.8XOX | 4 | FLAT-E | WASHERM10-FLAT-E | 0 | GR4-HEX | NUTM10-GR4-HEX | 0 | 2 | 12 | 4 | 44 | 4.8XOX | BOLTM10*45
6 x Bolt assembly | 30 | 65 | 8.8XOX | 2 | FLAT-E | WASHERM30-FLAT-E | 2 | GR8-HEX | NUTM30-GR8-HEX | 0 | 0 | 32 | 2 | 65 | 8.8XOX | BOLTM30*65
47 x Bolt assembly | 20 | 60 | 8.8XOX | 2 | FLAT-E | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 2 | 60 | 8.8XOX | BOLTM20*60
6 x Bolt assembly | 24 | 27.4 | 8.8XOX | 4 | FLAT-E | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 0 | 26 | 4 | 27.4 | 8.8XOX | BOLTM24*50
6 x Bolt assembly | 20 | 80 | 8.8XOX | 4 | FLAT-E | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 4 | 80 | 8.8XOX | BOLTM20*80
2 x Bolt assembly | 20 | 90 | 8.8XOX | 4 | FLAT-E | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 4 | 90 | 8.8XOX | BOLTM20*90
33 x Bolt assembly | 20 | 55 | 8.8XOX | 1 | FLAT-E | WASHERM20-FLAT-E | 1 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 1 | 55 | 8.8XOX | BOLTM20*55
54 x Bolt assembly | 20 | 50 | 8.8XOX | 2 | FLAT-E | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 28 | 0 | 22 | 2 | 50 | 8.8XOX | BOLTM20*50
30 x Bolt assembly | 12 | 10.9 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 2 | 11 | 8.8XOX | BOLTM12*25
18 x Bolt assembly | 20 | 8 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 2 | 8 | 8.8XOX | BOLTM20*40
30 x Bolt assembly | 20 | 12 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 2 | 12 | 8.8XOX | BOLTM20*40
18 x Bolt assembly | 16 | 12 | 8.8XOX | 0 | FLAT-E | WASHERM16-FLAT-E | 0 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 4 | 12 | 8.8XOX | BOLTM16*30
144 x Bolt assembly | 16 | 10 | 4.8XOX | 0 | FLAT-E | WASHERM16-FLAT-E | 0 | GR4-HEX | NUTM16-GR4-HEX | 0 | 0 | 18 | 1 | 10 | 4.8XOX | BOLTM16*30
36 x Bolt assembly | 16 | 6.4 | 8.8XOX | 0 | FLAT-E | WASHERM16-FLAT-E | 0 | GR8-HEX | NUTM16-GR8-HEX | 0 | 120 | 18 | 1 | 6.4 | 8.8XOX | BOLTM16*30
6 x Bolt assembly | 12 | 11 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 2 | 16 | 2 | 11 | 8.8XOX | BOLTM12*25
9 x Bolt assembly | 10 | 7 | 8.8XOX | 0 | FLAT-E | WASHERM10-FLAT-E | 0 | GR8-HEX | NUTM10-GR8-HEX | 0 | 0 | 12 | 4 | 7 | 8.8XOX | BOLTM10*20
18 x Bolt assembly | 16 | 13.91 | 8.8XOX | 0 | FLAT-E | WASHERM16-FLAT-E | 0 | GR8-HEX | NUTM16-GR8-HEX | 0 | 2 | 20 | 2 | 13.9 | 8.8XOX | BOLTM16*30
6 x Bolt assembly | 16 | 50 | 8.8XOX | 8 | FLAT-E | WASHERM16-FLAT-E | 8 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 8 | 50 | 8.8XOX | BOLTM16*50
6 x Bolt assembly | 16 | 50 | 8.8XOX | 7 | FLAT-E | WASHERM16-FLAT-E | 7 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 7 | 50 | 8.8XOX | BOLTM16*50
6 x Bolt assembly | 16 | 40 | 8.8XOX | 6 | FLAT-E | WASHERM16-FLAT-E | 6 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 6 | 40 | 8.8XOX | BOLTM16*40
6 x Bolt assembly | 16 | 40 | 8.8XOX | 10 | FLAT-E | WASHERM16-FLAT-E | 10 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 10 | 40 | 8.8XOX | BOLTM16*40
6 x Bolt assembly | 16 | 40 | 4.8CSK_NH | 10 |  |  | 10 |  |  | 0 | 0 | 18 | 10 | 40 | 4.8CSK_NH
12 x Bolt assembly | 16 | 55 | 8.8XOX | 1 | FLAT-E | WASHERM16-FLAT-E | 1 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 1 | 55 | 8.8XOX | BOLTM16*55
6 x Bolt assembly | 16 | 40 | 8.8XOX | 7 | FLAT-E | WASHERM16-FLAT-E | 7 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 7 | 40 | 8.8XOX | BOLTM16*40
6 x Bolt assembly | 16 | 40 | 8.8XOX | 5 | FLAT-E | WASHERM16-FLAT-E | 5 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 5 | 40 | 8.8XOX | BOLTM16*40
29 x Bolt assembly | 16 | 40 | 8.8XOX | 9 | FLAT-E | WASHERM16-FLAT-E | 9 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 9 | 40 | 8.8XOX | BOLTM16*40
30 x Bolt assembly | 16 | 40 | 4.8XOX | 4 | FLAT-E | WASHERM16-FLAT-E | 4 | GR4-HEX | NUTM16-GR4-HEX | 0 | 0 | 18 | 4 | 40 | 4.8XOX | BOLTM16*40
6 x Bolt assembly | 16 | 50 | 8.8XOX | 3 | FLAT-E | WASHERM16-FLAT-E | 3 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 3 | 50 | 8.8XOX | BOLTM16*50
6 x Bolt assembly | 16 | 45 | 8.8XOX | 9 | FLAT-E | WASHERM16-FLAT-E | 9 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 9 | 45 | 8.8XOX | BOLTM16*45
24 x Bolt assembly | 16 | 45 | 8.8XOX | 4 | FLAT-E | WASHERM16-FLAT-E | 4 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 4 | 45 | 8.8XOX | BOLTM16*45
6 x Bolt assembly | 12 | 6 | 4.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 3 | 6 | 4.8XOX | BOLTM12*25
6 x Bolt assembly | 12 | 6 | 4.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 5 | 6 | 4.8XOX | BOLTM12*25
8 x Bolt assembly | 16 | 45 | 4.8CSK_NH | 2 |  |  | 2 |  |  | 0 | 32 | 18 | 2 | 45 | 4.8CSK_NH
60 x Bolt assembly | 12 | 75 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 1 | 75 | 8.8XOX | BOLTM12*80
6 x Bolt assembly | 16 | 45 | 8.8XOX | 8 | FLAT-E | WASHERM16-FLAT-E | 4 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 4 | 45 | 8.8XOX | BOLTM16*45
48 x Bolt assembly | 24 | 150 | 8.8XOX | 2 | FLAT-E | WASHERM24-FLAT-E | 2 | GR8-HEX | NUTM24-GR8-HEX | 0 | 0 | 21 | 2 | 150 | 8.8XOX | BOLTM24*150
12 x Bolt assembly | 12 | 75 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 3 | 75 | 8.8XOX | BOLTM12*80
2 x Bolt assembly | 20 | 80 | 8.8XOX | 2 | FLAT-E | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 2 | 80 | 8.8XOX | BOLTM20*80
36 x Bolt assembly | 12 | 30 | 4.8XOX | 1 | FLAT-E | WASHERM12-FLAT-E | 1 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 1 | 30 | 4.8XOX | BOLTM12*30
6 x Bolt assembly | 24 | 12 | 8.8XOX | 0 | FLAT-E | WASHERM24-FLAT-E | 0 | GR8-HEX | NUTM24-GR8-HEX | 0 | 0 | 30 | 1 | 12 | 8.8XOX | BOLTM24*50
12 x Bolt assembly | 16 | 20 | 8.8XOX | 0 | FLAT-E | WASHERM16-FLAT-E | 0 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 4 | 20 | 8.8XOX | BOLTM16*30
12 x Bolt assembly | 12 | 40 | 4.8XOX | 2 | FLAT-E | WASHERM12-FLAT-E | 2 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 2 | 40 | 4.8XOX | BOLTM12*40
12 x Bolt assembly | 20 | 55 | 8.8XOX | 12 | FLAT-E | WASHERM20-FLAT-E | 12 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 12 | 55 | 8.8XOX | BOLTM20*55
6 x Bolt assembly | 20 | 10.2 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 4 | 10.2 | 8.8XOX | BOLTM20*40
6 x Bolt assembly | 20 | 10.2 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 6 | 10.2 | 8.8XOX | BOLTM20*40
60 x Bolt assembly | 10 | 5 | 4.8XOX | 0 | FLAT-E | WASHERM10-FLAT-E | 0 | GR4-HEX | NUTM10-GR4-HEX | 0 | 0 | 7 | 2 | 5 | 4.8XOX | BOLTM10*20
60 x Bolt assembly | 10 | 5 | 4.8XOX | 0 | FLAT-E | WASHERM10-FLAT-E | 0 | GR4-HEX | NUTM10-GR4-HEX | 0 | 0 | 4.8 | 2 | 5 | 4.8XOX | BOLTM10*20
60 x Bolt assembly | 20 | 70 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 20.5 | 1 | 70 | 8.8XOX | BOLTM20*70
60 x Bolt assembly | 12 | 35 | 4.8XOX | 2 | FLAT-E | WASHERM12-FLAT-E | 2 | GR4-HEX | NUTM12-GR4-HEX | 16 | 0 | 14 | 2 | 35 | 4.8XOX | BOLTM12*35
60 x Bolt assembly | 12 | 70 | 4.8XOX | 1 | FLAT-E | WASHERM12-FLAT-E | 1 | GR4-HEX | NUTM12-GR4-HEX | 0 | 2 | 14 | 1 | 70 | 4.8XOX | BOLTM12*70
12 x Bolt assembly | 24 | 70 | 8.8XOX | 4 | FLAT-E | WASHERM24-FLAT-E | 4 | GR8-HEX | NUTM24-GR8-HEX | 8 | 2 | 26 | 4 | 70 | 8.8XOX | BOLTM24*70
12 x Bolt assembly | 20 | 10 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 6 | 10 | 8.8XOX | BOLTM20*40
12 x Bolt assembly | 12 | 50 | 4.8XOX | 2 | FLAT-E | WASHERM12-FLAT-E | 2 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 2 | 50 | 4.8XOX | BOLTM12*50
18 x Bolt assembly | 20 | 65 | 8.8XOX | 1 | FLAT-E | WASHERM20-FLAT-E | 1 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 1 | 65 | 8.8XOX | BOLTM20*65
6 x Bolt assembly | 12 | 51.99 | 8.8XOX | 0 | FLAT-E | WASHERM12-FLAT-E | 0 | GR8-HEX | NUTM12-GR8-HEX | 0 | 3.8 | 14 | 4 | 52 | 8.8XOX | BOLTM12*55
60 x Bolt assembly | 12 | 50 | 4.8XOX | 1 | FLAT-E | WASHERM12-FLAT-E | 1 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 1 | 50 | 4.8XOX | BOLTM12*50
60 x Bolt assembly | 12 | 110 | 4.8XOX | 2 | FLAT-E | WASHERM12-FLAT-E | 2 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 2 | 110 | 4.8XOX | BOLTM12*110
30 x Bolt assembly | 12 | 45 | 4.8XOX | 1 | FLAT-E | WASHERM12-FLAT-E | 1 | GR4-HEX | NUTM12-GR4-HEX | 0 | 0 | 14 | 1 | 45 | 4.8XOX | BOLTM12*45
24 x Bolt assembly | 20 | 27 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 2 | 27 | 8.8XOX | BOLTM20*40
4 x Bolt assembly | 12 | 55 | 8.8XOX | 2 | FLAT-E | WASHERM12-FLAT-E | 2 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 2 | 55 | 8.8XOX | BOLTM12*55
12 x Bolt assembly | 8 | 44 | 4.8XOX | 0 | FLAT-E | WASHERM8-FLAT-E | 0 | GR4-HEX |  | 0 | 3.2 | 10 | 4 | 44 | 4.8XOX
12 x Bolt assembly | 24 | 80 | 8.8XOX | 2 | FLAT-E | WASHERM24-FLAT-E | 2 | GR8-HEX | NUTM24-GR8-HEX | 0 | 0 | 26 | 2 | 80 | 8.8XOX | BOLTM24*80
16 x Bolt assembly | 20 | 58.1 | 8.8 | 1 | DIN126 | Plain washer M20-126 | 1 | ISO4032 | Nut M20-4032 | 0 | 0 | 22 | 1 | 58.1 | ISO 4017 | Bolt M20x60
4 x Bolt assembly | 16 | 45 | 8.8XOX | 1 | FLAT-E | WASHERM16-FLAT-E | 1 | GR8-HEX | NUTM16-GR8-HEX | 38 | 0 | 22 | 1 | 45 | 8.8XOX | BOLTM16*45
4 x Bolt assembly | 12 | 30 | 8.8XOX | 3 | FLAT-E | WASHERM12-FLAT-E | 3 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 3 | 30 | 8.8XOX | BOLTM12*30
6 x Bolt assembly | 16 | 45 | 8.8XOX | 1 | FLAT-E | WASHERM16-FLAT-E | 1 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 20 | 1 | 45 | 8.8XOX | BOLTM16*45
2 x Bolt assembly | 16 | 80 | 8.8XOX | 1 | FLAT-E | WASHERM16-FLAT-E | 1 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 22 | 1 | 80 | 8.8XOX | BOLTM16*80
12 x Bolt assembly | 20 | 20 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 40 | 1 | 20 | 8.8XOX | BOLTM20*40
2 x Bolt assembly | 16 | 35 | 8.8XOX | 1 | FLAT-E | WASHERM16-FLAT-E | 1 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 20 | 1 | 35 | 8.8XOX | BOLTM16*35
3 x Bolt assembly | 20 | 3 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 24 | 6 | 3 | 8.8XOX | BOLTM20*40
6 x Bolt assembly | 16 | 6.4 | 8.8XOX | 0 | FLAT-E | WASHERM16-FLAT-E | 0 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 18 | 4 | 6.4 | 8.8XOX | BOLTM16*30
3 x Bolt assembly | 16 | 45 | 8.8XOX | 6 | FLAT-E | WASHERM16-FLAT-E | 2 | GR8-HEX | NUTM16-GR8-HEX | 0 | 29 | 18 | 2 | 45 | 8.8XOX | BOLTM16*45
3 x Bolt assembly | 16 | 45 | 8.8XOX | 4 | FLAT-E | WASHERM16-FLAT-E | 2 | GR8-HEX | NUTM16-GR8-HEX | 0 | 29 | 18 | 2 | 45 | 8.8XOX | BOLTM16*45
18 x Bolt assembly | 20 | 20 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 2 | 20 | 8.8XOX | BOLTM20*40
6 x Bolt assembly | 20 | 45 | 8.8XOX | 9 | FLAT-E | WASHERM20-FLAT-E | 9 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 9 | 45 | 8.8XOX | BOLTM20*45
6 x Bolt assembly | 12 | 30 | 8.8XOX | 4 | FLAT-E | WASHERM12-FLAT-E | 4 | GR8-HEX | NUTM12-GR8-HEX | 0 | 0 | 14 | 4 | 30 | 8.8XOX | BOLTM12*30
2 x Bolt assembly | 20 | 100 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 12 | 100 | 8.8XOX | BOLTM20*100
6 x Bolt assembly | 24 | 80 | 8.8XOX | 4 | FLAT-E | WASHERM24-FLAT-E | 4 | GR8-HEX | NUTM24-GR8-HEX | 0 | 0 | 26 | 4 | 80 | 8.8XOX | BOLTM24*80
6 x Bolt assembly | 20 | 45 | 8.8XOX | 4 | FLAT-E | WASHERM20-FLAT-E | 2 | GR8-HEX | NUTM20-GR8-HEX | 28 | 0 | 22 | 2 | 45 | 8.8XOX | BOLTM20*45
12 x Bolt assembly | 20 | 40 | 8.8XOX | 1 | FLAT-E | WASHERM20-FLAT-E | 1 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 1 | 40 | 8.8XOX | BOLTM20*40
12 x Bolt assembly | 24 | 70 | 8.8XOX | 4 | FLAT-E | WASHERM24-FLAT-E | 4 | GR8-HEX | NUTM24-GR8-HEX | 0 | 0 | 26 | 4 | 70 | 8.8XOX | BOLTM24*70
12 x Bolt assembly | 20 | 60 | 8.8XOX | 4 | FLAT-E | WASHERM20-FLAT-E | 4 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 4 | 60 | 8.8XOX | BOLTM20*60
2 x Bolt assembly | 20 | 100 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 13 | 100 | 8.8XOX | BOLTM20*100
Bolt assembly | 20 | 100 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 9 | 100 | 8.8XOX | BOLTM20*100
12 x Bolt assembly | 20 | 20 | 8.8XOX | 0 | FLAT-E | WASHERM20-FLAT-E | 0 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 4 | 20 | 8.8XOX | BOLTM20*40
Bolt assembly | 16 | 40 | 8.8XOX | 9 | FLAT-E | WASHERM16-FLAT-E | 9 | GR8-HEX | NUTM16-GR8-HEX | 0 | 0 | 38 | 9 | 40 | 8.8XOX | BOLTM16*40
92 x Bolt assembly | 20 | 55 | 8.8XOX | 3 | FLAT-E | WASHERM20-FLAT-E | 3 | GR8-HEX | NUTM20-GR8-HEX | 0 | 0 | 22 | 3 | 55 | 8.8XOX | BOLTM20*55

# IfcMember: C152*76 (21)
In: Undefined
Description: C152*76; Material: STEEL/S355JR
Tekla Common - Phase: 6; Class: 3
Tekla Quantity - Weight: 20.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 32.6 m2; Net surface area: 0.6 m2; Height: 152.4 mm; Width: 76.2 mm; Length: 1122.2 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - Length: 1122.2 mm; OuterSurfaceArea: 0.655665 m2; GrossSurfaceArea: 0.655665 m2; CrossSectionArea: 0.00228026 m2; NetVolume: 0.00234198 m3; GrossVolume: 0.0025589 m3; NetWeight: 18.3845 kg; GrossWeight: 20.0874 kg
Name | Bottom elevation | Top elevation | Reference
3 x Frame | +52.239 | +53.370 | m294
3 x Frame | +52.156 | +53.287 | m294
3 x Frame | +52.033 | +53.164 | m293
3 x Frame | +51.909 | +53.040 | m293
6 x Frame | +51.786 | +52.917 | m293
3 x Frame | +51.662 | +52.793 | m293

# IfcMember: CHS34*2.5 (16)
In: Undefined
Description: CHS34*2.5; Material: MISCELLANEOUS/COMPONENT
Tekla Common - Phase: 7; Class: 40
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 34 mm; Width: 34 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00023625 m2; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Bottom elevation | Top elevation | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) = GrossVolume (m3)
8 x HANDRAIL | +51.558 | +51.920 | 524.9 | A570 | 524.933 | 0.055687 | 0.000124016
8 x HANDRAIL | +51.057 | +51.413 | 514.7 | A569 | 514.688 | 0.0546052 | 0.000121595

# IfcMember: CHS43*3 (134)
In: Undefined
Description: CHS43*3; Material: MISCELLANEOUS/COMPONENT
Tekla Common - Phase: 7; Class: 46
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 60 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00036 m2; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Bottom elevation | Top elevation | Width (mm) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x HANDRAIL | +51.090 | +52.121 | 60 | 1029.8 | m430 | 1029.81 | 0.144338 | 0.144364 | 0.00075953 | 0.0007596
2 x HANDRAIL | +51.214 | +52.244 | 60 | 1029.8 | m430 | 1029.81 | 0.144338 | 0.144364 | 0.00075953 | 0.0007596
3 x HANDRAIL | +51.090 | +52.121 | 60 | 1029.8 | m430 | 1029.83 | 0.144338 | 0.144364 | 0.00075953 | 0.0007596
3 x HANDRAIL | +51.214 | +52.244 | 60 | 1029.8 | m430 | 1029.83 | 0.144338 | 0.144364 | 0.00075953 | 0.0007596
HANDRAIL | +51.105 | +52.135 | 60 | 1029.6 | m430 | 1029.61 | 0.144313 | 0.144364 | 0.000759461 | 0.0007596
HANDRAIL | +51.228 | +52.259 | 60 | 1030 | m430 | 1030.02 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +55.837 | +56.868 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +55.836 | +56.868 | 60 | 1030.8 | m430 | 1030.76 | 0.144466 | 0.144466 | 0.000759872 | 0.000759872
HANDRAIL | +51.075 | +52.106 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +51.199 | +52.230 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +57.277 | +58.309 | 60 | 1031.6 | m431 | 1031.58 | 0.144574 | 0.144576 | 0.000760165 | 0.000760171
HANDRAIL | +57.253 | +58.286 | 60.2 | 1031.6 | m431 | 1031.59 | 0.144574 | 0.144574 | 0.000760167 | 0.000760167
HANDRAIL | +57.203 | +58.236 | 60.1 | 1031.6 | m431 | 1031.73 | 0.144594 | 0.144594 | 0.000760221 | 0.000760221
HANDRAIL | +57.146 | +58.178 | 60.5 | 1031.6 | m431 | 1031.69 | 0.144585 | 0.144585 | 0.000760197 | 0.000760197
HANDRAIL | +57.081 | +58.112 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +57.008 | +58.041 | 60.2 | 1031.5 | m431 | 1031.54 | 0.144568 | 0.144568 | 0.000760151 | 0.000760151
HANDRAIL | +56.928 | +57.961 | 60.2 | 1031.6 | m431 | 1031.59 | 0.144574 | 0.144574 | 0.000760166 | 0.000760166
HANDRAIL | +56.840 | +57.881 | 60.2 | 1039.6 | m432 | 1039.61 | 0.145646 | 0.145646 | 0.000763056 | 0.000763056
HANDRAIL | +56.774 | +57.810 | 60 | 1034.9 | m433 | 1034.9 | 0.145016 | 0.145016 | 0.000761358 | 0.000761358
HANDRAIL | +56.711 | +57.742 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +56.643 | +57.674 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +56.531 | +57.561 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +56.412 | +57.443 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +55.919 | +56.950 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +56.043 | +57.073 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +56.166 | +57.197 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +56.290 | +57.321 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +55.751 | +56.782 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +54.845 | +55.876 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +54.927 | +55.958 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +55.031 | +56.062 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +55.174 | +56.205 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +55.669 | +56.700 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +55.545 | +56.576 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +55.422 | +56.452 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +55.298 | +56.329 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +54.759 | +55.790 | 60 | 1030 | m430 | 1030.01 | 0.144362 | 0.144364 | 0.000759595 | 0.0007596
HANDRAIL | +53.853 | +54.883 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.000759601 | 0.000759601
HANDRAIL | +53.935 | +54.966 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.000759601 | 0.000759601
HANDRAIL | +54.059 | +55.089 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.000759601 | 0.000759601
HANDRAIL | +54.182 | +55.213 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.000759601 | 0.000759601
HANDRAIL | +54.677 | +55.707 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +54.553 | +55.584 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +54.429 | +55.460 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +54.306 | +55.337 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +53.767 | +54.797 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +52.860 | +53.891 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.000759601 | 0.000759601
HANDRAIL | +52.943 | +53.973 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.000759601 | 0.000759601
HANDRAIL | +53.066 | +54.097 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.000759601 | 0.000759601
HANDRAIL | +53.190 | +54.221 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +53.684 | +54.715 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +53.561 | +54.591 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +53.437 | +54.468 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +53.313 | +54.344 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +52.774 | +53.805 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +51.868 | +52.899 | 60 | 1030 | m430 | 1030.02 | 0.144363 | 0.144364 | 0.000759598 | 0.0007596
HANDRAIL | +51.950 | +52.981 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.000759601 | 0.000759601
HANDRAIL | +52.074 | +53.059 | 60 | 984.6 | m434 | 984.648 | 0.138306 | 0.144364 | 0.00074327 | 0.0007596
HANDRAIL | +52.198 | +53.228 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +52.692 | +53.723 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +52.568 | +53.558 | 60 | 988.9 | m435 | 988.942 | 0.138879 | 0.144364 | 0.000744815 | 0.0007596
HANDRAIL | +52.445 | +53.476 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +52.321 | +53.309 | 60 | 986.8 | m436 | 986.795 | 0.138593 | 0.144364 | 0.000744042 | 0.0007596
HANDRAIL | +51.779 | +52.810 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +51.655 | +52.686 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +51.284 | +52.315 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +51.408 | +52.439 | 60 | 1030 | m430 | 1030.03 | 0.144364 | 0.144364 | 0.0007596 | 0.0007596
HANDRAIL | +51.531 | +52.512 | 60 | 979.9 | m426 | 979.937 | 0.137677 | 0.144364 | 0.000741574 | 0.0007596
HANDRAIL | +51.076 | +52.106 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759598 | 0.000759599
HANDRAIL | +51.199 | +52.230 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759598 | 0.000759599
HANDRAIL | +57.277 | +58.309 | 60.2 | 1031.6 | m431 | 1031.62 | 0.144576 | 0.144576 | 0.000760169 | 0.000760169
HANDRAIL | +57.253 | +58.270 | 60.1 | 1016.4 | m437 | 1016.41 | 0.142547 | 0.142548 | 0.000754702 | 0.000754702
HANDRAIL | +57.203 | +58.236 | 60 | 1031.6 | m431 | 1031.66 | 0.144585 | 0.144585 | 0.000760195 | 0.000760195
HANDRAIL | +57.146 | +58.178 | 60 | 1031.6 | m431 | 1031.68 | 0.144588 | 0.144588 | 0.000760202 | 0.000760202
HANDRAIL | +57.081 | +58.112 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759598 | 0.000759598
HANDRAIL | +57.008 | +58.041 | 60 | 1031.6 | m431 | 1031.58 | 0.144575 | 0.144575 | 0.000760168 | 0.000760168
HANDRAIL | +56.928 | +57.961 | 60 | 1031.6 | m431 | 1031.58 | 0.144575 | 0.144575 | 0.000760167 | 0.000760167
HANDRAIL | +56.840 | +57.881 | 60 | 1039.6 | m432 | 1039.61 | 0.145647 | 0.145647 | 0.000763057 | 0.000763057
HANDRAIL | +56.777 | +57.810 | 60 | 1031.6 | m431 | 1031.58 | 0.144575 | 0.144575 | 0.000760168 | 0.000760168
HANDRAIL | +56.710 | +57.744 | 60 | 1033.2 | m438 | 1033.22 | 0.144794 | 0.144794 | 0.000760759 | 0.000760759
HANDRAIL | +56.641 | +57.674 | 60 | 1031.6 | m431 | 1031.58 | 0.144575 | 0.144575 | 0.000760168 | 0.000760168
HANDRAIL | +56.530 | +57.561 | 60 | 1030.9 | m431 | 1030.86 | 0.144479 | 0.144479 | 0.000759908 | 0.000759908
HANDRAIL | +56.412 | +57.443 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +55.919 | +56.950 | 60 | 1030.1 | m430 | 1030.13 | 0.144381 | 0.144381 | 0.000759645 | 0.000759645
HANDRAIL | +56.043 | +57.073 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +56.166 | +57.197 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +56.290 | +57.321 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +55.751 | +56.782 | 60 | 1030 | m430 | 1029.97 | 0.14436 | 0.144364 | 0.000759587 | 0.000759599
HANDRAIL | +54.845 | +55.876 | 60 | 1030 | m430 | 1029.97 | 0.14436 | 0.144364 | 0.000759587 | 0.000759599
HANDRAIL | +54.927 | +55.958 | 60 | 1030 | m430 | 1029.97 | 0.14436 | 0.144364 | 0.000759587 | 0.000759599
HANDRAIL | +55.050 | +56.062 | 60 | 1010.5 | m439 | 1010.47 | 0.141754 | 0.144364 | 0.000752562 | 0.000759599
HANDRAIL | +55.174 | +56.205 | 60 | 1030 | m430 | 1029.97 | 0.14436 | 0.144364 | 0.000759587 | 0.000759599
HANDRAIL | +55.669 | +56.700 | 60 | 1030 | m430 | 1029.97 | 0.14436 | 0.144364 | 0.000759587 | 0.000759599
HANDRAIL | +55.545 | +56.576 | 60 | 1030 | m430 | 1029.97 | 0.14436 | 0.144364 | 0.000759587 | 0.000759599
HANDRAIL | +55.422 | +56.452 | 60 | 1030 | m430 | 1029.97 | 0.14436 | 0.144364 | 0.000759587 | 0.000759599
HANDRAIL | +55.298 | +56.329 | 60 | 1030 | m430 | 1029.97 | 0.14436 | 0.144364 | 0.000759587 | 0.000759599
HANDRAIL | +54.759 | +55.790 | 60 | 1030 | m430 | 1029.99 | 0.144363 | 0.144364 | 0.000759595 | 0.000759599
HANDRAIL | +53.853 | +54.883 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +53.935 | +54.966 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +54.059 | +55.089 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +54.182 | +55.213 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +54.677 | +55.707 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759598 | 0.000759599
HANDRAIL | +54.553 | +55.584 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759598 | 0.000759599
HANDRAIL | +54.429 | +55.460 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759598 | 0.000759599
HANDRAIL | +54.306 | +55.337 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +53.767 | +54.797 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759598 | 0.000759599
HANDRAIL | +52.860 | +53.891 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +52.943 | +53.973 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +53.066 | +54.097 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +53.190 | +54.221 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +53.684 | +54.715 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759598 | 0.000759599
HANDRAIL | +53.561 | +54.591 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
HANDRAIL | +53.437 | +54.468 | 60 | 1030 | m430 | 1030 | 0.144364 | 0.144364 | 0.000759599 | 0.000759599
