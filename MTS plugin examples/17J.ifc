Properties of the parts of a building model (IFC2X3), part 11 of 16

# IfcDiscreteAccessory: VB (1004)
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x VB | L50*50*4 | +54.881 | +55.888 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +54.963 | +55.971 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +55.463 | +56.542 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +55.381 | +56.460 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507947 | 0.000531563
3 x VB | L50*50*4 | +55.298 | +56.377 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m790 | 0.264508 | 0.000389809 | 0.000507807 | 0.000531506
3 x VB | L50*50*4 | +55.540 | +56.548 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +55.458 | +56.465 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +55.375 | +56.383 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +55.290 | +56.220 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m791 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +55.293 | +56.300 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +55.208 | +56.138 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +55.210 | +56.218 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +55.126 | +56.056 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +55.128 | +56.136 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +55.046 | +56.053 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +55.545 | +56.625 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m774 | 0.264536 | 0.000389809 | 0.000508007 | 0.000531563
3 x VB | L50*50*4 | +55.628 | +56.707 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L70*70*8 | +55.780 | +56.716 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1323.6 | m337 | 0.36037 | 0.00106497 | 0.00132647 | 0.00140954
3 x VB | L50*50*4 | +55.043 | +55.973 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m790 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +54.961 | +55.891 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507862 | 0.000531564
3 x VB | L50*50*4 | +55.705 | +56.712 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +55.622 | +56.630 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +54.881 | +55.888 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +54.963 | +55.971 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
2 x VB | L70*70*8 | +55.526 | +56.792 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.4 | m352 | 0.344244 | 0.00106497 | 0.00133513 | 0.00134647
3 x VB | L70*70*8 | +54.544 | +55.810 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1265.2 | m348 | 0.344473 | 0.00106497 | 0.00133602 | 0.00134737
3 x VB | L50*50*4 | +55.463 | +56.542 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +55.381 | +56.460 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507947 | 0.000531563
3 x VB | L50*50*4 | +55.298 | +56.377 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m791 | 0.264508 | 0.000389809 | 0.000507807 | 0.000531506
VB | L70*70*8 | +55.526 | +56.792 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.4 | m335 | 0.344244 | 0.00106497 | 0.00133513 | 0.00134647
3 x VB | L50*50*4 | +55.540 | +56.548 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +55.458 | +56.465 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +55.375 | +56.383 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +55.290 | +56.220 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m790 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +55.293 | +56.300 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +55.208 | +56.138 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +55.210 | +56.218 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +55.126 | +56.056 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
VB | L70*70*8 | +54.808 | +55.883 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1329.5 | m327 | 0.361986 | 0.00106497 | 0.00133931 | 0.00141587
3 x VB | L50*50*4 | +55.128 | +56.136 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +55.046 | +56.053 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
2 x VB | L70*70*8 | +54.544 | +55.810 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1265.2 | m352 | 0.344473 | 0.00106497 | 0.00133602 | 0.00134737
3 x VB | L70*70*8 | +54.788 | +55.724 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1323.6 | m339 | 0.36037 | 0.00106497 | 0.00132647 | 0.00140954
3 x VB | L70*70*8 | +53.816 | +54.891 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1329.5 | m341 | 0.361984 | 0.00106497 | 0.00133929 | 0.00141586
3 x VB | L50*50*4 | +54.553 | +55.632 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m775 | 0.264536 | 0.000389809 | 0.000508007 | 0.000531563
3 x VB | L50*50*4 | +54.635 | +55.715 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +54.051 | +54.981 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m791 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +53.968 | +54.899 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507863 | 0.000531564
3 x VB | L50*50*4 | +54.713 | +55.720 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +54.630 | +55.638 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +53.888 | +54.896 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +53.971 | +54.978 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +54.471 | +55.550 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +54.388 | +55.468 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507947 | 0.000531563
3 x VB | L50*50*4 | +54.306 | +55.385 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m790 | 0.264508 | 0.000389809 | 0.000507807 | 0.000531506
3 x VB | L50*50*4 | +54.548 | +55.555 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +54.465 | +55.473 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +54.383 | +55.390 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +54.298 | +55.228 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m791 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +54.300 | +55.308 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +54.216 | +55.146 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +54.218 | +55.226 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +54.133 | +55.063 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +54.136 | +55.143 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +54.053 | +55.061 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +54.553 | +55.632 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m774 | 0.264536 | 0.000389809 | 0.000508007 | 0.000531563
3 x VB | L50*50*4 | +54.635 | +55.715 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L70*70*8 | +54.788 | +55.724 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1323.6 | m337 | 0.36037 | 0.00106497 | 0.00132647 | 0.00140954
3 x VB | L50*50*4 | +54.051 | +54.981 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m790 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +53.968 | +54.899 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507862 | 0.000531564
3 x VB | L50*50*4 | +54.713 | +55.720 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +54.630 | +55.638 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +53.888 | +54.896 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +53.971 | +54.978 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
2 x VB | L70*70*8 | +54.533 | +55.799 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1265.2 | m352 | 0.344444 | 0.00106497 | 0.0013359 | 0.00134725
VB | L70*70*8 | +53.552 | +54.818 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.9 | m335 | 0.344413 | 0.00106497 | 0.00133579 | 0.00134713
3 x VB | L50*50*4 | +54.471 | +55.550 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +54.388 | +55.468 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507947 | 0.000531563
3 x VB | L50*50*4 | +54.306 | +55.385 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m791 | 0.264508 | 0.000389809 | 0.000507807 | 0.000531506
3 x VB | L70*70*8 | +54.533 | +55.799 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1265.2 | m348 | 0.344444 | 0.00106497 | 0.0013359 | 0.00134725
3 x VB | L50*50*4 | +54.548 | +55.555 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +54.465 | +55.473 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +54.383 | +55.390 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +54.298 | +55.228 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m790 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +54.300 | +55.308 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +54.216 | +55.146 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +54.218 | +55.226 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +54.133 | +55.063 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L70*70*8 | +53.816 | +54.891 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1329.5 | m340 | 0.361984 | 0.00106497 | 0.00133929 | 0.00141586
3 x VB | L50*50*4 | +54.136 | +55.143 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +54.053 | +55.061 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
2 x VB | L70*70*8 | +53.552 | +54.818 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.9 | m352 | 0.344413 | 0.00106497 | 0.00133579 | 0.00134713
3 x VB | L70*70*8 | +53.796 | +54.731 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1323.5 | m339 | 0.360357 | 0.00106497 | 0.00132637 | 0.00140949
3 x VB | L70*70*8 | +52.823 | +53.899 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1329.5 | m341 | 0.361983 | 0.00106497 | 0.00133929 | 0.00141585
3 x VB | L50*50*4 | +53.561 | +54.640 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m775 | 0.264536 | 0.000389809 | 0.000508007 | 0.000531563
3 x VB | L50*50*4 | +53.643 | +54.723 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +53.059 | +53.988 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m791 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +52.976 | +53.906 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507863 | 0.000531564
3 x VB | L50*50*4 | +53.720 | +54.728 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +53.638 | +54.646 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +52.896 | +53.904 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +52.979 | +53.986 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +53.478 | +54.558 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +53.396 | +54.475 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507947 | 0.000531563
3 x VB | L50*50*4 | +53.314 | +54.393 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m790 | 0.264508 | 0.000389809 | 0.000507807 | 0.000531506
3 x VB | L50*50*4 | +53.555 | +54.563 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +53.473 | +54.481 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +53.391 | +54.398 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +53.306 | +54.236 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m791 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +53.308 | +54.316 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +53.223 | +54.153 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +53.226 | +54.233 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +53.141 | +54.071 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +53.143 | +54.151 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +53.061 | +54.069 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +53.561 | +54.640 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m774 | 0.264536 | 0.000389809 | 0.000508007 | 0.000531563
3 x VB | L50*50*4 | +53.643 | +54.723 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L70*70*8 | +53.796 | +54.731 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1323.5 | m337 | 0.360357 | 0.00106497 | 0.00132637 | 0.00140949
3 x VB | L50*50*4 | +53.059 | +53.988 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m790 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +52.976 | +53.906 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507862 | 0.000531564
3 x VB | L50*50*4 | +53.720 | +54.728 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +53.638 | +54.646 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +52.896 | +53.904 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +52.979 | +53.986 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
2 x VB | L70*70*8 | +53.541 | +54.807 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.9 | m352 | 0.344384 | 0.00106497 | 0.00133567 | 0.00134702
3 x VB | L70*70*8 | +52.559 | +53.826 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1265.6 | m348 | 0.344598 | 0.00106497 | 0.0013365 | 0.00134785
3 x VB | L50*50*4 | +53.478 | +54.558 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +53.396 | +54.475 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507947 | 0.000531563
3 x VB | L50*50*4 | +53.314 | +54.393 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m791 | 0.264508 | 0.000389809 | 0.000507807 | 0.000531506
VB | L70*70*8 | +53.541 | +54.807 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.9 | m335 | 0.344384 | 0.00106497 | 0.00133567 | 0.00134702
3 x VB | L50*50*4 | +53.555 | +54.563 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +53.473 | +54.481 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +53.391 | +54.398 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +53.306 | +54.236 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m790 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +53.308 | +54.316 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +53.223 | +54.153 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +53.226 | +54.233 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +53.141 | +54.071 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L70*70*8 | +52.823 | +53.899 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1329.5 | m340 | 0.361983 | 0.00106497 | 0.00133929 | 0.00141585
3 x VB | L50*50*4 | +53.143 | +54.151 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +53.061 | +54.069 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
2 x VB | L70*70*8 | +52.559 | +53.826 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1265.6 | m352 | 0.344598 | 0.00106497 | 0.0013365 | 0.00134785
3 x VB | L70*70*8 | +52.804 | +53.739 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1323.5 | m339 | 0.360357 | 0.00106497 | 0.00132637 | 0.00140949
3 x VB | L70*70*8 | +51.831 | +52.906 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1329.5 | m338 | 0.361983 | 0.00106497 | 0.00133929 | 0.00141585
3 x VB | L50*50*4 | +52.569 | +53.648 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m775 | 0.264536 | 0.000389809 | 0.000508007 | 0.000531563
3 x VB | L50*50*4 | +52.651 | +53.730 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +52.066 | +52.996 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m791 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +51.984 | +52.914 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507863 | 0.000531564
3 x VB | L50*50*4 | +52.728 | +53.736 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +52.646 | +53.653 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +51.904 | +52.912 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +51.986 | +52.994 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +52.486 | +53.565 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +52.404 | +53.483 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507947 | 0.000531563
3 x VB | L50*50*4 | +52.321 | +53.400 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m790 | 0.264508 | 0.000389809 | 0.000507807 | 0.000531506
3 x VB | L50*50*4 | +52.563 | +53.571 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +52.481 | +53.488 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +52.398 | +53.406 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +52.314 | +53.243 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m791 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +52.316 | +53.323 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +52.231 | +53.161 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +52.234 | +53.241 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +52.149 | +53.079 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +52.151 | +53.159 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +52.069 | +53.076 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +52.569 | +53.648 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m774 | 0.264536 | 0.000389809 | 0.000508007 | 0.000531563
3 x VB | L50*50*4 | +52.651 | +53.730 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L70*70*8 | +52.804 | +53.739 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1323.5 | m337 | 0.360357 | 0.00106497 | 0.00132637 | 0.00140949
3 x VB | L50*50*4 | +52.066 | +52.996 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m790 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +51.984 | +52.914 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507862 | 0.000531564
3 x VB | L50*50*4 | +52.728 | +53.736 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +52.646 | +53.653 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +51.904 | +52.912 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +51.986 | +52.994 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
2 x VB | L70*70*8 | +52.548 | +53.815 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1265.6 | m352 | 0.344579 | 0.00106497 | 0.00133642 | 0.00134778
3 x VB | L70*70*8 | +51.566 | +52.833 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1266.3 | m348 | 0.344806 | 0.00106497 | 0.00133731 | 0.00134867
3 x VB | L50*50*4 | +52.486 | +53.565 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +52.404 | +53.483 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m791 | 0.264536 | 0.000389809 | 0.000507947 | 0.000531563
3 x VB | L50*50*4 | +52.321 | +53.400 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m791 | 0.264508 | 0.000389809 | 0.000507807 | 0.000531506
3 x VB | L70*70*8 | +52.548 | +53.815 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1265.6 | m348 | 0.344579 | 0.00106497 | 0.00133642 | 0.00134778
3 x VB | L50*50*4 | +52.563 | +53.571 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +52.481 | +53.488 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m783 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +52.398 | +53.406 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m783 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +52.314 | +53.243 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.4 | m790 | 0.264508 | 0.000389809 | 0.000507808 | 0.000531506
3 x VB | L50*50*4 | +52.316 | +53.323 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +52.231 | +53.161 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L50*50*4 | +52.234 | +53.241 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1006.8 | m782 | 0.19531 | 0.000389809 | 0.000386611 | 0.00039246
3 x VB | L50*50*4 | +52.149 | +53.079 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m790 | 0.264536 | 0.000389809 | 0.000507869 | 0.000531563
3 x VB | L70*70*8 | +51.831 | +52.906 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1329.5 | m336 | 0.361983 | 0.00106497 | 0.00133929 | 0.00141585
3 x VB | L50*50*4 | +52.151 | +53.159 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L50*50*4 | +52.069 | +53.076 | 2 | 4 | 3.1 | 63.4 | 0.2 | 50 | 50 | 1007 | m782 | 0.195349 | 0.000389809 | 0.000386688 | 0.000392538
3 x VB | L70*70*8 | +51.566 | +52.833 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1266.3 | m347 | 0.344806 | 0.00106497 | 0.00133731 | 0.00134867
2 x VB | L70*70*8 | +56.478 | +57.740 | 2 | 4 | 10.5 | 32.6 | 0.3 | 70 | 70 | 1259.5 | m326 | 0.342921 | 0.00106497 | 0.00132997 | 0.00134129
2 x VB | L70*70*8 | +56.487 | +57.754 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.9 | m348 | 0.344398 | 0.00106497 | 0.00133572 | 0.00134707
VB | L70*70*8 | +56.732 | +57.678 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1333 | m342 | 0.362954 | 0.00106497 | 0.00134565 | 0.00141965
2 x VB | L70*70*8 | +50.978 | +52.246 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1267.3 | m325 | 0.345048 | 0.00106497 | 0.00133816 | 0.00134961
2 x VB | L50*50*4 | +51.441 | +52.372 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m770 | 0.264535 | 0.000389809 | 0.000507822 | 0.000531562
2 x VB | L50*50*4 | +51.441 | +52.372 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1363.6 | m769 | 0.264535 | 0.000389809 | 0.000507822 | 0.000531562
2 x VB | L70*70*8 | +50.978 | +52.246 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1267.3 | m324 | 0.345048 | 0.00106497 | 0.00133816 | 0.00134961
2 x VB | L70*70*8 | +55.537 | +56.802 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.4 | m348 | 0.344274 | 0.00106497 | 0.00133525 | 0.00134659
2 x VB | L70*70*8 | +54.808 | +55.883 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1329.5 | m341 | 0.361986 | 0.00106497 | 0.00133931 | 0.00141587
2 x VB | L70*70*8 | +55.526 | +56.792 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.4 | m348 | 0.344244 | 0.00106497 | 0.00133513 | 0.00134647
2 x VB | L70*70*8 | +54.808 | +55.883 | 2 | 4 | 11.1 | 32.6 | 0.3 | 70 | 70 | 1329.5 | m340 | 0.361986 | 0.00106497 | 0.00133931 | 0.00141587
2 x VB | L70*70*8 | +53.552 | +54.818 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.9 | m348 | 0.344413 | 0.00106497 | 0.00133579 | 0.00134713
2 x VB | L70*70*8 | +53.541 | +54.807 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.9 | m348 | 0.344384 | 0.00106497 | 0.00133567 | 0.00134702
VB | L50*50*4 | +57.121 | +58.164 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1338.4 | m792 | 0.259647 | 0.000389809 | 0.000498533 | 0.000521739
VB | L50*50*4 | +57.121 | +58.164 | 2 | 4 | 4.2 | 63.4 | 0.3 | 50 | 50 | 1338.4 | m799 | 0.259647 | 0.000389809 | 0.000498533 | 0.000521739
VB | L70*70*8 | +56.487 | +57.754 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.9 | m347 | 0.344398 | 0.00106497 | 0.00133572 | 0.00134707
VB | L70*70*8 | +56.478 | +57.740 | 2 | 4 | 10.5 | 32.6 | 0.3 | 70 | 70 | 1259.5 | m334 | 0.342914 | 0.00106497 | 0.00132995 | 0.00134127
VB | L70*70*8 | +51.244 | +52.304 | 2 | 4 | 10.1 | 32.6 | 0.3 | 70 | 70 | 1220 | m332 | 0.332177 | 0.00106497 | 0.0012086 | 0.00129927
VB | L70*70*8 | +51.812 | +52.761 | 2 | 4 | 10.1 | 32.6 | 0.3 | 70 | 70 | 1214.9 | m331 | 0.330772 | 0.00106497 | 0.0011937 | 0.00129378
VB | L70*70*8 | +51.244 | +52.304 | 2 | 4 | 10.1 | 32.6 | 0.3 | 70 | 70 | 1220 | m330 | 0.332177 | 0.00106497 | 0.0012086 | 0.00129927
VB | L70*70*8 | +51.812 | +52.761 | 2 | 4 | 10.1 | 32.6 | 0.3 | 70 | 70 | 1214.9 | m329 | 0.330772 | 0.00106497 | 0.0011937 | 0.00129378
VB | L70*70*8 | +55.537 | +56.802 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.4 | m347 | 0.344274 | 0.00106497 | 0.00133525 | 0.00134659
VB | L70*70*8 | +55.526 | +56.792 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.4 | m347 | 0.344244 | 0.00106497 | 0.00133513 | 0.00134647
VB | L70*70*8 | +54.544 | +55.810 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1265.2 | m347 | 0.344473 | 0.00106497 | 0.00133602 | 0.00134737
VB | L70*70*8 | +54.533 | +55.799 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1265.2 | m347 | 0.344444 | 0.00106497 | 0.0013359 | 0.00134725
VB | L70*70*8 | +53.552 | +54.818 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.9 | m347 | 0.344413 | 0.00106497 | 0.00133579 | 0.00134713
VB | L70*70*8 | +53.541 | +54.807 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1264.9 | m347 | 0.344384 | 0.00106497 | 0.00133567 | 0.00134702
VB | L70*70*8 | +52.559 | +53.826 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1265.6 | m347 | 0.344598 | 0.00106497 | 0.0013365 | 0.00134785
VB | L70*70*8 | +52.548 | +53.815 | 2 | 4 | 10.6 | 32.6 | 0.3 | 70 | 70 | 1265.6 | m347 | 0.344579 | 0.00106497 | 0.00133642 | 0.00134778
VB | UB254*146*37 | +55.067 | +55.358 | 1 | 99 | 10.6 | 28.9 | 0.3 | 256 | 146.4 | 286.8 | m254 | 0.307399 | 0.00471338 | 0.000983409 | 0.00135163
VB | UB254*146*37 | +55.067 | +55.358 | 1 | 99 | 10.6 | 28.9 | 0.3 | 256 | 146.4 | 286.8 | m254 | 0.307399 | 0.00471338 | 0.000983418 | 0.00135163

# IfcDiscreteAccessory: Vastrap Plate (3)
In: Undefined
Description: PL6*456.5; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +52.971; Top elevation: +52.978; Phase: 6; Class: 8
Tekla Quantity - Weight: 13.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 43.4 m2; Net surface area: 0.6 m2; Height: 456.5 mm; Width: 6 mm; Length: 620 mm
Pset_PlateCommon - LoadBearing: yes; Reference: p665
BaseQuantities - CrossSectionArea: 0.000036 m2
Name | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
Vastrap Plate | 0.578937 | 0.28301 | 0.00169806
2 x Vastrap Plate | 0.57897 | 0.283026 | 0.00169816

# IfcDiscreteAccessory: Walkway_Angle (24)
In: Undefined
Description: L125*75*8; Material: STEEL/S355JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 32 m2; Height: 125 mm; Width: 75 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00155414 m2
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
4 x Walkway_Angle | +57.262 | +57.387 | 2 | 3 | 2 | 0.1 | 159.8 | m234 | 0.0623979 | 0.000241756 | 0.000248299
4 x Walkway_Angle | +57.262 | +57.387 | 2 | 3 | 2 | 0.1 | 159.8 | m235 | 0.0623979 | 0.000241756 | 0.000248299
4 x Walkway_Angle | +57.137 | +57.262 | 3 | 99 | 2.7 | 0.1 | 220 | m232 | 0.0859227 | 0.000327744 | 0.000341911
4 x Walkway_Angle | +57.137 | +57.262 | 3 | 99 | 2.7 | 0.1 | 220 | m233 | 0.0859227 | 0.000327744 | 0.000341911
Walkway_Angle | +57.228 | +57.387 | 2 | 3 | 17.7 | 0.6 | 1453.2 | m237 | 0.567572 | 0.00223089 | 0.00225853
Walkway_Angle | +57.228 | +57.387 | 2 | 3 | 17.7 | 0.6 | 1453.2 | m231 | 0.567572 | 0.00223089 | 0.00225853
2 x Walkway_Angle | +57.228 | +57.387 | 2 | 3 | 17.7 | 0.6 | 1452.2 | m220 | 0.567172 | 0.00223027 | 0.00225694
2 x Walkway_Angle | +57.228 | +57.387 | 2 | 3 | 17.7 | 0.6 | 1453.3 | m221 | 0.567582 | 0.00223081 | 0.00225857
Walkway_Angle | +57.228 | +57.387 | 2 | 3 | 17.7 | 0.6 | 1453.2 | m236 | 0.567572 | 0.00223089 | 0.00225853
Walkway_Angle | +57.228 | +57.387 | 2 | 3 | 17.7 | 0.6 | 1453.2 | m230 | 0.567572 | 0.00223089 | 0.00225853

# IfcDiscreteAccessory: Wire Mesh (123)
In: Undefined
Material: Undefined/VEM 6320H
Tekla Common - Class: 8
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Width: 3 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.000009 m2
Name | Description | Bottom elevation | Top elevation | Phase | Gross footprint area (m2) | Net surface area (m2) | Height (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
6 x Wire Mesh | PL3*467 | +50.362 | +52.574 | 9 | 0 | 2.1 | 467 | 2212 | p356 | 2.08208 | 1.033 | 0.00309901 | 0.00309901
6 x Wire Mesh | PL3*458 | +57.340 | +58.300 | 9 | 0 | 0.9 | 458 | 960 | p350 | 0.816424 | 0.43968 | 0.00120879 | 0.00131904
6 x Wire Mesh | PL3*631 | +57.340 | +58.300 | 9 | 0 | 1.3 | 631 | 960 | p362 | 1.22107 | 0.60576 | 0.00181728 | 0.00181728
6 x Wire Mesh | PL3*606 | +57.340 | +58.300 | 9 | 0 | 1.3 | 606 | 960 | p361 | 1.17292 | 0.58176 | 0.00174528 | 0.00174528
4 x Wire Mesh | PL3*560 | +56.855 | +57.815 | 12 | 0 | 0.9 | 560 | 960 | p351 | 1.01288 | 0.5376 | 0.00150255 | 0.0016128
2 x Wire Mesh | PL3*560 | +56.855 | +57.815 | 12 | 0 | 0.9 | 560 | 960 | p351 | 1.01287 | 0.537596 | 0.00150254 | 0.00161279
3 x Wire Mesh | PL3*710 | +50.362 | +52.574 | 9 | 0 | 3.1 | 710 | 2212 | p349 | 3.08713 | 1.57052 | 0.00460131 | 0.00471156
3 x Wire Mesh | PL3*597 | +50.362 | +52.574 | 9 | 0 | 2.7 | 597 | 2212 | p354 | 2.65798 | 1.32056 | 0.00396168 | 0.00396168
11 x Wire Mesh | PL3*297 | +57.340 | +58.254 | 9 | 0 | 0.6 | 297 | 914 | p359 | 0.550183 | 0.271459 | 0.000814376 | 0.000814376
6 x Wire Mesh | PL3*297 | +58.314 | +58.317 | 9 | 0.5 | 1.1 | 297 | 1787 | p360 | 1.07398 | 0.530739 | 0.00159222 | 0.00159222
Wire Mesh | PL3*297 | +57.340 | +58.254 | 3 | 0 | 0.6 | 297 | 914 | p359 | 0.550183 | 0.271459 | 0.000814376 | 0.000814376
3 x Wire Mesh | PL3*560 | +56.855 | +57.815 | 12 | 0 | 1.1 | 560 | 960 | p358 | 1.08432 | 0.5376 | 0.0016128 | 0.0016128
6 x Wire Mesh | PL3*600.9 | +56.855 | +57.815 | 12 | 0 | 1.3 | 600.9 | 960 | p357 | 1.1631 | 0.576867 | 0.0017306 | 0.0017306
6 x Wire Mesh | PL3*601 | +56.855 | +57.815 | 12 | 0 | 1.3 | 601 | 960 | p357 | 1.16329 | 0.57696 | 0.00173088 | 0.00173088
3 x Wire Mesh | PL3*560 | +56.855 | +57.815 | 12 | 0 | 1.1 | 560 | 960.1 | p358 | 1.08422 | 0.537632 | 0.00161266 | 0.00161266
3 x Wire Mesh | PLT3*363.5 | +57.848 | +58.106 | 5 | 0 | 1.1 | 363.5 | 1510 | p397 | 1.10913 | 0.548943 | 0.00164683 | 0.00164683
Wire Mesh | PLT3*719 | +57.071 | +57.790 | 5 | 0 | 2.2 | 719 | 1510 | p396 | 2.18476 | 1.08569 | 0.00325707 | 0.00325707
2 x Wire Mesh | PLT3*905 | +56.931 | +58.051 | 5 | 0 | 1.6 | 905 | 1120 | p393 | 1.56206 | 1.01359 | 0.00232071 | 0.00232071
2 x Wire Mesh | PLT3*905 | +56.931 | +58.051 | 5 | 0 | 1.6 | 905 | 1120 | p393 | 1.56207 | 1.0136 | 0.00232073 | 0.00232073
Wire Mesh | PLT3*749.9 | +58.571 | +59.370 | 5 | 0 | 1.3 | 749.9 | 799.7 | p395 | 1.19968 | 0.599723 | 0.00178563 | 0.00178563
3 x Wire Mesh | PLT3*749.9 | +58.571 | +59.370 | 5 | 0 | 1.3 | 749.9 | 799.7 | p395 | 1.19962 | 0.599724 | 0.00178554 | 0.00178554
2 x Wire Mesh | PLT3*720 | +57.070 | +57.790 | 5 | 0 | 2.2 | 720 | 1510 | p396 | 2.18778 | 1.0872 | 0.0032616 | 0.0032616
Wire Mesh | PLT3*905 | +56.931 | +58.051 | 5 | 0 | 1.6 | 905 | 1120 | p393 | 1.56208 | 1.0136 | 0.00232073 | 0.00232073
2 x Wire Mesh | PLT3*749.9 | +58.571 | +59.370 | 5 | 0 | 1.3 | 749.9 | 799.7 | p395 | 1.19962 | 0.599723 | 0.00178553 | 0.00178553
Wire Mesh | PLT3*905 | +56.931 | +58.051 | 5 | 0 | 1.6 | 905 | 1120 | p393 | 1.56206 | 1.01359 | 0.00232072 | 0.00232072
3 x Wire Mesh | PLT3*675.2 | +58.105 | +58.108 | 5 | 1 | 2.1 | 675.2 | 1510 | p394 | 2.05213 | 1.01951 | 0.00305853 | 0.00305853
9 x Wire Mesh | PL3*597 | +50.362 | +52.574 | 9 | 0 | 2.7 | 597 | 2212 | p354 | 2.65798 | 1.32056 | 0.00396169 | 0.00396169
6 x Wire Mesh | PL3*710 | +50.362 | +52.574 | 9 | 0 | 3.2 | 710 | 2212 | p355 | 3.15857 | 1.57052 | 0.00471156 | 0.00471156
6 x Wire Mesh | PL3*710 | +50.362 | +52.574 | 9 | 0 | 3.2 | 710 | 2212 | p355 | 3.15859 | 1.57053 | 0.00471159 | 0.00471159
3 x Wire Mesh | PL3*710 | +50.362 | +52.574 | 9 | 0 | 3.1 | 710 | 2212 | p348 | 3.08713 | 1.57052 | 0.00460131 | 0.00471156
3 x Wire Mesh | PL3*710 | +50.362 | +52.574 | 9 | 0 | 3.1 | 710 | 2212 | p348 | 3.08713 | 1.57052 | 0.00460132 | 0.00471156
3 x Wire Mesh | PL3*710 | +50.362 | +52.574 | 9 | 0 | 3.1 | 710 | 2212 | p347 | 3.08715 | 1.57052 | 0.00460134 | 0.00471156

# IfcElementAssembly (3904)
In: Undefined
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Steel Assembly | RIGID_FRAME | 16.4 | +52.183 | +52.659 | 13/B-C | A742 | 162
Steel Assembly | RIGID_FRAME | 16.4 | +52.183 | +52.659 | 13/C-D | A743 | 162
Steel Assembly | RIGID_FRAME | 5.5 | +53.146 | +53.371 | 12/B-C | A812 | 248.261
Steel Assembly | RIGID_FRAME | 5.5 | +52.674 | +52.889 | 11/B-C | A811 | 242.103
Steel Assembly | RIGID_FRAME | 5.5 | +53.146 | +53.371 | 12/C-D | A812 | 248.261
Steel Assembly | RIGID_FRAME | 5.5 | +52.674 | +52.889 | 11/C-D | A811 | 242.103
Steel Assembly | RIGID_FRAME | 5.3 | +52.184 | +52.383 | 10/B-C | A810 | 231.735
Steel Assembly | RIGID_FRAME | 5.3 | +52.184 | +52.383 | 10/C-D | A810 | 231.735
Steel Assembly | RIGID_FRAME | 5.2 | +51.701 | +51.876 | 9/B-C | A809 | 215.159
Steel Assembly | RIGID_FRAME | 5.2 | +51.701 | +51.876 | 9/C-D | A809 | 215.159
Steel Assembly | RIGID_FRAME | 5.7 | +51.212 | +51.375 | 8/B-C | A813 | 189.547
Steel Assembly | RIGID_FRAME | 5.7 | +51.212 | +51.375 | 8/C-D | A813 | 189.547
Steel Assembly | RIGID_FRAME | 4.8 | +52.377 | +52.596 | 13/B-C | A739 | 10
Steel Assembly | RIGID_FRAME | 4.8 | +52.377 | +52.596 | 13/C-D | A739 | 10
Steel Assembly | RIGID_FRAME | 43.2 | +52.377 | +52.457 | 13/B-D | A296 | 80
Steel Assembly | RIGID_FRAME | 31.4 | +53.186 | +53.266 | 12/B-D | A297 | 80
Steel Assembly | RIGID_FRAME | 31.3 | +52.710 | +52.790 | 11/B-D | A298 | 80
Steel Assembly | RIGID_FRAME | 31.3 | +52.214 | +52.294 | 10/B-D | A299 | 80
Steel Assembly | RIGID_FRAME | 31.1 | +51.718 | +51.798 | 9/B-D | A300 | 80
Steel Assembly | RIGID_FRAME | 30.8 | +51.221 | +51.301 | 8/B-D | A301 | 80
Steel Assembly | RIGID_FRAME | 970.8 | +52.547 | +54.828 | 8-9/C-D | A246 | 1682
Steel Assembly | RIGID_FRAME | 970.8 | +52.547 | +54.828 | 8-9/B-C | A252 | 1682
Steel Assembly | RIGID_FRAME | 652.6 | +50.966 | +52.843 | 6-7/C-D | A238 | 1682
Steel Assembly | RIGID_FRAME | 652 | +50.966 | +52.843 | 6-7/A-B | A237 | 1682
Steel Assembly | RIGID_FRAME | 652.6 | +50.966 | +52.843 | 6-7/B-C | A236 | 1682
Steel Assembly | RIGID_FRAME | 9.3 | +58.280 | +58.401 | 15-16/D-E | A481 | 121
Steel Assembly | RIGID_FRAME | 562.7 | +56.972 | +59.714 | 20-21/C-D | A62 | 2130.1
Steel Assembly | RIGID_FRAME | 562.7 | +56.972 | +59.714 | 20-21/B-C | A62 | 2130.1
Steel Assembly | RIGID_FRAME | 562.7 | +56.972 | +59.714 | 20-21/A-B | A62 | 2130.1
Steel Assembly | RIGID_FRAME | 106.8 | +57.067 | +57.400 | 15-17/C-D | A179 | 166.7
Steel Assembly | RIGID_FRAME | 106.8 | +57.067 | +57.400 | 15-17/C-D | A178 | 166.7
Steel Assembly | RIGID_FRAME | 106.8 | +57.067 | +57.400 | 15-17/B-C | A179 | 166.7
Steel Assembly | RIGID_FRAME | 688.2 | +56.331 | +56.817 | 13/A-E | A13 | 408
Steel Assembly | RIGID_FRAME | 285.6 | +51.006 | +52.249 | 2-6/A-B | A39 | 258.137
Steel Assembly | RIGID_FRAME | 280.1 | +51.006 | +52.249 | 2-6/B-C | A44 | 257.549
Steel Assembly | RIGID_FRAME | 285.6 | +51.006 | +52.249 | 2-6/B-C | A37 | 258.137
Steel Assembly | RIGID_FRAME | 280.1 | +51.006 | +52.249 | 2-6/C-D | A44 | 257.549
Steel Assembly | RIGID_FRAME | 285.6 | +51.006 | +52.249 | 2-6/C-D | A38 | 258.137
Steel Assembly | RIGID_FRAME | 280.1 | +51.006 | +52.249 | 2-6/D-E | A44 | 257.549
Steel Assembly | RIGID_FRAME | 1.1 | +50.932 | +50.992 | 5/A-B | A677 | 90
Steel Assembly | RIGID_FRAME | 36.5 | +50.242 | +51.017 | 4-5/A-B | A318 | 90
Steel Assembly | RIGID_FRAME | 84.1 | +58.004 | +58.417 | 13-16/D-E | A686 | 324.668
Steel Assembly | RIGID_FRAME | 84.1 | +58.004 | +58.417 | 13-16/C-D | A686 | 324.668
Steel Assembly | RIGID_FRAME | 84.1 | +58.004 | +58.417 | 13-16/B-C | A686 | 324.668
Steel Assembly | RIGID_FRAME | 84.1 | +58.004 | +58.417 | 13-16/C-D | A685 | 377.48
Steel Assembly | RIGID_FRAME | 84.1 | +58.004 | +58.417 | 13-16/B-C | A685 | 377.48
Steel Assembly | RIGID_FRAME | 84.1 | +58.004 | +58.417 | 13-16/A-B | A685 | 377.48
Steel Assembly | RIGID_FRAME | 969.5 | +55.525 | +57.762 | 11-12/A-B | A243 | 1682
Steel Assembly | RIGID_FRAME | 969.5 | +55.525 | +57.762 | 11-12/B-C | A242 | 1682
Steel Assembly | RIGID_FRAME | 969.5 | +55.525 | +57.762 | 11-12/C-D | A245 | 1682
Steel Assembly | RIGID_FRAME | 30 | +51.014 | +51.339 | 5-6/A-B | A260 | 145.002
Steel Assembly | RIGID_FRAME | 30 | +51.014 | +51.339 | 5-6/B-C | A262 | 145.002
Steel Assembly | RIGID_FRAME | 30 | +51.014 | +51.339 | 5-6/C-D | A262 | 145.002
Steel Assembly | RIGID_FRAME | 30 | +51.014 | +51.339 | 5-6/A-B | A257 | 145
Steel Assembly | RIGID_FRAME | 30 | +51.014 | +51.339 | 5-6/B-C | A259 | 145
Steel Assembly | RIGID_FRAME | 30 | +51.014 | +51.339 | 5-6/C-D | A259 | 145
Steel Assembly | RIGID_FRAME | 30 | +51.014 | +51.339 | 5-6/D-E | A261 | 145.002
Steel Assembly | RIGID_FRAME | 30 | +51.014 | +51.339 | 5-6/D-E | A258 | 145
Steel Assembly | RIGID_FRAME | 1.1 | +50.932 | +50.992 | 5/D-E | A677 | 90
Steel Assembly | RIGID_FRAME | 69.8 | +52.690 | +53.225 | 6-7/B | A414 | 160.4
Steel Assembly | RIGID_FRAME | 71.1 | +52.567 | +53.102 | 5-6/B | A34 | 168.4
Steel Assembly | RIGID_FRAME | 47.8 | +52.814 | +53.308 | 6-7/B | A416 | 160.401
Steel Assembly | RIGID_FRAME | 69.8 | +52.443 | +52.978 | 4-6/B | A403 | 160.4
Steel Assembly | RIGID_FRAME | 84.3 | +52.293 | +52.854 | 4-5/B | A410 | 160.4
Steel Assembly | RIGID_FRAME | 69.8 | +52.690 | +53.225 | 6-7/B | A413 | 160.401
Steel Assembly | RIGID_FRAME | 69.8 | +52.567 | +53.102 | 5-6/B | A404 | 160.4
Steel Assembly | RIGID_FRAME | 47.8 | +52.814 | +53.308 | 6-7/B | A415 | 160.4
Steel Assembly | RIGID_FRAME | 69.8 | +52.443 | +52.978 | 4-6/B | A402 | 160.4
Steel Assembly | RIGID_FRAME | 84.3 | +52.293 | +52.854 | 4-5/B | A409 | 160.401
Steel Assembly | RIGID_FRAME | 69.8 | +52.690 | +53.225 | 6-7/C | A414 | 160.4
Steel Assembly | RIGID_FRAME | 71.1 | +52.567 | +53.102 | 5-6/C | A34 | 168.4
Steel Assembly | RIGID_FRAME | 47.8 | +52.814 | +53.308 | 6-7/C | A416 | 160.401
Steel Assembly | RIGID_FRAME | 69.8 | +52.443 | +52.978 | 4-6/C | A403 | 160.4
Steel Assembly | RIGID_FRAME | 84.3 | +52.293 | +52.854 | 4-5/C | A410 | 160.4
Steel Assembly | RIGID_FRAME | 69.8 | +52.690 | +53.225 | 6-7/C | A413 | 160.401
Steel Assembly | RIGID_FRAME | 69.8 | +52.567 | +53.102 | 5-6/C | A404 | 160.4
Steel Assembly | RIGID_FRAME | 47.8 | +52.814 | +53.308 | 6-7/C | A415 | 160.4
Steel Assembly | RIGID_FRAME | 69.8 | +52.443 | +52.978 | 4-6/C | A402 | 160.4
Steel Assembly | RIGID_FRAME | 84.3 | +52.293 | +52.854 | 4-5/C | A409 | 160.401
Steel Assembly | RIGID_FRAME | 69.8 | +52.690 | +53.225 | 6-7/D | A414 | 160.4
Steel Assembly | RIGID_FRAME | 71.1 | +52.567 | +53.102 | 5-6/D | A34 | 168.4
Steel Assembly | RIGID_FRAME | 47.8 | +52.814 | +53.308 | 6-7/D | A416 | 160.401
Steel Assembly | RIGID_FRAME | 69.8 | +52.443 | +52.978 | 4-6/D | A403 | 160.4
Steel Assembly | RIGID_FRAME | 84.3 | +52.293 | +52.854 | 4-5/D | A411 | 160.4
Steel Assembly | RIGID_FRAME | 69.8 | +52.690 | +53.225 | 6-7/D | A413 | 160.401
Steel Assembly | RIGID_FRAME | 69.8 | +52.567 | +53.102 | 5-6/D | A404 | 160.4
Steel Assembly | RIGID_FRAME | 47.8 | +52.814 | +53.308 | 6-7/D | A415 | 160.4
Steel Assembly | RIGID_FRAME | 69.8 | +52.443 | +52.978 | 4-6/D | A402 | 160.4
Steel Assembly | RIGID_FRAME | 84.3 | +52.293 | +52.854 | 4-5/D | A412 | 160.401
Steel Assembly | RIGID_FRAME | 13.2 | +51.882 | +52.062 | 5/C-E | A43 | 100
Steel Assembly | RIGID_FRAME | 13.4 | +51.635 | +51.814 | 4/C-E | A42 | 100.025
Steel Assembly | RIGID_FRAME | 13.4 | +51.635 | +51.814 | 4/B-D | A42 | 100.025
Steel Assembly | RIGID_FRAME | 13.2 | +51.882 | +52.062 | 5/B-D | A43 | 100
Steel Assembly | RIGID_FRAME | 13.2 | +51.882 | +52.062 | 5/A-C | A43 | 100
Steel Assembly | RIGID_FRAME | 13.4 | +51.635 | +51.814 | 4/A-C | A42 | 100.025
Steel Assembly | RIGID_FRAME | 13.4 | +51.386 | +51.566 | 3/A-C | A42 | 100.175
Steel Assembly | RIGID_FRAME | 13.4 | +51.386 | +51.566 | 3/B-D | A42 | 100.175
Steel Assembly | RIGID_FRAME | 13.4 | +51.386 | +51.566 | 3/C-E | A42 | 100.175
Steel Assembly | RIGID_FRAME | 9.9 | +57.791 | +58.411 | 15-16/C-D | A441 | 60
Steel Assembly | RIGID_FRAME | 9.9 | +57.791 | +58.411 | 15-16/B-C | A441 | 60
Steel Assembly | RIGID_FRAME | 9.9 | +57.791 | +58.411 | 15-16/D-E | A442 | 60
Steel Assembly | RIGID_FRAME | 9.9 | +57.791 | +58.411 | 15-16/C-D | A442 | 60
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.594 | 1/D-E | A535 | 507
Steel Assembly | RIGID_FRAME | 5.3 | +52.152 | +52.202 | 1/C-E | A724 | 50
Steel Assembly | RIGID_FRAME | 963 | +56.476 | +58.318 | 12-13/C-D | A247 | 1682
Steel Assembly | RIGID_FRAME | 963.3 | +56.476 | +58.318 | 12-13/B-C | A255 | 1682
Steel Assembly | RIGID_FRAME | 963.1 | +56.476 | +58.318 | 12-13/A-B | A256 | 1682
Steel Assembly | RIGID_FRAME | 73.8 | +52.307 | +52.521 | 6-7/A-C | A792 | 1996.27
Steel Assembly | RIGID_FRAME | 74.1 | +51.812 | +52.027 | 4-5/C-E | A798 | 2003.71
Steel Assembly | RIGID_FRAME | 74.1 | +51.812 | +52.027 | 4-5/A-C | A798 | 2003.71
Steel Assembly | RIGID_FRAME | 74.1 | +51.812 | +52.027 | 4-5/B-D | A798 | 2003.71
2 x Steel Assembly |  | 0 | +51.558 | +51.920 | 4-5/D-E | A570 | 34
2 x Steel Assembly |  | 0 | +51.894 | +52.030 | 4-5/D-E | A558 | 117.021
2 x Steel Assembly |  | 0 | +51.558 | +51.920 | 4-5/C-D | A570 | 34
2 x Steel Assembly |  | 0 | +51.894 | +52.030 | 4-5/C-D | A558 | 117.021
2 x Steel Assembly |  | 0 | +51.558 | +51.920 | 4-5/B-C | A570 | 34
2 x Steel Assembly |  | 0 | +51.894 | +52.030 | 4-5/B-C | A558 | 117.021
2 x Steel Assembly |  | 0 | +51.558 | +51.920 | 4-5/A-B | A570 | 34
2 x Steel Assembly |  | 0 | +51.894 | +52.030 | 4-5/A-B | A558 | 117.027
Steel Assembly | RIGID_FRAME | 970.1 | +54.532 | +56.812 | 10-11/C-D | A244 | 1682
Steel Assembly | RIGID_FRAME | 969.7 | +51.554 | +53.835 | 7-8/C-D | A250 | 1682
Steel Assembly | RIGID_FRAME | 969.7 | +51.554 | +53.835 | 7-8/B-C | A248 | 1682
3 x Steel Assembly | RIGID_FRAME | 1.1 | +50.932 | +50.992 | 5/A-B | -38AL171 | 90
Steel Assembly | RIGID_FRAME | 36.5 | +50.242 | +51.017 | 4-5/A-B | A317 | 90
4 x Steel Assembly | RIGID_FRAME | 1.1 | +50.932 | +50.992 | 5/B-C | -38AL171 | 90
Steel Assembly | RIGID_FRAME | 36.5 | +50.242 | +51.017 | 4-5/B-C | A319 | 90
Steel Assembly | RIGID_FRAME | 36.5 | +50.242 | +51.017 | 4-5/B-C | A320 | 90
4 x Steel Assembly | RIGID_FRAME | 1.1 | +50.932 | +50.992 | 5/C-D | -38AL171 | 90
Steel Assembly | RIGID_FRAME | 36.5 | +50.242 | +51.017 | 4-5/C-D | A319 | 90
Steel Assembly | RIGID_FRAME | 36.5 | +50.242 | +51.017 | 4-5/C-D | A318 | 90
3 x Steel Assembly | RIGID_FRAME | 1.1 | +50.932 | +50.992 | 5/D-E | -38AL171 | 90
Steel Assembly | RIGID_FRAME | 36.5 | +50.242 | +51.017 | 4-5/D-E | A318 | 90
Steel Assembly | RIGID_FRAME | 23.3 | +55.195 | +56.605 | 13/A-C | A435 | 100
Steel Assembly | RIGID_FRAME | 51.8 | +52.413 | +54.862 | 13/A-B | A395 | 165.1
Steel Assembly | RIGID_FRAME | 367.5 | +54.659 | +55.469 | 13/A-E | A372 | 810.473
Steel Assembly | RIGID_FRAME | 24.3 | +56.735 | +57.400 | 17-18/D-E | A332 | 155
Steel Assembly | RIGID_FRAME | 44.4 | +56.735 | +57.400 | 17-18/D-E | A92 | 334.696
Steel Assembly | RIGID_FRAME | 24.3 | +56.735 | +57.400 | 17-18/C-D | A333 | 155
Steel Assembly | RIGID_FRAME | 52.8 | +56.735 | +57.400 | 17-18/C-D | A49 | 152.4
Steel Assembly | RIGID_FRAME | 24.3 | +56.735 | +57.400 | 17-18/C-D | A331 | 155
Steel Assembly | RIGID_FRAME | 66.7 | +57.067 | +57.400 | 16-18/C-D | A60 | 250
Steel Assembly | RIGID_FRAME | 66.7 | +57.067 | +57.400 | 16-18/C-D | A61 | 250
Steel Assembly | RIGID_FRAME | 24.3 | +56.735 | +57.400 | 17-18/B-C | A333 | 155
Steel Assembly | RIGID_FRAME | 52.8 | +56.735 | +57.400 | 17-18/B-C | A48 | 152.4
Steel Assembly | RIGID_FRAME | 24.3 | +56.735 | +57.400 | 17-18/B-C | A331 | 155
Steel Assembly | RIGID_FRAME | 24.3 | +56.735 | +57.400 | 17-18/A-B | A331 | 155
Steel Assembly | RIGID_FRAME | 44.3 | +56.735 | +57.400 | 17-18/A-B | A57 | 323.189
Steel Assembly | RIGID_FRAME | 76.3 | +52.436 | +55.027 | 13/C-D | A396 | 165.1
Steel Assembly | RIGID_FRAME | 51.8 | +52.413 | +54.862 | 13/D-E | A395 | 165.1
Steel Assembly | RIGID_FRAME | 225.6 | +50.242 | +55.395 | 13/D-E | A12 | 494.97
Steel Assembly | RIGID_FRAME | 79.2 | +55.267 | +56.793 | 13/D-E | A23 | 150
Steel Assembly | RIGID_FRAME | 225.6 | +50.242 | +55.395 | 13/A-B | A14 | 494.97
Steel Assembly | RIGID_FRAME | 79.2 | +55.267 | +56.793 | 13/A-B | A23 | 150
Steel Assembly | RIGID_FRAME | 9.9 | +56.817 | +57.067 | 13/B-C | A391 | 173
Steel Assembly | RIGID_FRAME | 347.1 | +57.067 | +57.400 | 13/A-E | A78 | 455.958
Steel Assembly | RIGID_FRAME | 9.9 | +56.817 | +57.067 | 13/C | A391 | 173
Steel Assembly | RIGID_FRAME | 9.9 | +56.817 | +57.067 | 13/C-D | A392 | 173
2 x Liner Plate |  | 0 | +52.777 | +53.219 | 6-7/D | A834 | 16
2 x Liner Plate |  | 0 | +52.777 | +53.219 | 6-7/B | A834 | 16
2 x Liner Plate |  | 0 | +52.777 | +53.219 | 6-7/C | A834 | 16
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.594 | 1/B-C | A535 | 507
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.594 | 1/A-B | A536 | 507.009
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.594 | 1/C-D | A536 | 507.009
Steel Assembly | RIGID_FRAME | 18.3 | +50.956 | +52.254 | 6/C-D | A315 | 312.262
Steel Assembly | RIGID_FRAME | 18.3 | +50.956 | +52.254 | 6/D-E | A316 | 312.262
Steel Assembly | RIGID_FRAME | 18.3 | +50.956 | +52.254 | 6/B-C | A315 | 312.262
Steel Assembly | RIGID_FRAME | 18.3 | +50.956 | +52.254 | 6/C-D | A316 | 312.262
Steel Assembly | RIGID_FRAME | 18.3 | +50.956 | +52.254 | 6/A-B | A315 | 312.262
Steel Assembly | RIGID_FRAME | 18.3 | +50.956 | +52.254 | 6/B-C | A316 | 312.262
Steel Assembly | RIGID_FRAME | 21.9 | +50.392 | +52.059 | 5/D-E | A41 | 276.213
Steel Assembly | RIGID_FRAME | 21.9 | +50.392 | +52.059 | 5/C-D | A36 | 276.211
Steel Assembly | RIGID_FRAME | 21.9 | +50.392 | +52.059 | 5/C-D | A41 | 276.211
Steel Assembly | RIGID_FRAME | 21.9 | +50.392 | +52.059 | 5/B-C | A36 | 276.211
Steel Assembly | RIGID_FRAME | 21.9 | +50.392 | +52.059 | 5/B-C | A41 | 276.211
Steel Assembly | RIGID_FRAME | 21.9 | +50.392 | +52.059 | 5/A-B | A36 | 276.211
Steel Assembly | RIGID_FRAME | 5.3 | +52.152 | +52.202 | 1/A-C | A724 | 50
Steel Assembly | RIGID_FRAME | 10.8 | +52.152 | +52.202 | 1-2/B-C | A725 | 50
Steel Assembly | RIGID_FRAME | 10.8 | +52.152 | +52.202 | 1-2/A-B | A726 | 50
Steel Assembly | RIGID_FRAME | 5.3 | +52.152 | +52.202 | 1/B-D | A724 | 50
Steel Assembly | RIGID_FRAME | 10.8 | +52.152 | +52.202 | 1-2/C-D | A725 | 50
Steel Assembly | RIGID_FRAME | 10.8 | +52.152 | +52.202 | 1-2/B-C | A726 | 50
Steel Assembly | RIGID_FRAME | 10.8 | +52.152 | +52.202 | 1-2/D-E | A725 | 50
Steel Assembly | RIGID_FRAME | 10.8 | +52.152 | +52.202 | 1-2/C-D | A726 | 50
Steel Assembly | RIGID_FRAME | 13.4 | +50.342 | +52.594 | 1/B-C | A527 | 637
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.594 | 2/A-B | A528 | 637
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.594 | 2/B-C | A529 | 637
Steel Assembly | RIGID_FRAME | 13.4 | +50.342 | +52.594 | 1/A-B | A526 | 637
Steel Assembly | RIGID_FRAME | 14.7 | +50.342 | +52.594 | 1/B-C | A533 | 750
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 1-2/A-B | A534 | 750
2 x Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 1-2/B-C | A534 | 750.001
Steel Assembly | RIGID_FRAME | 14.7 | +50.342 | +52.594 | 1-2/B-C | A532 | 750
2 x Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 1-2/B-C | A534 | 750
Steel Assembly | RIGID_FRAME | 14.7 | +50.342 | +52.594 | 1-2/A-B | A531 | 750
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 1-2/A-B | A534 | 750.001
Steel Assembly | RIGID_FRAME | 14.7 | +50.342 | +52.594 | 1/A-B | A530 | 750
Steel Assembly | RIGID_FRAME | 13.4 | +50.342 | +52.594 | 1/C-D | A527 | 637
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.594 | 2/B-C | A528 | 637
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.594 | 1/B-C | A536 | 507.009
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.594 | 1/C-D | A535 | 507
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.594 | 2/C-D | A529 | 637
Steel Assembly | RIGID_FRAME | 13.4 | +50.342 | +52.594 | 1/B-C | A526 | 637
Steel Assembly | RIGID_FRAME | 14.7 | +50.342 | +52.594 | 1/C-D | A533 | 750
2 x Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 1-2/C-D | A534 | 750.001
Steel Assembly | RIGID_FRAME | 14.7 | +50.342 | +52.594 | 1-2/C-D | A532 | 750
2 x Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 1-2/C-D | A534 | 750
Steel Assembly | RIGID_FRAME | 14.7 | +50.342 | +52.594 | 1-2/B-C | A531 | 750
Steel Assembly | RIGID_FRAME | 14.7 | +50.342 | +52.594 | 1/B-C | A530 | 750
Steel Assembly | RIGID_FRAME | 13.4 | +50.342 | +52.594 | 1/D-E | A527 | 637
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.594 | 2/C-D | A528 | 637
Steel Assembly | RIGID_FRAME | 13 | +50.342 | +52.594 | 2/D-E | A529 | 637
Steel Assembly | RIGID_FRAME | 13.4 | +50.342 | +52.594 | 1/C-D | A526 | 637
Steel Assembly | RIGID_FRAME | 14.7 | +50.342 | +52.594 | 1/D-E | A533 | 750
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 1-2/D-E | A534 | 750.001
Steel Assembly | RIGID_FRAME | 14.7 | +50.342 | +52.594 | 1-2/D-E | A532 | 750
Steel Assembly | RIGID_FRAME | 13.6 | +50.342 | +52.594 | 1-2/D-E | A534 | 750
Steel Assembly | RIGID_FRAME | 14.7 | +50.342 | +52.594 | 1-2/C-D | A531 | 750
Steel Assembly | RIGID_FRAME | 14.7 | +50.342 | +52.594 | 1/C-D | A530 | 750
Steel Assembly | RIGID_FRAME | 5.2 | +50.652 | +50.702 | 1/A-C | A729 | 50
Steel Assembly | RIGID_FRAME | 5.2 | +50.652 | +50.702 | 1/B-D | A729 | 50
Steel Assembly | RIGID_FRAME | 9.9 | +50.652 | +50.702 | 1-2/B-C | A728 | 50
Steel Assembly | RIGID_FRAME | 9.9 | +50.652 | +50.702 | 1-2/A-B | A727 | 50
Steel Assembly | RIGID_FRAME | 9.9 | +50.652 | +50.702 | 1-2/C-D | A728 | 50
Steel Assembly | RIGID_FRAME | 9.9 | +50.652 | +50.702 | 1-2/B-C | A727 | 50
Steel Assembly | RIGID_FRAME | 74 | +51.977 | +52.192 | 4-6/A-C | A790 | 2000
Steel Assembly | RIGID_FRAME | 74 | +51.977 | +52.192 | 4-6/B-D | A795 | 2000
Steel Assembly | RIGID_FRAME | 74 | +51.977 | +52.192 | 4-6/C-E | A795 | 2000
Steel Assembly | RIGID_FRAME | 0.7 | +51.144 | +51.264 | 5-6/A-B | A780 | 69.7606
Steel Assembly | RIGID_FRAME | 6.1 | +51.022 | +51.228 | 5-6/A-B | A603 | 66.1466
Steel Assembly | RIGID_FRAME | 0.7 | +51.096 | +51.221 | 5-6/A-B | A781 | 120.315
Steel Assembly | RIGID_FRAME | 0.7 | +51.144 | +51.264 | 5-6/B-C | A780 | 69.7606
Steel Assembly | RIGID_FRAME | 0.7 | +51.096 | +51.221 | 5-6/B-C | A781 | 120.315
Steel Assembly | RIGID_FRAME | 0.7 | +51.144 | +51.264 | 5-6/C-D | A780 | 69.7606
Steel Assembly | RIGID_FRAME | 0.7 | +51.096 | +51.221 | 5-6/C-D | A781 | 120.315
Steel Assembly | RIGID_FRAME | 91.1 | +51.111 | +53.987 | 5-6/C-D | A556 | 776.03
Steel Assembly | RIGID_FRAME | 91.1 | +51.111 | +53.987 | 5-6/B-C | A556 | 776.03
Steel Assembly | RIGID_FRAME | 91.1 | +51.111 | +53.987 | 5-6/A-B | A556 | 776.015
Steel Assembly | RIGID_FRAME | 78.3 | +52.239 | +53.370 | 6-7/A-B | A408 | 1690.4
Steel Assembly | RIGID_FRAME | 78.3 | +52.156 | +53.287 | 6-7/A-B | A408 | 1690.4
Steel Assembly | RIGID_FRAME | 78.3 | +52.033 | +53.164 | 5-6/A-B | A405 | 1690.4
Steel Assembly | RIGID_FRAME | 78.3 | +51.909 | +53.040 | 5-6/A-B | A405 | 1690.4
Steel Assembly | RIGID_FRAME | 30.3 | +51.786 | +52.917 | 4-5/A-B | A407 | 351.2
Steel Assembly | RIGID_FRAME | 78.3 | +51.662 | +52.793 | 4-5/A-B | A405 | 1690.4
Steel Assembly | RIGID_FRAME | 78.3 | +51.662 | +52.793 | 4-5/B-C | A398 | 1690.4
Steel Assembly | RIGID_FRAME | 30.3 | +51.786 | +52.917 | 4-5/B-C | A407 | 351.2
Steel Assembly | RIGID_FRAME | 78.3 | +51.909 | +53.040 | 5-6/B-C | A398 | 1690.4
Steel Assembly | RIGID_FRAME | 78.3 | +52.033 | +53.164 | 5-6/B-C | A398 | 1690.4
Steel Assembly | RIGID_FRAME | 78.3 | +52.156 | +53.287 | 6-7/B-C | A399 | 1690.4
Steel Assembly | RIGID_FRAME | 78.3 | +52.239 | +53.370 | 6-7/B-C | A399 | 1690.4
Steel Assembly | RIGID_FRAME | 78.3 | +52.239 | +53.370 | 6-7/C-D | A408 | 1690.4
Steel Assembly | RIGID_FRAME | 78.3 | +52.156 | +53.287 | 6-7/C-D | A408 | 1690.4
Steel Assembly | RIGID_FRAME | 78.3 | +52.033 | +53.164 | 5-6/C-D | A405 | 1690.4
Steel Assembly | RIGID_FRAME | 78.3 | +51.909 | +53.040 | 5-6/C-D | A405 | 1690.4
Steel Assembly | RIGID_FRAME | 30.3 | +51.786 | +52.917 | 4-5/C-D | A407 | 351.2
Steel Assembly | RIGID_FRAME | 78.3 | +51.662 | +52.793 | 4-5/C-D | A405 | 1690.4
Steel Assembly | RIGID_FRAME | 30.3 | +51.786 | +52.917 | 4-5/D-E | A406 | 351.2
Steel Assembly | RIGID_FRAME | 30.3 | +51.786 | +52.917 | 4-5/C-D | A406 | 351.2
Steel Assembly | RIGID_FRAME | 30.3 | +51.786 | +52.917 | 4-5/B-C | A406 | 351.2
Steel Assembly | RIGID_FRAME | 5.7 | +57.158 | +57.229 | 12-13/A-B | A646 | 130.007
Steel Assembly | RIGID_FRAME | 5.7 | +57.158 | +57.229 | 12-13/D-E | A646 | 130.007
Steel Assembly | RIGID_FRAME | 20.1 | +55.492 | +55.735 | 17-18/A-B | A188 | 225.001
Steel Assembly | RIGID_FRAME | 20.1 | +55.492 | +55.735 | 17-18/B-C | A189 | 225.001
Steel Assembly | RIGID_FRAME | 513.8 | +56.799 | +58.509 | 19-20/A-B | A63 | 2150.1
Steel Assembly | RIGID_FRAME | 11.9 | +57.280 | +58.407 | 15-16/B-C | A421 | 228.45
Steel Assembly | RIGID_FRAME | 11.9 | +57.280 | +58.407 | 15-16/D-E | A422 | 228.45
