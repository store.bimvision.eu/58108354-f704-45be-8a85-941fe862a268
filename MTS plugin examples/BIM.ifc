Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], ExchangeRequirement[Structural, SurfaceGeometry]
File name: BIM.ifc
Time: 2017-01-18T18:13:19
Author: GEN-PC\GEN
Organization: Structural Designer
Written by: IFC Database Version:Work
Made in: Tekla Structures 21.1, IFC Export Version: 4.0.0.0 Sep 11 2015

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: L70*70*6 (60)
In: Undefined
Description: L70*70*6; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Weight: 6.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 42.7 m2; Net surface area: 0.3 m2; Height: 70 mm; Width: 70 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
12 x Angle | +1.016 | +1.086 | 979.4 | A16 | 979.445 | 0.266678 | 0.000787473 | 6.18167
12 x Angle | +5.103 | +5.173 | 976.9 | A17 | 976.882 | 0.26598 | 0.000785413 | 6.16549
12 x Angle | +4.108 | +4.178 | 976.9 | A17 | 976.883 | 0.26598 | 0.000785414 | 6.1655
12 x Angle | +3.077 | +3.147 | 979.4 | A16 | 979.445 | 0.266678 | 0.000787473 | 6.18167
12 x Angle | +2.046 | +2.116 | 979.4 | A16 | 979.446 | 0.266678 | 0.000787474 | 6.18167

# IfcBeam: PLT20*5500 (2)
In: Undefined
Description: PLT20*5500; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Weight: 15652 kg; Volume: 2 m3; Area per tons: 12.8 m2; Net surface area: 200.3 m2; Height: 5500 mm; Width: 20 mm; Length: 18126.2 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A15
BaseQuantities - Length: 18126.2 mm; OuterSurfaceArea: 200.333 m2; NetVolume: 1.99388 m3; NetWeight: 15652 kg
Name | Bottom elevation | Top elevation | Gross footprint area (m2)
PLATE | +1.000 | +7.086 | 33.2
PLATE | -0.020 | +6.066 | 0.1

# IfcBeam: UB406*140*39 (36)
In: Undefined
Description: UB406*140*39; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 34.1 m2; Height: 397.3 mm; Width: 141.8 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x Beam | +4.289 | +5.169 | 58.9 | 1.9 | 1509.6 | M21 | 1509.61 | 2.01033 | 0.00661434 | 51.9225
12 x Beam | +0.020 | +5.173 | 201 | 7 | 5153.3 | M19 | 5153.29 | 6.86257 | 0.0249089 | 195.535
12 x Beam | +0.020 | +7.196 | 279.9 | 9.7 | 7176.1 | M18 | 7176.12 | 9.55636 | 0.0346864 | 272.289
6 x Beam | +5.789 | +7.202 | 121 | 4 | 3101.5 | M20 | 3101.53 | 4.13027 | 0.014309 | 112.326

# IfcBeam: UB533*210*92 (28)
In: Undefined
Description: UB533*210*92; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 3
Tekla Quantity - Volume: 0.1 m3; Area per tons: 20.2 m2; Height: 533.1 mm; Width: 209.3 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Beam | -0.000 | +0.533 | 457.7 | 1 | 9.4 | 4969.8 | M3 | 4969.8 | 9.24977 | 0.0578959 | 454.483
Beam | +3.000 | +3.533 | 457.7 | 1 | 9.4 | 4969.8 | M3 | 4969.8 | 9.24977 | 0.0578959 | 454.483
Beam | +3.533 | +4.066 | 457.7 | 1 | 9.4 | 4969.8 | M3 | 4969.8 | 9.24977 | 0.0578959 | 454.483
Beam | +0.000 | +0.533 | 437.2 | 1 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +0.095 | +0.667 | 437.2 | 0 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +0.443 | +0.968 | 437.2 | 0 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +0.994 | +1.391 | 437.2 | 0 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +3.000 | +3.533 | 437.2 | 1 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +2.866 | +3.439 | 437.2 | 0 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +2.565 | +3.090 | 437.2 | 0 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +2.142 | +2.539 | 437.2 | 0 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +1.662 | +1.871 | 437.2 | 0.1 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +3.533 | +4.066 | 437.2 | 1 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +3.628 | +4.200 | 437.2 | 0 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +3.977 | +4.502 | 437.2 | 0 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +4.527 | +4.924 | 437.2 | 0 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +6.533 | +7.066 | 437.2 | 1 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +6.399 | +6.972 | 437.2 | 0 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +6.098 | +6.623 | 437.2 | 0 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +5.675 | +6.072 | 437.2 | 0 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +5.195 | +5.404 | 437.2 | 0.1 | 9 | 4746.7 | M4 | 4746.7 | 8.83454 | 0.0552969 | 434.08
Beam | +6.533 | +7.066 | 457.7 | 1 | 9.4 | 4969.8 | M3 | 4969.8 | 9.24977 | 0.0578959 | 454.483
2 x Beam | -0.000 | +3.533 | 872.8 | 0.6 | 17.9 | 9476.6 | M2 | 9476.55 | 17.6377 | 0.110368 | 866.392
2 x Beam | +3.533 | +7.066 | 872.8 | 0.6 | 17.9 | 9476.6 | M2 | 9476.55 | 17.6377 | 0.110368 | 866.392
2 x Beam | +0.000 | +7.066 | 650.8 | 0 | 13.3 | 7066.2 | A1 | 7066.2 | 13.1516 | 0.082318 | 646.196

# IfcDiscreteAccessory: Beam (12)
In: Undefined
Description: UB406*140*39; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 34.1 m2; Height: 397.3 mm; Width: 141.8 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00496815 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
6 x Beam | +4.289 | +5.169 | 58.9 | 1.9 | 1509.6 | M21 | 2.01033 | 0.00661434 | 0.00749998
6 x Beam | +5.789 | +7.202 | 121 | 4 | 3101.5 | M20 | 4.13027 | 0.014309 | 0.0154089

# IfcDiscreteAccessory: ENDPLATE (40)
In: Undefined
Material: STEEL/350WA
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Width: 10 mm
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
12 x ENDPLATE | FL10*150 | +4.753 | +5.163 | 4.8 | 27.7 | 0.1 | 150 | 409.5 | M9 | 0.134053 | 0.0015 | 0.000614309
12 x ENDPLATE | FL10*150 | +6.787 | +7.196 | 4.8 | 27.7 | 0.1 | 150 | 409.5 | M9 | 0.134053 | 0.0015 | 0.000614309
2 x ENDPLATE | PLT10*160 | +0.010 | +0.523 | 6.3 | 27.6 | 0.2 | 160 | 513.1 | P5 | 0.177654 | 0.0016 | 0.00082096
2 x ENDPLATE | PLT10*160 | +3.010 | +3.523 | 6.3 | 27.6 | 0.2 | 160 | 513.1 | P5 | 0.177654 | 0.0016 | 0.00082096
2 x ENDPLATE | PLT10*160 | +3.543 | +4.056 | 6.3 | 27.6 | 0.2 | 160 | 513.1 | P5 | 0.177654 | 0.0016 | 0.00082096
2 x ENDPLATE | PLT10*160 | +6.543 | +7.056 | 6.3 | 27.6 | 0.2 | 160 | 513.1 | P5 | 0.177654 | 0.0016 | 0.00082096
2 x ENDPLATE | PLT10*170 | +0.010 | +0.523 | 6.8 | 27.5 | 0.2 | 170 | 513.1 | P2 | 0.188116 | 0.0017 | 0.00087227
2 x ENDPLATE | PLT10*170 | +3.010 | +3.523 | 6.8 | 27.5 | 0.2 | 170 | 513.1 | P2 | 0.188116 | 0.0017 | 0.00087227
2 x ENDPLATE | PLT10*170 | +3.543 | +4.056 | 6.8 | 27.5 | 0.2 | 170 | 513.1 | P2 | 0.188116 | 0.0017 | 0.00087227
2 x ENDPLATE | PLT10*170 | +6.543 | +7.056 | 6.8 | 27.5 | 0.2 | 170 | 513.1 | P2 | 0.188116 | 0.0017 | 0.00087227

# IfcDiscreteAccessory: PLATE (610)
In: Undefined
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Material | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
6 x PLATE | PLT10*205.6 | STEEL/350WA | +5.798 | +6.035 | 3.9 | 27.7 | 0.1 | 205.6 | 10 | 273.8 | M14 | 0.108726 | 0.0563048 | 0.0001 | 0.000499633 | 0.000499633
12 x PLATE | PLT10*93.6 | STEEL/350WA | +5.138 | +5.335 | 1.2 | 29.7 | 0 | 93.6 | 10 | 175.6 | M11 | 0.0364492 | 0.0164331 | 0.0001 | 0.000156327 | 0.000156327
12 x PLATE | FL10*70 | STEEL/350WA | +5.103 | +5.173 | 0.9 | 30.7 | 0 | 70 | 10 | 160 | M8 | 0.027 | 0.0112 | 0.0001 | 0.000112 | 0.000112
12 x PLATE | PLT10*245.9 | STEEL/350WA | +3.951 | +4.333 | 6.5 | 27.2 | 0.2 | 245.9 | 10 | 382.5 | M7 | 0.177074 | 0.0940659 | 0.0001 | 0.000828808 | 0.000828808
12 x PLATE | FL10*70 | STEEL/350WA | +3.077 | +3.147 | 0.9 | 30.7 | 0 | 70 | 10 | 160 | M8 | 0.027 | 0.0112 | 0.0001 | 0.000112 | 0.000112
12 x PLATE | PLT10*243.4 | STEEL/350WA | +1.890 | +2.273 | 6.5 | 27.2 | 0.2 | 243.4 | 10 | 383.5 | M6 | 0.175711 | 0.093319 | 0.0001 | 0.000822141 | 0.000822141
12 x PLATE | PLT10*161 | STEEL/350WA | +0.020 | +0.181 | 2.1 | 28.6 | 0.1 | 161 | 10 | 170.1 | M10 | 0.0586428 | 0.0273779 | 0.0001 | 0.000261556 | 0.000261556
12 x PLATE | FL10*70 | STEEL/350WA | +1.016 | +1.086 | 0.9 | 30.7 | 0 | 70 | 10 | 160 | M8 | 0.027 | 0.0112 | 0.0001 | 0.000112 | 0.000112
12 x PLATE | PLT10*225.8 | STEEL/350WA | +4.948 | +5.173 | 3.9 | 27.7 | 0.1 | 225.8 | 10 | 245.9 | M12 | 0.109132 | 0.0555223 | 0.0001 | 0.00050156 | 0.00050156
12 x PLATE | FL10*70 | STEEL/350WA | +4.108 | +4.178 | 0.9 | 30.7 | 0 | 70 | 10 | 160 | M8 | 0.027 | 0.0112 | 0.0001 | 0.000112 | 0.000112
12 x PLATE | PLT10*243.4 | STEEL/350WA | +2.920 | +3.304 | 6.5 | 27.2 | 0.2 | 243.4 | 10 | 383.5 | M6 | 0.175712 | 0.0933194 | 0.0001 | 0.000822145 | 0.000822145
12 x PLATE | FL10*70 | STEEL/350WA | +2.046 | +2.116 | 0.9 | 30.7 | 0 | 70 | 10 | 160 | M8 | 0.027 | 0.0112 | 0.0001 | 0.000112 | 0.000112
12 x PLATE | PLT10*243.4 | STEEL/350WA | +0.859 | +1.242 | 6.5 | 27.2 | 0.2 | 243.4 | 10 | 383.5 | M6 | 0.175695 | 0.0933278 | 0.0001 | 0.000822065 | 0.000822065
6 x PLATE | PLT10*205.6 | STEEL/350WA | +5.798 | +6.035 | 3.9 | 27.7 | 0.1 | 205.6 | 10 | 273.8 | M13 | 0.110527 | 0.0563048 | 0.0001 | 0.000507636 | 0.000507636
36 x PLATE | PLT10*67.6 | Undefined/A36 | +3.107 | +3.117 | 0 |  | 0.1 | 67.6 | 10 | 379.8 | P10 | 0.0597866 | 0.0256555 | 0.0001 | 0.000254942 | 0.000254942
36 x PLATE | PLT10*67.6 | Undefined/A36 | +2.076 | +2.086 | 0 |  | 0.1 | 67.6 | 10 | 379.8 | P10 | 0.0597866 | 0.0256555 | 0.0001 | 0.000254942 | 0.000254942
36 x PLATE | PLT10*67.6 | Undefined/A36 | +1.046 | +1.056 | 0 |  | 0.1 | 67.6 | 10 | 379.8 | P10 | 0.0597866 | 0.0256555 | 0.0001 | 0.000254942 | 0.000254942
12 x PLATE | PLT10*67.6 | Undefined/A36 | +1.033 | +1.043 | 0 |  | 0.1 | 67.6 | 10 | 379.8 | P10 | 0.0597866 | 0.0256555 | 0.0001 | 0.000254942 | 0.000254942
12 x PLATE | PLT10*67.6 | Undefined/A36 | +2.064 | +2.074 | 0 |  | 0.1 | 67.6 | 10 | 379.8 | P10 | 0.0597866 | 0.0256555 | 0.0001 | 0.000254942 | 0.000254942
12 x PLATE | PLT10*67.6 | Undefined/A36 | +3.094 | +3.104 | 0 |  | 0.1 | 67.6 | 10 | 379.8 | P10 | 0.0597866 | 0.0256555 | 0.0001 | 0.000254942 | 0.000254942
12 x PLATE | PLT10*67.6 | Undefined/A36 | +4.125 | +4.135 | 0 |  | 0.1 | 67.6 | 10 | 379.8 | P10 | 0.0597866 | 0.0256555 | 0.0001 | 0.000254942 | 0.000254942
36 x PLATE | PLT10*67.6 | Undefined/A36 | +4.138 | +4.148 | 0 |  | 0.1 | 67.6 | 10 | 379.8 | P10 | 0.0597866 | 0.0256555 | 0.0001 | 0.000254942 | 0.000254942
24 x PLATE | PLT10*67.6 | Undefined/A36 | +5.136 | +5.146 | 0 |  | 0.1 | 67.6 | 10 | 379.8 | P10 | 0.0597866 | 0.0256555 | 0.0001 | 0.000254942 | 0.000254942
24 x PLATE | PLT10*67.6 | Undefined/A36 | +5.133 | +5.143 | 0 |  | 0.1 | 67.6 | 10 | 379.8 | P10 | 0.0597866 | 0.0256555 | 0.0001 | 0.000254942 | 0.000254942
24 x PLATE | PLT10*67.6 | Undefined/A36 | +4.572 | +4.933 | 0 |  | 0.1 | 67.6 | 10 | 379.8 | P10 | 0.0597866 | 0.0256555 | 0.0001 | 0.000254942 | 0.000254942
6 x PLATE | PLT10*63.8 | Undefined/A36 | +5.128 | +5.164 | 0 |  | 0 | 63.8 | 10 | 63.8 | P11 | 0.0102215 | 0.00407044 | 0.0001 | 0.0000390915 | 0.0000390915
24 x PLATE | PLT10*67.6 | Undefined/A36 | +6.007 | +6.368 | 0 |  | 0.1 | 67.6 | 10 | 379.8 | P10 | 0.0597866 | 0.0256555 | 0.0001 | 0.000254942 | 0.000254942
6 x PLATE | PLT10*231.5 | STEEL/350WA | +4.711 | +4.934 | 4.4 | 27.6 | 0.1 | 231.5 | 10 | 327.9 | M5 | 0.121382 | 0.0758899 | 0.0001 | 0.000561076 | 0.00069806
2 x PLATE | PLT5*63.5 | STEEL/350WA | +6.303 | +6.426 | 0.3 | 57.6 | 0 | 63.5 | 5 | 135 | P15 | 0.0146983 | 0.00857318 | 0.000025 | 0.0000325128 | 0.0000718258
2 x PLATE | FL10*130 | STEEL/350WA | +6.261 | +6.495 | 3 | 28.2 | 0.1 | 130 | 10 | 305 | P8 | 0.0843314 | 0.03965 | 0.0001 | 0.0003805 | 0.0003805
2 x PLATE | PLT10*225.4 | STEEL/350WA | +6.308 | +6.533 | 4.1 | 27.9 | 0.1 | 225.4 | 10 | 352.2 | P7 | 0.115328 | 0.0793884 | 0.0001 | 0.000527226 | 0.000527226
2 x PLATE | PLT5*63.5 | STEEL/350WA | +6.303 | +6.426 | 0.3 | 57.6 | 0 | 63.5 | 5 | 135 | P15 | 0.0146983 | 0.00857319 | 0.000025 | 0.0000325128 | 0.0000718258
2 x PLATE | PLT5*63.5 | STEEL/350WA | +4.173 | +4.296 | 0.3 | 57.6 | 0 | 63.5 | 5 | 135 | P15 | 0.0146983 | 0.00857318 | 0.000025 | 0.0000325128 | 0.0000718258
2 x PLATE | FL10*130 | STEEL/350WA | +4.104 | +4.338 | 3 | 28.2 | 0.1 | 130 | 10 | 305 | P8 | 0.0843314 | 0.03965 | 0.0001 | 0.0003805 | 0.0003805
2 x PLATE | PLT10*225.4 | STEEL/350WA | +4.066 | +4.292 | 4.1 | 27.9 | 0.1 | 225.4 | 10 | 352.2 | P7 | 0.115328 | 0.0793884 | 0.0001 | 0.000527226 | 0.000527226
2 x PLATE | PLT5*63.5 | STEEL/350WA | +5.396 | +5.519 | 0.3 | 57.6 | 0 | 63.5 | 5 | 135 | P15 | 0.0146983 | 0.00857318 | 0.000025 | 0.0000325128 | 0.0000718258
PLATE | FL10*130 | STEEL/350WA | +5.327 | +5.562 | 3 | 28.2 | 0.1 | 130 | 10 | 305 | P8 | 0.0843314 | 0.03965 | 0.0001 | 0.0003805 | 0.0003805
2 x PLATE | PLT5*63.5 | STEEL/350WA | +5.080 | +5.203 | 0.3 | 57.6 | 0 | 63.5 | 5 | 135 | P15 | 0.0146983 | 0.00857319 | 0.000025 | 0.0000325128 | 0.0000718258
PLATE | FL10*130 | STEEL/350WA | +5.038 | +5.272 | 3 | 28.2 | 0.1 | 130 | 10 | 305 | P8 | 0.0843314 | 0.03965 | 0.0001 | 0.0003805 | 0.0003805
PLATE | PLT10*380.6 | STEEL/350WA | +5.084 | +5.515 | 16.8 | 26.6 | 0.3 | 380.6 | 10 | 675.5 | P6 | 0.44586 | 0.25714 | 0.0001 | 0.00213872 | 0.00213872
2 x PLATE | PLT5*63.5 | STEEL/350WA | +4.173 | +4.296 | 0.3 | 57.6 | 0 | 63.5 | 5 | 135 | P15 | 0.0146983 | 0.00857319 | 0.000025 | 0.0000325128 | 0.0000718258
2 x PLATE | PLT5*63.5 | STEEL/350WA | +0.640 | +0.763 | 0.3 | 57.6 | 0 | 63.5 | 5 | 135 | P15 | 0.0146983 | 0.00857319 | 0.000025 | 0.0000325128 | 0.0000718258
2 x PLATE | FL10*130 | STEEL/350WA | +0.571 | +0.805 | 3 | 28.2 | 0.1 | 130 | 10 | 305 | P8 | 0.0843314 | 0.03965 | 0.0001 | 0.0003805 | 0.0003805
2 x PLATE | PLT10*225.4 | STEEL/350WA | +0.533 | +0.759 | 4.1 | 27.9 | 0.1 | 225.4 | 10 | 352.2 | P7 | 0.115328 | 0.0793884 | 0.0001 | 0.000527226 | 0.000527226
2 x PLATE | PLT5*63.5 | STEEL/350WA | +2.770 | +2.893 | 0.3 | 57.6 | 0 | 63.5 | 5 | 135 | P15 | 0.0146983 | 0.00857318 | 0.000025 | 0.0000325128 | 0.0000718258
2 x PLATE | FL10*130 | STEEL/350WA | +2.728 | +2.962 | 3 | 28.2 | 0.1 | 130 | 10 | 305 | P8 | 0.0843314 | 0.03965 | 0.0001 | 0.0003805 | 0.0003805
2 x PLATE | PLT10*225.4 | STEEL/350WA | +2.775 | +3.000 | 4.1 | 27.9 | 0.1 | 225.4 | 10 | 352.2 | P7 | 0.115328 | 0.0793884 | 0.0001 | 0.000527226 | 0.000527226
2 x PLATE | PLT5*63.5 | STEEL/350WA | +2.770 | +2.893 | 0.3 | 57.6 | 0 | 63.5 | 5 | 135 | P15 | 0.0146983 | 0.00857319 | 0.000025 | 0.0000325128 | 0.0000718258
2 x PLATE | PLT5*63.5 | STEEL/350WA | +1.863 | +1.986 | 0.3 | 57.6 | 0 | 63.5 | 5 | 135 | P15 | 0.0146983 | 0.00857318 | 0.000025 | 0.0000325128 | 0.0000718258
PLATE | FL10*130 | STEEL/350WA | +1.794 | +2.028 | 3 | 28.2 | 0.1 | 130 | 10 | 305 | P8 | 0.0843314 | 0.03965 | 0.0001 | 0.0003805 | 0.0003805
2 x PLATE | PLT5*63.5 | STEEL/350WA | +1.547 | +1.670 | 0.3 | 57.6 | 0 | 63.5 | 5 | 135 | P15 | 0.0146983 | 0.00857319 | 0.000025 | 0.0000325128 | 0.0000718258
PLATE | FL10*130 | STEEL/350WA | +1.505 | +1.739 | 3 | 28.2 | 0.1 | 130 | 10 | 305 | P8 | 0.0843314 | 0.03965 | 0.0001 | 0.0003805 | 0.0003805
PLATE | PLT10*380.6 | STEEL/350WA | +1.551 | +1.982 | 16.8 | 26.6 | 0.3 | 380.6 | 10 | 675.5 | P6 | 0.44586 | 0.25714 | 0.0001 | 0.00213872 | 0.00213872
2 x PLATE | PLT5*63.5 | STEEL/350WA | +0.640 | +0.763 | 0.3 | 57.6 | 0 | 63.5 | 5 | 135 | P15 | 0.0146983 | 0.00857318 | 0.000025 | 0.0000325128 | 0.0000718258
2 x PLATE | PLT10*160 | STEEL/350WA | +0.010 | +0.523 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +0.016 | +0.518 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +0.005 | +0.528 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +0.113 | +0.648 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +0.146 | +0.616 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +0.109 | +0.653 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +0.468 | +0.944 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +0.523 | +0.889 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +0.464 | +0.947 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +1.020 | +1.365 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +1.089 | +1.296 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +1.019 | +1.367 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +3.010 | +3.523 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +3.016 | +3.517 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +3.005 | +3.528 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +2.885 | +3.420 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +2.917 | +3.387 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +2.880 | +3.425 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +2.589 | +3.065 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +2.644 | +3.010 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +2.586 | +3.069 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +2.168 | +2.513 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +2.237 | +2.444 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +2.167 | +2.515 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +1.687 | +1.847 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +1.759 | +1.775 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +1.687 | +1.847 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +3.543 | +4.056 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +3.549 | +4.051 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +3.538 | +4.061 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +3.646 | +4.182 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +3.679 | +4.149 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +3.642 | +4.186 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +4.001 | +4.477 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +4.056 | +4.422 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +3.998 | +4.481 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +4.554 | +4.898 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +4.622 | +4.829 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +4.552 | +4.900 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +6.543 | +7.056 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +6.549 | +7.051 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +6.538 | +7.061 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +6.418 | +6.953 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +6.450 | +6.920 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +6.413 | +6.958 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +6.122 | +6.598 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +6.177 | +6.543 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +6.119 | +6.602 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +5.702 | +6.046 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +5.770 | +5.977 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +5.700 | +6.048 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696
2 x PLATE | PLT10*160 | STEEL/350WA | +5.220 | +5.380 | 6.3 | 27.6 | 0.2 | 160 | 10 | 513.1 | P4 | 0.177654 | 0.177654 | 0.0016 | 0.00082096 | 0.00082096
2 x PLATE | FL16*90 | STEEL/350WA | +5.292 | +5.308 | 5.6 | 19.2 | 0.1 | 90 | 16 | 501.9 | P14 | 0.108552 | 0.045171 | 0.000256 | 0.000719136 | 0.000719136
2 x PLATE | PLT10*160 | STEEL/350WA | +5.220 | +5.380 | 6.6 | 27.6 | 0.2 | 160 | 10 | 523.1 | P3 | 0.181054 | 0.181054 | 0.0016 | 0.00083696 | 0.00083696

# IfcDiscreteAccessory: Plate (26)
In: Undefined
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.1 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Material | Bottom elevation | Top elevation | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
12 x Plate | PLT10*141.8 | STEEL/S355JR | +7.196 | +7.206 | 1 | 4.4 | 27.9 | 0.1 | 141.8 | 10 | 397.2 | P9 | 0.123426 | 0.056323 | 0.0001 | 0.00056323
12 x Plate | PLT10*141.8 | STEEL/S355JR | +5.173 | +5.183 | 1 | 4.4 | 27.9 | 0.1 | 141.8 | 10 | 397.2 | P9 | 0.123426 | 0.056323 | 0.0001 | 0.00056323
Plate | PLT8*366.2 | STEEL/350WA | +0.263 | +0.271 | 99 | 9.3 | 33.1 | 0.3 | 366.2 | 8 | 419.3 | P12 | 0.309163 | 0.153535 | 0.000064 | 0.00118843
Plate | PLT8*366.2 | STEEL/350WA | +3.263 | +3.271 | 99 | 9.3 | 33.1 | 0.3 | 366.2 | 8 | 419.3 | P12 | 0.309163 | 0.153535 | 0.000064 | 0.00118843

# IfcDiscreteAccessory: Unnamed (24)
In: Undefined
Description: FL20*300; Material: STEEL/350WA
Tekla Common - Bottom elevation: +0.000; Top elevation: +0.020; Phase: 1; Class: 99
Tekla Quantity - Weight: 23.6 kg; Volume: 0 m3; Gross footprint area: 0.2 m2; Area per tons: 14.1 m2; Net surface area: 0.3 m2; Height: 300 mm; Width: 20 mm; Length: 500 mm
Pset_PlateCommon - LoadBearing: yes; Reference: P17
BaseQuantities - NetArea: 0.332 m2; GrossArea: 0.332 m2; CrossSectionArea: 0.006 m2; NetVolume: 0.003 m3; GrossVolume: 0.003 m3

# IfcElementAssembly (226)
In: Undefined
PredefinedType: RIGID_FRAME
Name | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Steel Assembly | 6.3 | +5.173 | +5.972 | B-C/6 | A24 | 70
Steel Assembly | 8.1 | +4.777 | +5.954 | B-C/6 | A23 | 70
Steel Assembly | 259.5 | +5.789 | +7.202 | A-C/6 | A9 | 150
Steel Assembly | 6.2 | +5.173 | +5.962 | B-C/6 | A21 | 70
Steel Assembly | 134.3 | +4.289 | +5.335 | B-C/6 | A8 | 150
Steel Assembly | 6.2 | +5.103 | +5.173 | C-D/6 | A17 | 70
Steel Assembly | 246.6 | +0.000 | +5.183 | C/6 | A10 | 300
Steel Assembly | 8.3 | +3.157 | +4.098 | C-D/6 | A19 | 70
Steel Assembly | 6.2 | +4.108 | +4.178 | C-D/6 | A17 | 70
Steel Assembly | 8.1 | +4.188 | +5.093 | C-D/6 | A18 | 70
Steel Assembly | 6.2 | +3.077 | +3.147 | C-D/6 | A16 | 70
Steel Assembly | 8.3 | +1.096 | +2.036 | C-D/6 | A19 | 70
Steel Assembly | 6.2 | +2.046 | +2.116 | C-D/6 | A16 | 70
Steel Assembly | 8.3 | +2.126 | +3.067 | C-D/6 | A19 | 70
Steel Assembly | 8.6 | +0.034 | +1.006 | C-D/6 | A20 | 70
Steel Assembly | 6.2 | +1.016 | +1.086 | C-D/6 | A16 | 70
Steel Assembly | 6.2 | +5.103 | +5.173 | A-B/6 | A17 | 70
Steel Assembly | 246.6 | +0.000 | +5.183 | B/6 | A10 | 300
Steel Assembly | 8.6 | +0.034 | +1.006 | A-B/6 | A20 | 70
Steel Assembly | 6.2 | +1.016 | +1.086 | A-B/6 | A16 | 70
Steel Assembly | 8.3 | +2.126 | +3.067 | A-B/6 | A19 | 70
Steel Assembly | 6.2 | +2.046 | +2.116 | A-B/6 | A16 | 70
Steel Assembly | 8.3 | +1.096 | +2.036 | A-B/6 | A19 | 70
Steel Assembly | 8.1 | +4.188 | +5.093 | A-B/6 | A18 | 70
Steel Assembly | 6.2 | +4.108 | +4.178 | A-B/6 | A17 | 70
Steel Assembly | 8.3 | +3.157 | +4.098 | A-B/6 | A19 | 70
Steel Assembly | 6.2 | +3.077 | +3.147 | A-B/6 | A16 | 70
Steel Assembly | 326.4 | +0.000 | +7.206 | D/6 | A12 | 300
Steel Assembly | 8.1 | +4.777 | +5.954 | B-C/6 | A22 | 70
Steel Assembly | 326.4 | +0.000 | +7.206 | A/6 | A11 | 300
Steel Assembly | 6.3 | +5.173 | +5.972 | B-C/5 | A24 | 70
Steel Assembly | 8.1 | +4.777 | +5.954 | B-C/5 | A23 | 70
Steel Assembly | 259.5 | +5.789 | +7.202 | A-C/5 | A9 | 150
Steel Assembly | 6.2 | +5.173 | +5.962 | B-C/5 | A21 | 70
Steel Assembly | 134.3 | +4.289 | +5.335 | B-C/5 | A8 | 150
Steel Assembly | 6.2 | +5.103 | +5.173 | C-D/5 | A17 | 70
Steel Assembly | 246.6 | +0.000 | +5.183 | C/5 | A10 | 300
Steel Assembly | 8.3 | +3.157 | +4.098 | C-D/5 | A19 | 70
Steel Assembly | 6.2 | +4.108 | +4.178 | C-D/5 | A17 | 70
Steel Assembly | 8.1 | +4.188 | +5.093 | C-D/5 | A18 | 70
Steel Assembly | 6.2 | +3.077 | +3.147 | C-D/5 | A16 | 70
Steel Assembly | 8.3 | +1.096 | +2.036 | C-D/5 | A19 | 70
Steel Assembly | 6.2 | +2.046 | +2.116 | C-D/5 | A16 | 70
Steel Assembly | 8.3 | +2.126 | +3.067 | C-D/5 | A19 | 70
Steel Assembly | 8.6 | +0.034 | +1.006 | C-D/5 | A20 | 70
Steel Assembly | 6.2 | +1.016 | +1.086 | C-D/5 | A16 | 70
Steel Assembly | 6.2 | +5.103 | +5.173 | A-B/5 | A17 | 70
Steel Assembly | 246.6 | +0.000 | +5.183 | B/5 | A10 | 300
Steel Assembly | 8.6 | +0.034 | +1.006 | A-B/5 | A20 | 70
Steel Assembly | 6.2 | +1.016 | +1.086 | A-B/5 | A16 | 70
Steel Assembly | 8.3 | +2.126 | +3.067 | A-B/5 | A19 | 70
Steel Assembly | 6.2 | +2.046 | +2.116 | A-B/5 | A16 | 70
Steel Assembly | 8.3 | +1.096 | +2.036 | A-B/5 | A19 | 70
Steel Assembly | 8.1 | +4.188 | +5.093 | A-B/5 | A18 | 70
Steel Assembly | 6.2 | +4.108 | +4.178 | A-B/5 | A17 | 70
Steel Assembly | 8.3 | +3.157 | +4.098 | A-B/5 | A19 | 70
Steel Assembly | 6.2 | +3.077 | +3.147 | A-B/5 | A16 | 70
Steel Assembly | 326.4 | +0.000 | +7.206 | D/5 | A12 | 300
Steel Assembly | 8.1 | +4.777 | +5.954 | B-C/5 | A22 | 70
Steel Assembly | 326.4 | +0.000 | +7.206 | A/5 | A11 | 300
Steel Assembly | 6.3 | +5.173 | +5.972 | B-C/4 | A24 | 70
Steel Assembly | 8.1 | +4.777 | +5.954 | B-C/4 | A23 | 70
Steel Assembly | 259.5 | +5.789 | +7.202 | A-C/4 | A9 | 150
Steel Assembly | 6.2 | +5.173 | +5.962 | B-C/4 | A21 | 70
Steel Assembly | 134.3 | +4.289 | +5.335 | B-C/4 | A8 | 150
Steel Assembly | 6.2 | +5.103 | +5.173 | C-D/4 | A17 | 70
Steel Assembly | 246.6 | +0.000 | +5.183 | C/4 | A10 | 300
Steel Assembly | 8.3 | +3.157 | +4.098 | C-D/4 | A19 | 70
Steel Assembly | 6.2 | +4.108 | +4.178 | C-D/4 | A17 | 70
Steel Assembly | 8.1 | +4.188 | +5.093 | C-D/4 | A18 | 70
Steel Assembly | 6.2 | +3.077 | +3.147 | C-D/4 | A16 | 70
Steel Assembly | 8.3 | +1.096 | +2.036 | C-D/4 | A19 | 70
Steel Assembly | 6.2 | +2.046 | +2.116 | C-D/4 | A16 | 70
Steel Assembly | 8.3 | +2.126 | +3.067 | C-D/4 | A19 | 70
Steel Assembly | 8.6 | +0.034 | +1.006 | C-D/4 | A20 | 70
Steel Assembly | 6.2 | +1.016 | +1.086 | C-D/4 | A16 | 70
Steel Assembly | 6.2 | +5.103 | +5.173 | A-B/4 | A17 | 70
Steel Assembly | 246.6 | +0.000 | +5.183 | B/4 | A10 | 300
Steel Assembly | 8.6 | +0.034 | +1.006 | A-B/4 | A20 | 70
Steel Assembly | 6.2 | +1.016 | +1.086 | A-B/4 | A16 | 70
Steel Assembly | 8.3 | +2.126 | +3.067 | A-B/4 | A19 | 70
Steel Assembly | 6.2 | +2.046 | +2.116 | A-B/4 | A16 | 70
Steel Assembly | 8.3 | +1.096 | +2.036 | A-B/4 | A19 | 70
Steel Assembly | 8.1 | +4.188 | +5.093 | A-B/4 | A18 | 70
Steel Assembly | 6.2 | +4.108 | +4.178 | A-B/4 | A17 | 70
Steel Assembly | 8.3 | +3.157 | +4.098 | A-B/4 | A19 | 70
Steel Assembly | 6.2 | +3.077 | +3.147 | A-B/4 | A16 | 70
Steel Assembly | 326.4 | +0.000 | +7.206 | D/4 | A12 | 300
Steel Assembly | 8.1 | +4.777 | +5.954 | B-C/4 | A22 | 70
Steel Assembly | 326.4 | +0.000 | +7.206 | A/4 | A11 | 300
Steel Assembly | 6.3 | +5.173 | +5.972 | B-C/3 | A24 | 70
Steel Assembly | 8.1 | +4.777 | +5.954 | B-C/3 | A23 | 70
Steel Assembly | 259.5 | +5.789 | +7.202 | A-C/3 | A9 | 150
Steel Assembly | 6.2 | +5.173 | +5.962 | B-C/3 | A21 | 70
Steel Assembly | 134.3 | +4.289 | +5.335 | B-C/3 | A8 | 150
Steel Assembly | 6.2 | +5.103 | +5.173 | C-D/3 | A17 | 70
Steel Assembly | 246.6 | +0.000 | +5.183 | C/3 | A10 | 300
Steel Assembly | 8.3 | +3.157 | +4.098 | C-D/3 | A19 | 70
Steel Assembly | 6.2 | +4.108 | +4.178 | C-D/3 | A17 | 70
Steel Assembly | 8.1 | +4.188 | +5.093 | C-D/3 | A18 | 70
Steel Assembly | 6.2 | +3.077 | +3.147 | C-D/3 | A16 | 70
Steel Assembly | 8.3 | +1.096 | +2.036 | C-D/3 | A19 | 70
Steel Assembly | 6.2 | +2.046 | +2.116 | C-D/3 | A16 | 70
Steel Assembly | 8.3 | +2.126 | +3.067 | C-D/3 | A19 | 70
Steel Assembly | 8.6 | +0.034 | +1.006 | C-D/3 | A20 | 70
Steel Assembly | 6.2 | +1.016 | +1.086 | C-D/3 | A16 | 70
Steel Assembly | 6.2 | +5.103 | +5.173 | A-B/3 | A17 | 70
Steel Assembly | 246.6 | +0.000 | +5.183 | B/3 | A10 | 300
Steel Assembly | 8.6 | +0.034 | +1.006 | A-B/3 | A20 | 70
Steel Assembly | 6.2 | +1.016 | +1.086 | A-B/3 | A16 | 70
Steel Assembly | 8.3 | +2.126 | +3.067 | A-B/3 | A19 | 70
Steel Assembly | 6.2 | +2.046 | +2.116 | A-B/3 | A16 | 70
Steel Assembly | 8.3 | +1.096 | +2.036 | A-B/3 | A19 | 70
Steel Assembly | 8.1 | +4.188 | +5.093 | A-B/3 | A18 | 70
Steel Assembly | 6.2 | +4.108 | +4.178 | A-B/3 | A17 | 70
Steel Assembly | 8.3 | +3.157 | +4.098 | A-B/3 | A19 | 70
Steel Assembly | 6.2 | +3.077 | +3.147 | A-B/3 | A16 | 70
Steel Assembly | 326.4 | +0.000 | +7.206 | D/3 | A12 | 300
Steel Assembly | 8.1 | +4.777 | +5.954 | B-C/3 | A22 | 70
Steel Assembly | 326.4 | +0.000 | +7.206 | A/3 | A11 | 300
Steel Assembly | 6.3 | +5.173 | +5.972 | B-C/2 | A24 | 70
Steel Assembly | 8.1 | +4.777 | +5.954 | B-C/2 | A23 | 70
Steel Assembly | 259.5 | +5.789 | +7.202 | A-C/2 | A9 | 150
Steel Assembly | 6.2 | +5.173 | +5.962 | B-C/2 | A21 | 70
Steel Assembly | 134.3 | +4.289 | +5.335 | B-C/2 | A8 | 150
Steel Assembly | 6.2 | +5.103 | +5.173 | C-D/2 | A17 | 70
Steel Assembly | 246.6 | +0.000 | +5.183 | C/2 | A10 | 300
Steel Assembly | 8.3 | +3.157 | +4.098 | C-D/2 | A19 | 70
Steel Assembly | 6.2 | +4.108 | +4.178 | C-D/2 | A17 | 70
Steel Assembly | 8.1 | +4.188 | +5.093 | C-D/2 | A18 | 70
Steel Assembly | 6.2 | +3.077 | +3.147 | C-D/2 | A16 | 70
Steel Assembly | 8.3 | +1.096 | +2.036 | C-D/2 | A19 | 70
Steel Assembly | 6.2 | +2.046 | +2.116 | C-D/2 | A16 | 70
Steel Assembly | 8.3 | +2.126 | +3.067 | C-D/2 | A19 | 70
Steel Assembly | 8.6 | +0.034 | +1.006 | C-D/2 | A20 | 70
Steel Assembly | 6.2 | +1.016 | +1.086 | C-D/2 | A16 | 70
Steel Assembly | 6.2 | +5.103 | +5.173 | A-B/2 | A17 | 70
Steel Assembly | 246.6 | +0.000 | +5.183 | B/2 | A10 | 300
Steel Assembly | 8.6 | +0.034 | +1.006 | A-B/2 | A20 | 70
Steel Assembly | 6.2 | +1.016 | +1.086 | A-B/2 | A16 | 70
Steel Assembly | 8.3 | +2.126 | +3.067 | A-B/2 | A19 | 70
Steel Assembly | 6.2 | +2.046 | +2.116 | A-B/2 | A16 | 70
Steel Assembly | 8.3 | +1.096 | +2.036 | A-B/2 | A19 | 70
Steel Assembly | 8.1 | +4.188 | +5.093 | A-B/2 | A18 | 70
Steel Assembly | 6.2 | +4.108 | +4.178 | A-B/2 | A17 | 70
Steel Assembly | 8.3 | +3.157 | +4.098 | A-B/2 | A19 | 70
Steel Assembly | 6.2 | +3.077 | +3.147 | A-B/2 | A16 | 70
Steel Assembly | 326.4 | +0.000 | +7.206 | D/2 | A12 | 300
Steel Assembly | 8.1 | +4.777 | +5.954 | B-C/2 | A22 | 70
Steel Assembly | 326.4 | +0.000 | +7.206 | A/2 | A11 | 300
Steel Assembly | 326.4 | +0.000 | +7.206 | D/1 | A12 | 300
Steel Assembly | 326.4 | +0.000 | +7.206 | A/1 | A11 | 300
Steel Assembly | 246.6 | +0.000 | +5.183 | C/1 | A10 | 300
Steel Assembly | 134.3 | +4.289 | +5.335 | B-C/1 | A8 | 150
Steel Assembly | 8.1 | +4.777 | +5.954 | B-C/1 | A23 | 70
Steel Assembly | 259.5 | +5.789 | +7.202 | A-C/1 | A9 | 150
Steel Assembly | 246.6 | +0.000 | +5.183 | B/1 | A10 | 300
Steel Assembly | 6.2 | +1.016 | +1.086 | C-D/1 | A16 | 70
Steel Assembly | 8.6 | +0.034 | +1.006 | C-D/1 | A20 | 70
Steel Assembly | 8.3 | +1.096 | +2.036 | C-D/1 | A19 | 70
Steel Assembly | 6.2 | +2.046 | +2.116 | C-D/1 | A16 | 70
Steel Assembly | 8.3 | +2.126 | +3.067 | C-D/1 | A19 | 70
Steel Assembly | 6.2 | +3.077 | +3.147 | C-D/1 | A16 | 70
Steel Assembly | 8.3 | +3.157 | +4.098 | C-D/1 | A19 | 70
Steel Assembly | 6.2 | +4.108 | +4.178 | C-D/1 | A17 | 70
Steel Assembly | 8.1 | +4.188 | +5.093 | C-D/1 | A18 | 70
Steel Assembly | 6.2 | +5.103 | +5.173 | C-D/1 | A17 | 70
Steel Assembly | 6.3 | +5.173 | +5.972 | B-C/1 | A24 | 70
Steel Assembly | 8.1 | +4.777 | +5.954 | B-C/1 | A22 | 70
Steel Assembly | 6.2 | +5.173 | +5.962 | B-C/1 | A21 | 70
Steel Assembly | 6.2 | +5.103 | +5.173 | A-B/1 | A17 | 70
Steel Assembly | 8.1 | +4.188 | +5.093 | A-B/1 | A18 | 70
Steel Assembly | 6.2 | +4.108 | +4.178 | A-B/1 | A17 | 70
Steel Assembly | 6.2 | +3.077 | +3.147 | A-B/1 | A16 | 70
Steel Assembly | 8.3 | +3.157 | +4.098 | A-B/1 | A19 | 70
Steel Assembly | 8.3 | +2.126 | +3.067 | A-B/1 | A19 | 70
Steel Assembly | 6.2 | +2.046 | +2.116 | A-B/1 | A16 | 70
Steel Assembly | 8.3 | +1.096 | +2.036 | A-B/1 | A19 | 70
Steel Assembly | 6.2 | +1.016 | +1.086 | A-B/1 | A16 | 70
Steel Assembly | 8.6 | +0.034 | +1.006 | A-B/1 | A20 | 70
Steel Assembly | 1655.7 | -0.000 | +7.066 | <A/4 | PA3 | 20
Steel Assembly | 1655.7 | -0.000 | +7.066 | <A/6 | PA3 | 20
Steel Assembly | 15652 | +1.000 | +7.086 | <A/1-6 | A15 | 6086.2
Steel Assembly | 15652 | -0.020 | +6.066 | <A/1-6 | A15 | 6086.2
Steel Assembly | 1655.7 | -0.000 | +7.066 | <A/1 | PA3 | 20
Steel Assembly | 87.2 | +4.104 | +6.495 | <A/1-6 | A13 | 137
Steel Assembly | 34.1 | +5.327 | +6.495 | <A/1-3 | A14 | 137
Steel Assembly | 478.9 | +6.308 | +7.066 | <A/1-6 | A5 | 209.3
Steel Assembly | 34.1 | +4.104 | +5.272 | <A/4-6 | A14 | 137
Steel Assembly | 478.9 | +3.533 | +4.292 | <A/1-6 | A6 | 209.3
Steel Assembly | 87.2 | +0.571 | +2.962 | <A/1-6 | A13 | 137
Steel Assembly | 478.9 | -0.000 | +0.759 | <A/1-6 | A6 | 209.3
Steel Assembly | 34.1 | +1.794 | +2.962 | <A/1-3 | A14 | 137
Steel Assembly | 478.9 | +2.775 | +3.533 | <A/1-6 | A5 | 209.3
Steel Assembly | 34.1 | +0.571 | +1.739 | <A/4-6 | A14 | 137
Steel Assembly | 681.2 | -0.000 | +0.008 | <A/1-6 | PA2 | 8
Steel Assembly | 681.2 | +0.517 | +0.525 | <A/1-6 | PA2 | 8
Steel Assembly | 681.2 | +7.058 | +7.066 | <A/1-6 | PA2 | 8
Steel Assembly | 450.1 | +0.000 | +0.533 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +0.095 | +0.667 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +0.443 | +0.968 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +0.994 | +1.391 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +3.000 | +3.533 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +2.866 | +3.439 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +2.565 | +3.090 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +2.142 | +2.539 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +1.662 | +1.871 | <A/1-6 | A7 | 209.3
Steel Assembly | 1015.1 | -0.000 | +3.533 | <A/1 | A2 | 529.026
Steel Assembly | 996.4 | -0.000 | +3.533 | <A/6 | A3 | 219.3
Steel Assembly | 450.1 | +3.533 | +4.066 | <A/1-6 | A7 | 209.3
Steel Assembly | 996.4 | +3.533 | +7.066 | <A/1 | A4 | 219.3
Steel Assembly | 996.4 | +3.533 | +7.066 | <A/6 | A3 | 219.3
Steel Assembly | 450.1 | +3.628 | +4.200 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +3.977 | +4.502 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +4.527 | +4.924 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +6.533 | +7.066 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +6.399 | +6.972 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +6.098 | +6.623 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +5.675 | +6.072 | <A/1-6 | A7 | 209.3
Steel Assembly | 450.1 | +5.195 | +5.404 | <A/1-6 | A7 | 209.3
Steel Assembly | 10.5 | -0.012 | -0.000 | <A/6 | PA1 | 12
Steel Assembly | 10.5 | +7.066 | +7.078 | <A/6 | PA1 | 12
Steel Assembly | 650.8 | +0.000 | +7.066 | <A/6 | A1 | 209.3
Steel Assembly | 10.5 | -0.012 | -0.000 | <A/1 | PA1 | 12
Steel Assembly | 10.5 | +7.066 | +7.078 | <A/1 | PA1 | 12
Steel Assembly | 650.8 | +0.000 | +7.066 | <A/1 | A1 | 209.3

# IfcMechanicalFastener: Bolt assembly (400)
In: Undefined
NominalDiameter: 20 mm
Tekla Bolt - Washer diameter: 20 mm; Slotted hole y: 0 mm; Slotted hole x: 0 mm; Location: Site; Bolt size: 20 mm
Name | NominalLength (mm) = Bolt length (mm) | Material | Washer count = Nut count | Washer type | Washer name | Nut type | Nut name | Bolt hole diameter (mm) | Bolt count | Bolt standard | Bolt Name
288 x Bolt assembly | 45 | 8.8XOX | 2 | FLAT-E | WASHERM20-FLAT-E | GR8-HEX | NUTM20-GR8-HEX | 22 | 2 | 8.8XOX | BOLTM20*45
24 x Bolt assembly | 50 | 8.8XOX | 6 | FLAT-E | WASHERM20-FLAT-E | GR8-HEX | NUTM20-GR8-HEX | 22 | 6 | 8.8XOX | BOLTM20*50
24 x Bolt assembly | 20 | 8.8 | 0 | DIN126 | Plain washer M20-126 | ISO4032 | Nut M20-4032 | 24 | 4 | ISO 4017 | Bolt M20x40
12 x Bolt assembly | 50 | 8.8 | 2 | DIN126 | Plain washer M20-126 | ISO4032 | Nut M20-4032 | 22 | 2 | ISO 4017 | Bolt M20x50
8 x Bolt assembly | 50 | 8.8XOX | 10 | FLAT-E | WASHERM20-FLAT-E | GR8-HEX | NUTM20-GR8-HEX | 22 | 10 | 8.8XOX | BOLTM20*50
36 x Bolt assembly | 55 | 8.8XOX | 6 | FLAT-E | WASHERM20-FLAT-E | GR8-HEX | NUTM20-GR8-HEX | 22 | 6 | 8.8XOX | BOLTM20*55
8 x Bolt assembly | 55 | 8.8XOX | 8 | FLAT-E | WASHERM20-FLAT-E | GR8-HEX | NUTM20-GR8-HEX | 22 | 8 | 8.8XOX | BOLTM20*55

# IfcMember: CHS127*4.5 (6)
In: Undefined
Description: CHS127*4.5; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 127 mm; Width: 127 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00170346 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
Beam | +5.403 | +6.420 | 27.1 | 29.7 | 0.8 | 2035.1 | M16 | 2035.08 | 0.808058 | 0.810391 | 0.00344867 | 0.00346667 | 27.072 | 27.2133
Beam | +4.179 | +6.420 | 63.4 | 29.9 | 1.9 | 4786.5 | M15 | 4786.52 | 1.89312 | 1.90366 | 0.00807899 | 0.00815362 | 63.4201 | 64.0059
Beam | +4.179 | +5.197 | 27.1 | 29.7 | 0.8 | 2035.1 | M16 | 2035.08 | 0.808058 | 0.810391 | 0.00344867 | 0.00346667 | 27.072 | 27.2133
Beam | +1.870 | +2.887 | 27.1 | 29.7 | 0.8 | 2035.1 | M16 | 2035.08 | 0.808058 | 0.810391 | 0.00344867 | 0.00346667 | 27.072 | 27.2133
Beam | +0.646 | +2.887 | 63.4 | 29.9 | 1.9 | 4786.5 | M15 | 4786.52 | 1.89312 | 1.90366 | 0.00807899 | 0.00815362 | 63.4201 | 64.0059
Beam | +0.646 | +1.663 | 27.1 | 29.7 | 0.8 | 2035.1 | M16 | 2035.08 | 0.808058 | 0.810391 | 0.00344867 | 0.00346667 | 27.072 | 27.2133

# IfcMember: L70*70*6 (84)
In: Undefined
Description: L70*70*6; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 42.7 m2; Net surface area: 0.3 m2; Height: 70 mm; Width: 70 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.000812739 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
12 x Angle | +0.034 | +1.006 | 8.6 | 1346.9 | A20 | 1346.93 | 0.366735 | 0.00108293 | 0.00109471 | 8.50104 | 8.59344
12 x Angle | +1.096 | +2.036 | 8.3 | 1302.7 | A19 | 1302.74 | 0.354701 | 0.0010474 | 0.00105878 | 8.22208 | 8.31145
12 x Angle | +2.126 | +3.067 | 8.3 | 1302.7 | A19 | 1302.74 | 0.354701 | 0.0010474 | 0.00105878 | 8.22208 | 8.31145
12 x Angle | +3.157 | +4.098 | 8.3 | 1302.7 | A19 | 1302.74 | 0.354701 | 0.0010474 | 0.00105878 | 8.22208 | 8.31145
12 x Angle | +4.188 | +5.093 | 8.1 | 1273.9 | A18 | 1273.93 | 0.346859 | 0.00102424 | 0.00103537 | 8.04029 | 8.12768
6 x Angle | +5.173 | +5.972 | 6.3 | 983.5 | A24 | 983.46 | 0.267771 | 0.000790702 | 0.000799296 | 6.20701 | 6.27448
6 x Angle | +4.777 | +5.954 | 8.1 | 1263.5 | M28 | 1263.48 | 0.344012 | 0.00101584 | 0.00102688 | 7.97431 | 8.06098
6 x Angle | +4.777 | +5.954 | 8.1 | 1263.5 | A22 | 1263.48 | 0.344012 | 0.00101584 | 0.00102688 | 7.97431 | 8.06098
6 x Angle | +5.173 | +5.962 | 6.2 | 970.4 | A21 | 970.446 | 0.264227 | 0.000780238 | 0.000788719 | 6.12487 | 6.19144

# IfcPlate: PLT12*209.3 (4)
In: Undefined
Description: PLT12*209.3; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 10.5 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 22.9 m2; Net surface area: 0.2 m2; Height: 209.3 mm; Width: 12 mm; Length: 533.1 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PA1
BaseQuantities - Width: 209.3 mm; NetArea: 0.240973 m2; GrossArea: 0.111578 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00133893 m3; GrossVolume: 0.00133893 m3
Name | Bottom elevation | Top elevation
2 x Plate | -0.012 | -0.000
2 x Plate | +7.066 | +7.078

# IfcPlate: PLT20*6000 (3)
In: Undefined
Description: PLT20*6000; Material: STEEL/S355JR
Tekla Common - Bottom elevation: -0.000; Top elevation: +7.066; Phase: 1; Class: 1
Tekla Quantity - Weight: 1655.7 kg; Volume: 0.2 m3; Gross footprint area: 0.1 m2; Area per tons: 13.6 m2; Net surface area: 22.6 m2; Height: 6000 mm; Width: 20 mm; Length: 7066.2 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PA3
BaseQuantities - Width: 6000 mm; NetArea: 22.5618 m2; GrossArea: 42.3972 m2; CrossSectionArea: 0.0004 m2; NetVolume: 0.210921 m3; GrossVolume: 0.341324 m3

# IfcPlate: PLT8*2264.2 (3)
In: Undefined
Description: PLT8*2264.2; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 6
Tekla Quantity - Weight: 681.2 kg; Volume: 0.1 m3; Gross footprint area: 10.8 m2; Area per tons: 32 m2; Net surface area: 21.8 m2; Height: 2264.2 mm; Width: 8 mm; Length: 4790.7 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PA2
BaseQuantities - Width: 2264.17 mm; NetArea: 21.8068 m2; GrossArea: 10.847 m2; CrossSectionArea: 0.000064 m2; NetVolume: 0.0867757 m3; GrossVolume: 0.0867757 m3
Name | Bottom elevation | Top elevation
Plate | -0.000 | +0.008
Plate | +0.517 | +0.525
Plate | +7.058 | +7.066
